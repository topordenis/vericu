			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A72
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_ena_lih_trtm
			"Vbx_ena_lih_trtm"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6D2B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_ena_nom_trtm
			"Vbx_ena_nom_trtm"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6D2C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_ena_ovt
			"Vbx_ena_ovt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF82FD
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_ena_pinj
			"Vbx_ena_pinj"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7BA3
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_enab_svkl_oc_diag
			"Vbx_enab_svkl_oc_diag"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7660
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_eng_gear_no_cple
			"Vbx_eng_gear_no_cple"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF819E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_eng_off_mdf1_on
			"Vbx_eng_off_mdf1_on"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF791F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_eng_stal
			"Vbx_eng_stal"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7F24
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_eng_tq_loss_ad_dsb
			"Vbx_eng_tq_loss_ad_dsb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7BD5
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_ev_iae_lk_stt
			"Vbx_ev_iae_lk_stt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8496
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_ex_gaz_cata_obd_ena
			"Vbx_ex_gaz_cata_obd_ena"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D13
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_fail_dft_ini_req
			"Vbx_fail_dft_ini_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF75C4
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_fast_slop
			"Vbx_fast_slop"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A73
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_fault_crk_nr
			"Vbx_fault_crk_nr"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7F25
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_fct_off_mem
			"Vbx_fct_off_mem"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF88C8
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_fl
			"Vbx_fl"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF82FE
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_fl_cdn
			"Vbx_fl_cdn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A74
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_fl_ena
			"Vbx_fl_ena"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A75
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_frst_inj
			"Vbx_frst_inj"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF80D8
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_fsys_diag_ctr
			"Vbx_fsys_diag_ctr"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D14
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_fsys_diag_done
			"Vbx_fsys_diag_done"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D15
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_fsys_diag_done_lpg
			"Vbx_fsys_diag_done_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D16
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_fsys_req
			"Vbx_fsys_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D17
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_gas_pump_rly_cmd
			"Vbx_gas_pump_rly_cmd"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF814A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_gas_wup_run
			"Vbx_gas_wup_run"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6D5F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_gear_cge
			"Vbx_gear_cge"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF78B7
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_gear_cge_1
			"Vbx_gear_cge_1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF80C8
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_gear_cge_eal_thd_cdn_16ms
			"Vbx_gear_cge_eal_thd_cdn_16ms"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF78B8
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_gear_cge_eal_thd_cdn_8ms
			"Vbx_gear_cge_eal_thd_cdn_8ms"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF78B9
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_gear_cge_fast_lim
			"Vbx_gear_cge_fast_lim"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF78BA
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_gear_cge_fast_lim_prec
			"Vbx_gear_cge_fast_lim_prec"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF78BB
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_gear_cge_l_tq
			"Vbx_gear_cge_l_tq"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF78BC
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_gear_cge_l_tq_prec
			"Vbx_gear_cge_l_tq_prec"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF78BD
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_gear_cge_prec
			"Vbx_gear_cge_prec"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF78BE
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_gear_lih
			"Vbx_gear_lih"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF819F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_gear_neut_psn
			"Vbx_gear_neut_psn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF81A0
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_gear_rvr
			"Vbx_gear_rvr"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF81A1
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_gear_rvr_psn
			"Vbx_gear_rvr_psn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF81A2
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_gear_vs_thd_cdn
			"Vbx_gear_vs_thd_cdn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF78BF
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_h_prs_ac_dsb
			"Vbx_h_prs_ac_dsb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF744A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_h_thr
			"Vbx_h_thr"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF82FF
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_iga_re_syn_req
			"Vbx_iga_re_syn_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6BC2
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_igk
			"Vbx_igk"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7BE4
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_igk_off_igk_on
			"Vbx_igk_off_igk_on"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7BE5
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_igk_on_igk_off
			"Vbx_igk_on_igk_off"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7BE6
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_igk_stal
			"Vbx_igk_stal"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF78DA
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_in_crk_lvl
			"Vbx_in_crk_lvl"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6BC3
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_ini_ok
			"Vbx_ini_ok"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF75C5
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_ini_prs_acq
			"Vbx_ini_prs_acq"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8051
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_inj1_cut
			"Vbx_inj1_cut"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A78
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_inj1_cut_req
			"Vbx_inj1_cut_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A79
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_inj1_dft
			"Vbx_inj1_dft"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7846
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_inj2_cut
			"Vbx_inj2_cut"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A7A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_inj2_cut_req
			"Vbx_inj2_cut_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A7B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_inj2_dft
			"Vbx_inj2_dft"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7847
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_inj3_cut
			"Vbx_inj3_cut"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A7C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_inj3_cut_req
			"Vbx_inj3_cut_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A7D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_inj3_dft
			"Vbx_inj3_dft"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7848
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_inj4_cut
			"Vbx_inj4_cut"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A7E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_inj4_cut_req
			"Vbx_inj4_cut_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A7F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_inj4_dft
			"Vbx_inj4_dft"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7849
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_inj_1_4_cut_req
			"Vbx_inj_1_4_cut_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E04
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_inj_2_3_cut_req
			"Vbx_inj_2_3_cut_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E05
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_inj_aut1
			"Vbx_inj_aut1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6D82
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_inj_dstb_act
			"Vbx_inj_dstb_act"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6BC4
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_inj_dstb_phs1
			"Vbx_inj_dstb_phs1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6BC5
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_inj_dstb_phs2
			"Vbx_inj_dstb_phs2"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6BC6
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_inj_ena
			"Vbx_inj_ena"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A76
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_inj_re_phs_req
			"Vbx_inj_re_phs_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6BC7
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_inj_seq_stt
			"Vbx_inj_seq_stt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A77
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_inj_stop_tco_det
			"Vbx_inj_stop_tco_det"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF80E4
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_inj_swi1
			"Vbx_inj_swi1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6D83
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_int_agb_tq_max
			"Vbx_int_agb_tq_max"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E92
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_ip_lk_stt
			"Vbx_ip_lk_stt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E93
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_is_act_mdf1
			"Vbx_is_act_mdf1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7920
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_is_act_mdf1_i_1
			"Vbx_is_act_mdf1_i_1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF79B9
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_is_act_mdf2
			"Vbx_is_act_mdf2"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7921
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_is_act_mdf2_i_1
			"Vbx_is_act_mdf2_i_1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF79BA
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_is_ad_cdn
			"Vbx_is_ad_cdn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF79BB
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_is_dft_ini_req
			"Vbx_is_dft_ini_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF75C6
		/end MEASUREMENT
		/begin MEASUREMENT VBX_IS_DYN_IGA
			"VBX_IS_DYN_IGA"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x4
			ECU_ADDRESS 0xFFFF6D9B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_is_hot_dly
			"Vbx_is_hot_dly"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A80
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_is_i_zon_out
			"Vbx_is_i_zon_out"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF79BC
		/end MEASUREMENT
		/begin MEASUREMENT VBX_IS_IGA_STT
			"VBX_IS_IGA_STT"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x2
			ECU_ADDRESS 0xFFFF6DA4
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_kd_pdl
			"Vbx_kd_pdl"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7FB9
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_kd_pdl_0
			"Vbx_kd_pdl_0"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7FBA
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_kd_thr
			"Vbx_kd_thr"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7FBB
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_knk_2_cyl_min
			"Vbx_knk_2_cyl_min"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6D84
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_knk_det_ena
			"Vbx_knk_det_ena"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7474
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_knk_zon
			"Vbx_knk_zon"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7475
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_l_is_pwm
			"Vbx_l_is_pwm"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF79BD
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_l_min_iga
			"Vbx_l_min_iga"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A19
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_l_min_iga_ctr_thd
			"Vbx_l_min_iga_ctr_thd"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A1A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_l_n_igk_cut
			"Vbx_l_n_igk_cut"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF78DB
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_l_prs_ac_dsb
			"Vbx_l_prs_ac_dsb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF744B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lbdw_det_dft_done
			"Vbx_lbdw_det_dft_done"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7E9C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lbdw_det_oc_done
			"Vbx_lbdw_det_oc_done"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7E9D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lbdw_det_scg_done
			"Vbx_lbdw_det_scg_done"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7E9E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lbdw_diag_ena
			"Vbx_lbdw_diag_ena"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7E9F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lbdw_hot_cmd
			"Vbx_lbdw_hot_cmd"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7EA0
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lbdw_pump_crt_act
			"Vbx_lbdw_pump_crt_act"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7EA1
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lbup_det_dft_done
			"Vbx_lbup_det_dft_done"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7EA2
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lbup_det_oc_done
			"Vbx_lbup_det_oc_done"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7EA3
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lbup_det_scg_done
			"Vbx_lbup_det_scg_done"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7EA4
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lbup_diag_stop
			"Vbx_lbup_diag_stop"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D1C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lbup_dly_swi_req
			"Vbx_lbup_dly_swi_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D1D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lbup_down_stt
			"Vbx_lbup_down_stt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7EA5
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lbup_efv_stt
			"Vbx_lbup_efv_stt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7EA6
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lbup_fail_trs
			"Vbx_lbup_fail_trs"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7EA7
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lbup_hot_cmd
			"Vbx_lbup_hot_cmd"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7EA8
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lbup_lean_rich_trs
			"Vbx_lbup_lean_rich_trs"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7EA9
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lbup_mes
			"Vbx_lbup_mes"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D1E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lbup_per_dly_acq_max
			"Vbx_lbup_per_dly_acq_max"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D1F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lbup_prev_stt
			"Vbx_lbup_prev_stt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7EAA
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lbup_pump_crt_act
			"Vbx_lbup_pump_crt_act"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7EAB
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lbup_req
			"Vbx_lbup_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D20
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lbup_stt
			"Vbx_lbup_stt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7EAC
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lbup_sw_stt
			"Vbx_lbup_sw_stt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7EAD
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lbup_trs
			"Vbx_lbup_trs"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7EAE
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lbup_up_stt
			"Vbx_lbup_up_stt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7EAF
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lih_gear
			"Vbx_lih_gear"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E94
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lih_inj1_cut_req
			"Vbx_lih_inj1_cut_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A81
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lih_inj2_cut_req
			"Vbx_lih_inj2_cut_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A82
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lih_inj3_cut_req
			"Vbx_lih_inj3_cut_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A83
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lih_inj4_cut_req
			"Vbx_lih_inj4_cut_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A84
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lpg_ad_cdn
			"Vbx_lpg_ad_cdn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7935
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lpg_avl
			"Vbx_lpg_avl"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7936
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lpg_cdn
			"Vbx_lpg_cdn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7937
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lpg_cl_lean_cdn
			"Vbx_lpg_cl_lean_cdn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7938
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lpg_conf
			"Vbx_lpg_conf"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E95
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lpg_cyl1_cut
			"Vbx_lpg_cyl1_cut"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7939
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lpg_cyl2_cut
			"Vbx_lpg_cyl2_cut"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF793A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lpg_cyl3_cut
			"Vbx_lpg_cyl3_cut"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF793B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lpg_cyl4_cut
			"Vbx_lpg_cyl4_cut"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF793C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lpg_decl_cdn
			"Vbx_lpg_decl_cdn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF793D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lpg_decl_cut
			"Vbx_lpg_decl_cut"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF793E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lpg_decl_cyl1_cut
			"Vbx_lpg_decl_cyl1_cut"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF793F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lpg_decl_cyl2_cut
			"Vbx_lpg_decl_cyl2_cut"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7940
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lpg_decl_cyl3_cut
			"Vbx_lpg_decl_cyl3_cut"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7941
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lpg_decl_cyl4_cut
			"Vbx_lpg_decl_cyl4_cut"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7942
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lpg_dft
			"Vbx_lpg_dft"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7943
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lpg_driv_req
			"Vbx_lpg_driv_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7944
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lpg_fl_lean_cdn
			"Vbx_lpg_fl_lean_cdn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7945
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lpg_gas_lih_lpg_dft
			"Vbx_lpg_gas_lih_lpg_dft"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7946
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lpg_gas_lpg_cdn
			"Vbx_lpg_gas_lpg_cdn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7947
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lpg_gas_lpg_trs
			"Vbx_lpg_gas_lpg_trs"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7948
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lpg_gas_lpg_trs_ok
			"Vbx_lpg_gas_lpg_trs_ok"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7949
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lpg_gas_mod
			"Vbx_lpg_gas_mod"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF794A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lpg_gas_pump
			"Vbx_lpg_gas_pump"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF794B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lpg_gas_pump_cut_ena
			"Vbx_lpg_gas_pump_cut_ena"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF794C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lpg_inj_ena
			"Vbx_lpg_inj_ena"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF794D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lpg_l_prs_cdn
			"Vbx_lpg_l_prs_cdn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF794E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lpg_lbup_cl_lean_diag
			"Vbx_lpg_lbup_cl_lean_diag"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF794F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lpg_lbup_fl_lean_diag
			"Vbx_lpg_lbup_fl_lean_diag"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7950
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lpg_lih_req
			"Vbx_lpg_lih_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7951
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lpg_lih_req_state
			"Vbx_lpg_lih_req_state"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7952
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lpg_lk_stt
			"Vbx_lpg_lk_stt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF75C7
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lpg_lpg_gas_cdn
			"Vbx_lpg_lpg_gas_cdn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7953
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lpg_lpg_gas_trs
			"Vbx_lpg_lpg_gas_trs"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7954
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lpg_lpg_gas_trs_ok
			"Vbx_lpg_lpg_gas_trs_ok"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7955
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lpg_lpg_mem_mod
			"Vbx_lpg_lpg_mem_mod"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8920
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lpg_lpg_mod
			"Vbx_lpg_lpg_mod"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7956
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lpg_mil_req
			"Vbx_lpg_mil_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF73F5
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lpg_min_lpg_diag
			"Vbx_lpg_min_lpg_diag"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7957
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lpg_min_lpg_lvl
			"Vbx_lpg_min_lpg_lvl"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7958
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lpg_min_ti_fac_diag
			"Vbx_lpg_min_ti_fac_diag"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7959
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lpg_rich_cl_cdn
			"Vbx_lpg_rich_cl_cdn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A85
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lpg_sta
			"Vbx_lpg_sta"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF795A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lpg_sta_cdn
			"Vbx_lpg_sta_cdn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF795B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lpg_stab_cdn
			"Vbx_lpg_stab_cdn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF795C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lpg_stall_dft_diag
			"Vbx_lpg_stall_dft_diag"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF795D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lpg_trs_dsb
			"Vbx_lpg_trs_dsb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF795E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lpg_wup_cdn
			"Vbx_lpg_wup_cdn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF795F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lpg_wup_ok
			"Vbx_lpg_wup_ok"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7960
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lpg_wup_run
			"Vbx_lpg_wup_run"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6D60
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lpg_zon_1_ad_cdn
			"Vbx_lpg_zon_1_ad_cdn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7961
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lpg_zon_2_ad_cdn
			"Vbx_lpg_zon_2_ad_cdn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7962
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lpg_zon_3_ad_cdn
			"Vbx_lpg_zon_3_ad_cdn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7963
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lpg_zon_4_ad_cdn
			"Vbx_lpg_zon_4_ad_cdn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7964
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lpg_zon_5_ad_cdn
			"Vbx_lpg_zon_5_ad_cdn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7965
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_lsm_dft_ini_req
			"Vbx_lsm_dft_ini_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF75C8
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_max_ecu_pws
			"Vbx_max_ecu_pws"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF814B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_max_ti
			"Vbx_max_ti"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A86
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mdf1_cmd
			"Vbx_mdf1_cmd"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7923
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mdf1_cmd_mem
			"Vbx_mdf1_cmd_mem"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6BC8
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mdf1_lk_stt
			"Vbx_mdf1_lk_stt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7924
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mdf2_cmd
			"Vbx_mdf2_cmd"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7925
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mdf2_cmd_mem
			"Vbx_mdf2_cmd_mem"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6BC9
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mdf2_lk_stt
			"Vbx_mdf2_lk_stt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7926
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mdf_pws
			"Vbx_mdf_pws"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7922
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mdl_cp_load_dsb
			"Vbx_mdl_cp_load_dsb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7BD6
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mem_run_eng
			"Vbx_mem_run_eng"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF78DC
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mem_sta_gas_pump
			"Vbx_mem_sta_gas_pump"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF814C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mem_swlk
			"Vbx_mem_swlk"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF78DD
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_ac_prs
			"Vbx_mf_ac_prs"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF694C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_ac_rcpt
			"Vbx_mf_ac_rcpt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF694D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_acr
			"Vbx_mf_acr"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A1F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_acr_oc
			"Vbx_mf_acr_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF694E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_acr_scg
			"Vbx_mf_acr_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF694F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_acr_vb_sc
			"Vbx_mf_acr_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6950
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_actr_rly
			"Vbx_mf_actr_rly"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6951
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_actr_rly_cut
			"Vbx_mf_actr_rly_cut"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6952
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_agb
			"Vbx_mf_agb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A22
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_agb_conv_stt
			"Vbx_mf_agb_conv_stt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6953
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_agb_gear
			"Vbx_mf_agb_gear"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6954
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_agb_rcpt
			"Vbx_mf_agb_rcpt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6955
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_agb_tq_nok
			"Vbx_mf_agb_tq_nok"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6956
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_air
			"Vbx_mf_air"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6957
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_alt
			"Vbx_mf_alt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A24
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_alt_ecu
			"Vbx_mf_alt_ecu"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6958
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_alt_load_in
			"Vbx_mf_alt_load_in"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF695A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_alt_mux
			"Vbx_mf_alt_mux"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6959
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_bkup_mem
			"Vbx_mf_bkup_mem"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF695B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_checksum
			"Vbx_mf_checksum"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF695C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_clu
			"Vbx_mf_clu"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF695D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_cp
			"Vbx_mf_cp"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A29
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_cp_oc
			"Vbx_mf_cp_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF695E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_cp_scg
			"Vbx_mf_cp_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF695F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_cp_vb_sc
			"Vbx_mf_cp_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6960
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_crk
			"Vbx_mf_crk"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6961
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_crk_nr
			"Vbx_mf_crk_nr"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6962
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_cru
			"Vbx_mf_cru"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A2C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_cru_brk_cnt1
			"Vbx_mf_cru_brk_cnt1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6963
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_cru_brk_cnt2
			"Vbx_mf_cru_brk_cnt2"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6964
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_cru_on_off_chr
			"Vbx_mf_cru_on_off_chr"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6965
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_cru_whl_cmd
			"Vbx_mf_cru_whl_cmd"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6966
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_el_wind_rcpt
			"Vbx_mf_el_wind_rcpt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6967
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_eng_temp
			"Vbx_mf_eng_temp"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A2E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_eng_temp_oc
			"Vbx_mf_eng_temp_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6968
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_eng_temp_scg
			"Vbx_mf_eng_temp_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6969
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_eng_temp_vb_sc
			"Vbx_mf_eng_temp_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF696A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_eng_whl
			"Vbx_mf_eng_whl"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF696B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_fsys
			"Vbx_mf_fsys"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF696C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_fsys_lpg
			"Vbx_mf_fsys_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF696D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_gas_pump
			"Vbx_mf_gas_pump"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A32
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_gas_pump_oc
			"Vbx_mf_gas_pump_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF696E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_gas_pump_scg
			"Vbx_mf_gas_pump_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF696F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_gas_pump_vb_sc
			"Vbx_mf_gas_pump_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6970
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_igc_1
			"Vbx_mf_igc_1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A33
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_igc_1_oc
			"Vbx_mf_igc_1_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6971
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_igc_1_vb_sc
			"Vbx_mf_igc_1_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6972
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_igc_2
			"Vbx_mf_igc_2"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A34
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_igc_2_oc
			"Vbx_mf_igc_2_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6973
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_igc_2_vb_sc
			"Vbx_mf_igc_2_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6974
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_igc_3
			"Vbx_mf_igc_3"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A35
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_igc_3_oc
			"Vbx_mf_igc_3_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6975
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_igc_3_vb_sc
			"Vbx_mf_igc_3_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6976
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_igc_4
			"Vbx_mf_igc_4"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A36
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_igc_4_oc
			"Vbx_mf_igc_4_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6977
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_igc_4_vb_sc
			"Vbx_mf_igc_4_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6978
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_inj1
			"Vbx_mf_inj1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A37
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_inj1_oc
			"Vbx_mf_inj1_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6979
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_inj1_scg
			"Vbx_mf_inj1_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF697A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_inj1_vb_sc
			"Vbx_mf_inj1_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF697B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_inj2
			"Vbx_mf_inj2"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A38
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_inj2_oc
			"Vbx_mf_inj2_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF697C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_inj2_scg
			"Vbx_mf_inj2_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF697D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_inj2_vb_sc
			"Vbx_mf_inj2_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF697E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_inj3
			"Vbx_mf_inj3"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A39
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_inj3_oc
			"Vbx_mf_inj3_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF697F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_inj3_scg
			"Vbx_mf_inj3_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6980
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_inj3_vb_sc
			"Vbx_mf_inj3_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6981
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_inj4
			"Vbx_mf_inj4"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A3A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_inj4_oc
			"Vbx_mf_inj4_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6982
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_inj4_scg
			"Vbx_mf_inj4_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6983
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_inj4_vb_sc
			"Vbx_mf_inj4_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6984
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_inj_ecu
			"Vbx_mf_inj_ecu"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6985
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_ip_inj_cnt
			"Vbx_mf_ip_inj_cnt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6986
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_knk
			"Vbx_mf_knk"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6987
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_lbdw
			"Vbx_mf_lbdw"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A3E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_lbdw_hot
			"Vbx_mf_lbdw_hot"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A3F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_lbdw_hot_oc
			"Vbx_mf_lbdw_hot_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF698B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_lbdw_hot_scg
			"Vbx_mf_lbdw_hot_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF698C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_lbdw_hot_vb_sc
			"Vbx_mf_lbdw_hot_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF698D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_lbdw_oc
			"Vbx_mf_lbdw_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6988
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_lbdw_pump_crt
			"Vbx_mf_lbdw_pump_crt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF698E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_lbdw_scg
			"Vbx_mf_lbdw_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6989
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_lbdw_vb_sc
			"Vbx_mf_lbdw_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF698A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_lbup
			"Vbx_mf_lbup"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A41
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_lbup_hot
			"Vbx_mf_lbup_hot"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A42
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_lbup_hot_oc
			"Vbx_mf_lbup_hot_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6992
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_lbup_hot_scg
			"Vbx_mf_lbup_hot_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6993
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_lbup_hot_vb_sc
			"Vbx_mf_lbup_hot_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6994
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_lbup_oc
			"Vbx_mf_lbup_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF698F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_lbup_pump_crt
			"Vbx_mf_lbup_pump_crt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6995
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_lbup_scg
			"Vbx_mf_lbup_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6990
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_lbup_vb_sc
			"Vbx_mf_lbup_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6991
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_lpg_rcpt
			"Vbx_mf_lpg_rcpt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6996
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_map
			"Vbx_mf_map"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6997
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_map_chr
			"Vbx_mf_map_chr"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6998
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_mastervac
			"Vbx_mf_mastervac"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A47
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_mastervac_cc
			"Vbx_mf_mastervac_cc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6999
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_mastervac_oc
			"Vbx_mf_mastervac_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF699A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_mcut_sens1
			"Vbx_mf_mcut_sens1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF699B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_mdf1
			"Vbx_mf_mdf1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A49
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_mdf1_oc
			"Vbx_mf_mdf1_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF699C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_mdf1_scg
			"Vbx_mf_mdf1_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF699D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_mdf1_vb_sc
			"Vbx_mf_mdf1_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF699E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_mdf2
			"Vbx_mf_mdf2"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A4A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_mdf2_oc
			"Vbx_mf_mdf2_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF699F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_mdf2_scg
			"Vbx_mf_mdf2_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69A0
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_mdf2_vb_sc
			"Vbx_mf_mdf2_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69A1
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_min_gas_lvl
			"Vbx_mf_min_gas_lvl"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69A2
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_min_lpg_lvl
			"Vbx_mf_min_lpg_lvl"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69A3
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_mis_cata
			"Vbx_mf_mis_cata"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69A4
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_mis_cata_1
			"Vbx_mf_mis_cata_1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69A5
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_mis_cata_1_lpg
			"Vbx_mf_mis_cata_1_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69A6
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_mis_cata_2
			"Vbx_mf_mis_cata_2"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69A7
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_mis_cata_2_lpg
			"Vbx_mf_mis_cata_2_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69A8
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_mis_cata_3
			"Vbx_mf_mis_cata_3"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69A9
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_mis_cata_3_lpg
			"Vbx_mf_mis_cata_3_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69AA
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_mis_cata_4
			"Vbx_mf_mis_cata_4"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69AB
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_mis_cata_4_lpg
			"Vbx_mf_mis_cata_4_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69AC
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_mis_cata_gas
			"Vbx_mf_mis_cata_gas"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69AD
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_mis_cata_lpg
			"Vbx_mf_mis_cata_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69AE
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_mis_fast
			"Vbx_mf_mis_fast"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69AF
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_mis_lih
			"Vbx_mf_mis_lih"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69B0
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_mis_polu
			"Vbx_mf_mis_polu"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69B1
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_mis_polu_1
			"Vbx_mf_mis_polu_1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69B2
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_mis_polu_1_lpg
			"Vbx_mf_mis_polu_1_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69B3
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_mis_polu_2
			"Vbx_mf_mis_polu_2"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69B4
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_mis_polu_2_lpg
			"Vbx_mf_mis_polu_2_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69B5
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_mis_polu_3
			"Vbx_mf_mis_polu_3"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69B6
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_mis_polu_3_lpg
			"Vbx_mf_mis_polu_3_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69B7
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_mis_polu_4
			"Vbx_mf_mis_polu_4"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69B8
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_mis_polu_4_lpg
			"Vbx_mf_mis_polu_4_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69B9
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_mis_polu_gas
			"Vbx_mf_mis_polu_gas"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69BA
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_mis_polu_lpg
			"Vbx_mf_mis_polu_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69BB
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_mvac_pump
			"Vbx_mf_mvac_pump"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A65
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_mvac_pump_oc
			"Vbx_mf_mvac_pump_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69BC
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_mvac_pump_scg
			"Vbx_mf_mvac_pump_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69BD
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_mvac_pump_vb_sc
			"Vbx_mf_mvac_pump_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69BE
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_mvac_sys
			"Vbx_mf_mvac_sys"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69BF
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_obd_cata
			"Vbx_mf_obd_cata"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69C0
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_obd_lamb
			"Vbx_mf_obd_lamb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69C1
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_obd_sa
			"Vbx_mf_obd_sa"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69C2
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_oil
			"Vbx_mf_oil"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A6A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_oil_cc
			"Vbx_mf_oil_cc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69C3
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_oil_co
			"Vbx_mf_oil_co"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69C4
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_pdl
			"Vbx_mf_pdl"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A6B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_pdl_sens1_oc
			"Vbx_mf_pdl_sens1_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69C5
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_pdl_sens1_vb_sc
			"Vbx_mf_pdl_sens1_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69C6
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_pdl_sens2_oc
			"Vbx_mf_pdl_sens2_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69C7
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_pdl_sens2_vb_sc
			"Vbx_mf_pdl_sens2_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69C8
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_pdl_sens_chr
			"Vbx_mf_pdl_sens_chr"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69C9
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_pmh
			"Vbx_mf_pmh"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A6C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_pmh_cc
			"Vbx_mf_pmh_cc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69CA
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_pmh_co
			"Vbx_mf_pmh_co"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69CB
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_pow_lbdw
			"Vbx_mf_pow_lbdw"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69CC
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_pow_lbup
			"Vbx_mf_pow_lbup"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69CD
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_ptc
			"Vbx_mf_ptc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69CE
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_ptc_rov
			"Vbx_mf_ptc_rov"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A70
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_ptc_rov_oc
			"Vbx_mf_ptc_rov_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69CF
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_ptc_rov_scg
			"Vbx_mf_ptc_rov_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69D0
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_ptc_rov_vb_sc
			"Vbx_mf_ptc_rov_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69D1
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_pws
			"Vbx_mf_pws"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A71
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_pws_1
			"Vbx_mf_pws_1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69D2
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_pws_2
			"Vbx_mf_pws_2"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69D3
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_pws_pdl2
			"Vbx_mf_pws_pdl2"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69D4
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_pws_thr_pdl1
			"Vbx_mf_pws_thr_pdl1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69D5
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_rams
			"Vbx_mf_rams"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A72
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_rams_map_tq
			"Vbx_mf_rams_map_tq"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69D6
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_rams_pdl
			"Vbx_mf_rams_pdl"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69D9
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_rams_tq_ctl
			"Vbx_mf_rams_tq_ctl"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69D7
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_rams_tq_req
			"Vbx_mf_rams_tq_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69D8
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_reserve_3
			"Vbx_mf_reserve_3"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A74
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_reserve_3_oc
			"Vbx_mf_reserve_3_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69DA
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_reserve_3_scg
			"Vbx_mf_reserve_3_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69DB
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_reserve_3_vb_sc
			"Vbx_mf_reserve_3_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69DC
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_rmc
			"Vbx_mf_rmc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A75
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_rmc_algopp
			"Vbx_mf_rmc_algopp"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69DD
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_rmc_clockpp
			"Vbx_mf_rmc_clockpp"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69DE
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_rmc_comspipp
			"Vbx_mf_rmc_comspipp"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69DF
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_rmc_inhwp
			"Vbx_mf_rmc_inhwp"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69E0
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_rmc_monitpp
			"Vbx_mf_rmc_monitpp"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69E1
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_rmc_papmpp
			"Vbx_mf_rmc_papmpp"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69E2
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_rmc_pedmpp
			"Vbx_mf_rmc_pedmpp"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69E3
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_rmc_timeoutpp
			"Vbx_mf_rmc_timeoutpp"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69E4
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_sa
			"Vbx_mf_sa"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A76
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_sa_ev
			"Vbx_mf_sa_ev"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A77
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_sa_ev_oc
			"Vbx_mf_sa_ev_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69E8
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_sa_ev_scg
			"Vbx_mf_sa_ev_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69E9
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_sa_ev_vb_sc
			"Vbx_mf_sa_ev_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69EA
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_sa_oc
			"Vbx_mf_sa_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69E5
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_sa_scg
			"Vbx_mf_sa_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69E6
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_sa_vb_sc
			"Vbx_mf_sa_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69E7
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_spg
			"Vbx_mf_spg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69EB
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_spg_sys
			"Vbx_mf_spg_sys"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69EC
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_spi_cc
			"Vbx_mf_spi_cc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69ED
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_svkl
			"Vbx_mf_svkl"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A7B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_svkl_chk_springs
			"Vbx_mf_svkl_chk_springs"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69EE
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_svkl_lih
			"Vbx_mf_svkl_lih"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69EF
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_svkl_oc
			"Vbx_mf_svkl_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69F0
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_svkl_psn
			"Vbx_mf_svkl_psn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69F1
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_svkl_sge
			"Vbx_mf_svkl_sge"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69F2
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_svkl_trt_srch
			"Vbx_mf_svkl_trt_srch"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69F3
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_swlk
			"Vbx_mf_swlk"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A7C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_swlk_mem
			"Vbx_mf_swlk_mem"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69F4
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_tco
			"Vbx_mf_tco"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A7D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_tco_acq
			"Vbx_mf_tco_acq"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69F5
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_tco_chr
			"Vbx_mf_tco_chr"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69F6
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_thpl
			"Vbx_mf_thpl"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A7E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_thpl_oc
			"Vbx_mf_thpl_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69F7
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_thpl_scg
			"Vbx_mf_thpl_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69F8
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_thpl_vb_sc
			"Vbx_mf_thpl_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69F9
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_thr
			"Vbx_mf_thr"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A7F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_thr_cmd
			"Vbx_mf_thr_cmd"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A80
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_thr_cmd_cpt
			"Vbx_mf_thr_cmd_cpt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69FF
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_thr_cmd_vb_sc
			"Vbx_mf_thr_cmd_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A00
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_thr_sens1_oc
			"Vbx_mf_thr_sens1_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69FA
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_thr_sens1_vb_sc
			"Vbx_mf_thr_sens1_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69FB
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_thr_sens2_scg
			"Vbx_mf_thr_sens2_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69FC
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_thr_sens2_vb_sc
			"Vbx_mf_thr_sens2_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69FD
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_thr_sens_chr
			"Vbx_mf_thr_sens_chr"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF69FE
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_tia
			"Vbx_mf_tia"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A81
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_tia_high
			"Vbx_mf_tia_high"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A01
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_tia_low
			"Vbx_mf_tia_low"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A02
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_tjy_ctl
			"Vbx_mf_tjy_ctl"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A03
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_tlz_ad_b
			"Vbx_mf_tlz_ad_b"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A04
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_vb
			"Vbx_mf_vb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A84
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_vb_high
			"Vbx_mf_vb_high"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A05
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_vb_low
			"Vbx_mf_vb_low"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A06
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_vs
			"Vbx_mf_vs"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A85
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_vs_eal
			"Vbx_mf_vs_eal"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A07
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_vs_mux
			"Vbx_mf_vs_mux"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A08
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_vs_parasite
			"Vbx_mf_vs_parasite"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A09
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_vta_intake
			"Vbx_mf_vta_intake"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A86
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_vta_intake_pmh
			"Vbx_mf_vta_intake_pmh"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A0A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_vta_intake_shift
			"Vbx_mf_vta_intake_shift"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A0B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_vvt_int
			"Vbx_mf_vvt_int"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A87
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_vvt_int_ev
			"Vbx_mf_vvt_int_ev"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A88
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_vvt_int_ev_oc
			"Vbx_mf_vvt_int_ev_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A0D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_vvt_int_ev_scg
			"Vbx_mf_vvt_int_ev_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A0E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_vvt_int_ev_vb_sc
			"Vbx_mf_vvt_int_ev_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A0F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_vvt_int_old_off
			"Vbx_mf_vvt_int_old_off"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A0C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_vvt_intake
			"Vbx_mf_vvt_intake"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A89
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_vvt_intake_blk
			"Vbx_mf_vvt_intake_blk"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A10
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_vvt_intake_bound
			"Vbx_mf_vvt_intake_bound"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A11
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_vvt_intake_dyn
			"Vbx_mf_vvt_intake_dyn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A12
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_vvt_intake_int
			"Vbx_mf_vvt_intake_int"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A13
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_vvtc_toth_3
			"Vbx_mf_vvtc_toth_3"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A14
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_wat_temp
			"Vbx_mf_wat_temp"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A8B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_wat_temp_high
			"Vbx_mf_wat_temp_high"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A15
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_wat_temp_low
			"Vbx_mf_wat_temp_low"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A16
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_wgc
			"Vbx_mf_wgc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A8C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_wgc_oc
			"Vbx_mf_wgc_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A17
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_wgc_scg
			"Vbx_mf_wgc_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A18
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_wgc_vb_sc
			"Vbx_mf_wgc_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A19
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_wpmp
			"Vbx_mf_wpmp"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A8D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_wpmp_oc
			"Vbx_mf_wpmp_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A1A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_wpmp_scg
			"Vbx_mf_wpmp_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A1B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mf_wpmp_vb_sc
			"Vbx_mf_wpmp_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A1C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_agb_rcpt
			"Vbx_mfo_agb_rcpt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AD4
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_air
			"Vbx_mfo_air"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AD5
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_bkup_mem
			"Vbx_mfo_bkup_mem"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AD6
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_clu
			"Vbx_mfo_clu"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AD7
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_cp
			"Vbx_mfo_cp"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B03
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_crk
			"Vbx_mfo_crk"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AD8
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_crk_nr
			"Vbx_mfo_crk_nr"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AD9
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_eng_whl
			"Vbx_mfo_eng_whl"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6ADA
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_fsys
			"Vbx_mfo_fsys"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6ADB
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_fsys_lpg
			"Vbx_mfo_fsys_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6ADC
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_gas_pump
			"Vbx_mfo_gas_pump"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B04
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_igc_1
			"Vbx_mfo_igc_1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B05
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_igc_2
			"Vbx_mfo_igc_2"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B06
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_igc_3
			"Vbx_mfo_igc_3"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B07
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_igc_4
			"Vbx_mfo_igc_4"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B08
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_inj1
			"Vbx_mfo_inj1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B09
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_inj2
			"Vbx_mfo_inj2"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B0A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_inj3
			"Vbx_mfo_inj3"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B0B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_inj4
			"Vbx_mfo_inj4"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B0C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_inj_ecu
			"Vbx_mfo_inj_ecu"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6ADD
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_knk
			"Vbx_mfo_knk"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6ADE
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_lbdw
			"Vbx_mfo_lbdw"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B0D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_lbdw_hot
			"Vbx_mfo_lbdw_hot"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B0E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_lbup
			"Vbx_mfo_lbup"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B0F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_lbup_hot
			"Vbx_mfo_lbup_hot"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B10
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_lpg_rcpt
			"Vbx_mfo_lpg_rcpt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6ADF
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_map
			"Vbx_mfo_map"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AE0
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_min_gas_lvl
			"Vbx_mfo_min_gas_lvl"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AE1
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_mis_cata
			"Vbx_mfo_mis_cata"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AE2
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_mis_cata_1
			"Vbx_mfo_mis_cata_1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AE3
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_mis_cata_1_lpg
			"Vbx_mfo_mis_cata_1_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AE4
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_mis_cata_2
			"Vbx_mfo_mis_cata_2"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AE5
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_mis_cata_2_lpg
			"Vbx_mfo_mis_cata_2_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AE6
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_mis_cata_3
			"Vbx_mfo_mis_cata_3"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AE7
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_mis_cata_3_lpg
			"Vbx_mfo_mis_cata_3_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AE8
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_mis_cata_4
			"Vbx_mfo_mis_cata_4"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AE9
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_mis_cata_4_lpg
			"Vbx_mfo_mis_cata_4_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AEA
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_mis_cata_gas
			"Vbx_mfo_mis_cata_gas"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AEB
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_mis_cata_lpg
			"Vbx_mfo_mis_cata_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AEC
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_mis_polu
			"Vbx_mfo_mis_polu"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AED
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_mis_polu_1
			"Vbx_mfo_mis_polu_1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AEE
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_mis_polu_1_lpg
			"Vbx_mfo_mis_polu_1_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AEF
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_mis_polu_2
			"Vbx_mfo_mis_polu_2"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AF0
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_mis_polu_2_lpg
			"Vbx_mfo_mis_polu_2_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AF1
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_mis_polu_3
			"Vbx_mfo_mis_polu_3"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AF2
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_mis_polu_3_lpg
			"Vbx_mfo_mis_polu_3_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AF3
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_mis_polu_4
			"Vbx_mfo_mis_polu_4"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AF4
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_mis_polu_4_lpg
			"Vbx_mfo_mis_polu_4_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AF5
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_mis_polu_gas
			"Vbx_mfo_mis_polu_gas"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AF6
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_mis_polu_lpg
			"Vbx_mfo_mis_polu_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AF7
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_obd_cata
			"Vbx_mfo_obd_cata"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AF8
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_obd_lamb
			"Vbx_mfo_obd_lamb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AF9
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_obd_sa
			"Vbx_mfo_obd_sa"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AFA
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_pow_lbdw
			"Vbx_mfo_pow_lbdw"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AFB
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_pow_lbup
			"Vbx_mfo_pow_lbup"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AFC
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_rams_pdl
			"Vbx_mfo_rams_pdl"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AFD
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_sa
			"Vbx_mfo_sa"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B11
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_sa_ev
			"Vbx_mfo_sa_ev"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B12
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_spg
			"Vbx_mfo_spg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AFE
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_spg_sys
			"Vbx_mfo_spg_sys"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AFF
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_tco
			"Vbx_mfo_tco"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B13
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_tia
			"Vbx_mfo_tia"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B14
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_tlz_ad_b
			"Vbx_mfo_tlz_ad_b"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B00
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_vs
			"Vbx_mfo_vs"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B15
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_vta_intake
			"Vbx_mfo_vta_intake"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B16
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_vvt_int_ev
			"Vbx_mfo_vvt_int_ev"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B17
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_vvt_int_old_off
			"Vbx_mfo_vvt_int_old_off"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B01
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_vvt_intake
			"Vbx_mfo_vvt_intake"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B18
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_vvtc_toth_3
			"Vbx_mfo_vvtc_toth_3"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B02
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mfo_wgc
			"Vbx_mfo_wgc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B19
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mil_flsh_req
			"Vbx_mil_flsh_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7871
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mil_prmt_ecu_req
			"Vbx_mil_prmt_ecu_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7872
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mil_prmt_req
			"Vbx_mil_prmt_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7873
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_min_cp_ti
			"Vbx_min_cp_ti"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A87
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_min_ecu_pws
			"Vbx_min_ecu_pws"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF814D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_min_gas
			"Vbx_min_gas"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E96
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_min_gas_lvl
			"Vbx_min_gas_lvl"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E97
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_min_iga_dsb
			"Vbx_min_iga_dsb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A1B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_min_lpg_diag_lean_cdn
			"Vbx_min_lpg_diag_lean_cdn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7966
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_min_lpg_prs_diag
			"Vbx_min_lpg_prs_diag"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7967
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_min_ti
			"Vbx_min_ti"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A88
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_min_ti_cut
			"Vbx_min_ti_cut"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A89
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mis_cata_win_stop
			"Vbx_mis_cata_win_stop"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D21
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mis_cut
			"Vbx_mis_cut"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D22
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mis_cut_cyl_done
			"Vbx_mis_cut_cyl_done"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D23
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mis_cyl1
			"Vbx_mis_cyl1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D24
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mis_cyl1_fail
			"Vbx_mis_cyl1_fail"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D25
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mis_cyl1_lpg
			"Vbx_mis_cyl1_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D26
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mis_cyl2
			"Vbx_mis_cyl2"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D27
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mis_cyl2_fail
			"Vbx_mis_cyl2_fail"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D28
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mis_cyl2_lpg
			"Vbx_mis_cyl2_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D29
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mis_cyl3
			"Vbx_mis_cyl3"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D2A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mis_cyl3_fail
			"Vbx_mis_cyl3_fail"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D2B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mis_cyl3_lpg
			"Vbx_mis_cyl3_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D2C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mis_cyl4
			"Vbx_mis_cyl4"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D2D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mis_cyl4_fail
			"Vbx_mis_cyl4_fail"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D2E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mis_cyl4_lpg
			"Vbx_mis_cyl4_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D2F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mis_det
			"Vbx_mis_det"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D30
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mis_det_1_2
			"Vbx_mis_det_1_2"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D31
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mis_det_1_2_inh
			"Vbx_mis_det_1_2_inh"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D32
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mis_det_1_4
			"Vbx_mis_det_1_4"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D33
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mis_det_intm
			"Vbx_mis_det_intm"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D34
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mis_diag_done
			"Vbx_mis_diag_done"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D35
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mis_diag_done_lpg
			"Vbx_mis_diag_done_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D36
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mis_fil_rst_eal_dif
			"Vbx_mis_fil_rst_eal_dif"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D37
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mis_fil_rst_eal_dif1
			"Vbx_mis_fil_rst_eal_dif1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D38
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mis_fil_rst_eal_dif2
			"Vbx_mis_fil_rst_eal_dif2"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D39
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mis_fil_rst_n_dif
			"Vbx_mis_fil_rst_n_dif"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D3A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mis_fil_rst_n_dif1
			"Vbx_mis_fil_rst_n_dif1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D3B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mis_fil_rst_n_dif2
			"Vbx_mis_fil_rst_n_dif2"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D3C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mis_inj1_cut_req
			"Vbx_mis_inj1_cut_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D3E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mis_inj2_cut_req
			"Vbx_mis_inj2_cut_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D3F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mis_inj3_cut_req
			"Vbx_mis_inj3_cut_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D40
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mis_inj4_cut_req
			"Vbx_mis_inj4_cut_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D41
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mis_inj_re_phs_done
			"Vbx_mis_inj_re_phs_done"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6BCA
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mis_inj_re_phs_req
			"Vbx_mis_inj_re_phs_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D3D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mis_km_ena
			"Vbx_mis_km_ena"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D42
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mis_lih_chk_dsb
			"Vbx_mis_lih_chk_dsb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D43
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mis_lih_phs_chk
			"Vbx_mis_lih_phs_chk"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D44
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mis_lih_phs_chk_req
			"Vbx_mis_lih_phs_chk_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D45
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mis_lih_phs_ok
			"Vbx_mis_lih_phs_ok"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D46
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mis_obd_diag_stop
			"Vbx_mis_obd_diag_stop"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D47
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mis_req
			"Vbx_mis_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D48
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mis_stat_fil
			"Vbx_mis_stat_fil"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D49
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mis_stat_fil1
			"Vbx_mis_stat_fil1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D4A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mis_stat_fil2
			"Vbx_mis_stat_fil2"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D4B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mis_stat_fil3
			"Vbx_mis_stat_fil3"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D4C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mis_stat_fil4
			"Vbx_mis_stat_fil4"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D4D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mis_stop
			"Vbx_mis_stop"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D4E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mis_tlz_cor_ena
			"Vbx_mis_tlz_cor_ena"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D4F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mis_tlz_fil_rst
			"Vbx_mis_tlz_fil_rst"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D50
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_agb
			"Vbx_mreq_agb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E98
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_agb_rcpt
			"Vbx_mreq_agb_rcpt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B1A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_air
			"Vbx_mreq_air"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B1B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_bkup_mem
			"Vbx_mreq_bkup_mem"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B1C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_clu
			"Vbx_mreq_clu"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B1D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_cp
			"Vbx_mreq_cp"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B49
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_crk
			"Vbx_mreq_crk"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B1E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_crk_nr
			"Vbx_mreq_crk_nr"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B1F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_eng_whl
			"Vbx_mreq_eng_whl"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B20
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_fsys
			"Vbx_mreq_fsys"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B21
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_fsys_lpg
			"Vbx_mreq_fsys_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B22
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_gas_pump
			"Vbx_mreq_gas_pump"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B4A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_igc_1
			"Vbx_mreq_igc_1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B4B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_igc_2
			"Vbx_mreq_igc_2"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B4C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_igc_3
			"Vbx_mreq_igc_3"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B4D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_igc_4
			"Vbx_mreq_igc_4"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B4E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_inj1
			"Vbx_mreq_inj1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B4F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_inj2
			"Vbx_mreq_inj2"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B50
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_inj3
			"Vbx_mreq_inj3"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B51
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_inj4
			"Vbx_mreq_inj4"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B52
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_inj_ecu
			"Vbx_mreq_inj_ecu"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B23
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_knk
			"Vbx_mreq_knk"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B24
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_lbdw
			"Vbx_mreq_lbdw"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B53
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_lbdw_hot
			"Vbx_mreq_lbdw_hot"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B54
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_lbup
			"Vbx_mreq_lbup"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B55
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_lbup_hot
			"Vbx_mreq_lbup_hot"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B56
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_lpg
			"Vbx_mreq_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E99
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_lpg_rcpt
			"Vbx_mreq_lpg_rcpt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B25
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_map
			"Vbx_mreq_map"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B26
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_min_gas_lvl
			"Vbx_mreq_min_gas_lvl"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B27
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_mis_cata
			"Vbx_mreq_mis_cata"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B28
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_mis_cata_1
			"Vbx_mreq_mis_cata_1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B29
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_mis_cata_1_lpg
			"Vbx_mreq_mis_cata_1_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B2A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_mis_cata_2
			"Vbx_mreq_mis_cata_2"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B2B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_mis_cata_2_lpg
			"Vbx_mreq_mis_cata_2_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B2C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_mis_cata_3
			"Vbx_mreq_mis_cata_3"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B2D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_mis_cata_3_lpg
			"Vbx_mreq_mis_cata_3_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B2E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_mis_cata_4
			"Vbx_mreq_mis_cata_4"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B2F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_mis_cata_4_lpg
			"Vbx_mreq_mis_cata_4_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B30
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_mis_cata_gas
			"Vbx_mreq_mis_cata_gas"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B31
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_mis_cata_lpg
			"Vbx_mreq_mis_cata_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B32
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_mis_polu
			"Vbx_mreq_mis_polu"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B33
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_mis_polu_1
			"Vbx_mreq_mis_polu_1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B34
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_mis_polu_1_lpg
			"Vbx_mreq_mis_polu_1_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B35
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_mis_polu_2
			"Vbx_mreq_mis_polu_2"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B36
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_mis_polu_2_lpg
			"Vbx_mreq_mis_polu_2_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B37
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_mis_polu_3
			"Vbx_mreq_mis_polu_3"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B38
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_mis_polu_3_lpg
			"Vbx_mreq_mis_polu_3_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B39
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_mis_polu_4
			"Vbx_mreq_mis_polu_4"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B3A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_mis_polu_4_lpg
			"Vbx_mreq_mis_polu_4_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B3B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_mis_polu_gas
			"Vbx_mreq_mis_polu_gas"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B3C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_mis_polu_lpg
			"Vbx_mreq_mis_polu_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B3D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_obd_cata
			"Vbx_mreq_obd_cata"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B3E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_obd_lamb
			"Vbx_mreq_obd_lamb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B3F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_obd_sa
			"Vbx_mreq_obd_sa"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B40
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_pow_lbdw
			"Vbx_mreq_pow_lbdw"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B41
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_pow_lbup
			"Vbx_mreq_pow_lbup"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B42
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_rams_pdl
			"Vbx_mreq_rams_pdl"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B43
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_sa
			"Vbx_mreq_sa"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B57
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_sa_ev
			"Vbx_mreq_sa_ev"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B58
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_spg
			"Vbx_mreq_spg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B44
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_spg_sys
			"Vbx_mreq_spg_sys"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B45
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_tco
			"Vbx_mreq_tco"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B59
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_tia
			"Vbx_mreq_tia"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B5A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_tlz_ad_b
			"Vbx_mreq_tlz_ad_b"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B46
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_vs
			"Vbx_mreq_vs"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B5B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_vta_intake
			"Vbx_mreq_vta_intake"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B5C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_vvt_int_ev
			"Vbx_mreq_vvt_int_ev"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B5D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_vvt_int_old_off
			"Vbx_mreq_vvt_int_old_off"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B47
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_vvt_intake
			"Vbx_mreq_vvt_intake"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B5E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_vvtc_toth_3
			"Vbx_mreq_vvtc_toth_3"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B48
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mreq_wgc
			"Vbx_mreq_wgc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6B5F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_msr_cnd
			"Vbx_msr_cnd"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E9A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_msr_sp_vld
			"Vbx_msr_sp_vld"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E9B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mux_ac_acel_is_req
			"Vbx_mux_ac_acel_is_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E9C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mux_ac_acel_is_req_lk
			"Vbx_mux_ac_acel_is_req_lk"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF73E1
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mux_ac_el_bk_wind
			"Vbx_mux_ac_el_bk_wind"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF73E2
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mux_ac_el_wind
			"Vbx_mux_ac_el_wind"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF73E3
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mux_ac_mdf1_req
			"Vbx_mux_ac_mdf1_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E9D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mux_ac_mdf2_req
			"Vbx_mux_ac_mdf2_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E9E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mux_ac_req
			"Vbx_mux_ac_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E9F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mux_acc_clu_ena
			"Vbx_mux_acc_clu_ena"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF744C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mux_agb_acel_is_req
			"Vbx_mux_agb_acel_is_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF73CB
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mux_agb_mdf_req
			"Vbx_mux_agb_mdf_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF73CC
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mux_agb_rcpt
			"Vbx_mux_agb_rcpt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6EA0
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mux_asr_msr_cnd
			"Vbx_mux_asr_msr_cnd"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6EA1
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mux_cru_sl_warn
			"Vbx_mux_cru_sl_warn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF81A3
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mux_gear_cge
			"Vbx_mux_gear_cge"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF73CD
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mux_gear_rvr
			"Vbx_mux_gear_rvr"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7425
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mux_inj_dft_lght_req
			"Vbx_mux_inj_dft_lght_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6EA2
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mux_inj_stop_tco_det
			"Vbx_mux_inj_stop_tco_det"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6EA3
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mux_ip_dft_lght_tco
			"Vbx_mux_ip_dft_lght_tco"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6EA4
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mux_lpg_avl
			"Vbx_mux_lpg_avl"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF73F6
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mux_lpg_dft
			"Vbx_mux_lpg_dft"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF73F7
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mux_lpg_driv_req
			"Vbx_mux_lpg_driv_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF73F8
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mux_max_lpg_dft
			"Vbx_mux_max_lpg_dft"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF73F9
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mux_min_gas_lvl
			"Vbx_mux_min_gas_lvl"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7411
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mux_min_lpg_dft
			"Vbx_mux_min_lpg_dft"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF73FA
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mux_min_lpg_lvl
			"Vbx_mux_min_lpg_lvl"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7412
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mux_ptc_is_acel
			"Vbx_mux_ptc_is_acel"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7426
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mux_pwst_prs_stt_on
			"Vbx_mux_pwst_prs_stt_on"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF77B5
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mux_tq_req_dsb
			"Vbx_mux_tq_req_dsb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6EA5
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mvac_acq_fil
			"Vbx_mvac_acq_fil"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF78EF
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mvac_brk_nok
			"Vbx_mvac_brk_nok"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF78F0
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mvac_cut_req
			"Vbx_mvac_cut_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF78F1
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mvac_dp_chr_h_dft
			"Vbx_mvac_dp_chr_h_dft"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF78F2
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mvac_dp_chr_l_dft
			"Vbx_mvac_dp_chr_l_dft"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF78F3
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mvac_dp_mdl_act
			"Vbx_mvac_dp_mdl_act"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF78F4
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mvac_l_dp
			"Vbx_mvac_l_dp"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF78F5
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mvac_map_nok
			"Vbx_mvac_map_nok"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF78F6
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mvac_prs_cnt
			"Vbx_mvac_prs_cnt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF78F7
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mvac_prs_cnt_i_1
			"Vbx_mvac_prs_cnt_i_1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF78F8
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mvac_prs_cnt_lk_stt
			"Vbx_mvac_prs_cnt_lk_stt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF78F9
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mvac_pump_act
			"Vbx_mvac_pump_act"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF78FA
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mvac_pump_avl
			"Vbx_mvac_pump_avl"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF78FB
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mvac_pump_lk_stt
			"Vbx_mvac_pump_lk_stt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF78FC
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mvac_pump_prot_mod
			"Vbx_mvac_pump_prot_mod"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF78FD
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mvac_pump_req
			"Vbx_mvac_pump_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF78FE
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_mvac_sys_nok
			"Vbx_mvac_sys_nok"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF78FF
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_n_ac_dsb
			"Vbx_n_ac_dsb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF744D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_n_gear_cge
			"Vbx_n_gear_cge"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF78C0
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_n_inj_stop
			"Vbx_n_inj_stop"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A8A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_n_ovs_n_max
			"Vbx_n_ovs_n_max"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8300
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_neut_agb
			"Vbx_neut_agb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6EA6
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_obd_dft_ini_req
			"Vbx_obd_dft_ini_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF75C9
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_obd_eng_cdn
			"Vbx_obd_eng_cdn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D51
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_obd_lbup_fail_trs
			"Vbx_obd_lbup_fail_trs"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7EB0
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_obd_lgl_cdn
			"Vbx_obd_lgl_cdn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D52
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_obd_no_test_lgl_cdn
			"Vbx_obd_no_test_lgl_cdn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D53
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_obd_trs_fail_det_cdn
			"Vbx_obd_trs_fail_det_cdn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7EB1
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_ofs2_ena
			"Vbx_ofs2_ena"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A8B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_open_agb_conv
			"Vbx_open_agb_conv"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6EA7
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_open_brk
			"Vbx_open_brk"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF81A4
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_open_brk_nok
			"Vbx_open_brk_nok"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF81A5
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_open_brk_swi
			"Vbx_open_brk_swi"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7900
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_ovn_conf
			"Vbx_ovn_conf"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8301
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_ovn_det
			"Vbx_ovn_det"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8302
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_ovn_sta_conf
			"Vbx_ovn_sta_conf"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF80E5
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_ovn_tq_cor_dsb
			"Vbx_ovn_tq_cor_dsb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7BD7
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_ovp_inj_cut
			"Vbx_ovp_inj_cut"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8497
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pdl_psn_acq_dsb
			"Vbx_pdl_psn_acq_dsb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF824C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pdl_sens_shift_diag_ena
			"Vbx_pdl_sens_shift_diag_ena"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7661
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pdl_sens_shift_fil
			"Vbx_pdl_sens_shift_fil"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7662
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pdl_temp_shift_fil
			"Vbx_pdl_temp_shift_fil"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7663
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pdl_thr_dft
			"Vbx_pdl_thr_dft"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7BD8
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_perf_ac_dsb
			"Vbx_perf_ac_dsb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF744E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_ac_prs
			"Vbx_pf_ac_prs"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6668
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_ac_rcpt
			"Vbx_pf_ac_rcpt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6669
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_acr
			"Vbx_pf_acr"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF673B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_acr_oc
			"Vbx_pf_acr_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF666A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_acr_scg
			"Vbx_pf_acr_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF666B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_acr_vb_sc
			"Vbx_pf_acr_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF666C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_actr_rly
			"Vbx_pf_actr_rly"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF666D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_actr_rly_cut
			"Vbx_pf_actr_rly_cut"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF666E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_agb
			"Vbx_pf_agb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF673E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_agb_conv_stt
			"Vbx_pf_agb_conv_stt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF666F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_agb_gear
			"Vbx_pf_agb_gear"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6670
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_agb_rcpt
			"Vbx_pf_agb_rcpt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6671
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_agb_tq_nok
			"Vbx_pf_agb_tq_nok"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6672
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_air
			"Vbx_pf_air"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6673
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_alt
			"Vbx_pf_alt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6740
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_alt_ecu
			"Vbx_pf_alt_ecu"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6674
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_alt_load_in
			"Vbx_pf_alt_load_in"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6676
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_alt_mux
			"Vbx_pf_alt_mux"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6675
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_bkup_mem
			"Vbx_pf_bkup_mem"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6677
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_checksum
			"Vbx_pf_checksum"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6678
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_clu
			"Vbx_pf_clu"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6679
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_cp
			"Vbx_pf_cp"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6745
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_cp_oc
			"Vbx_pf_cp_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF667A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_cp_scg
			"Vbx_pf_cp_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF667B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_cp_vb_sc
			"Vbx_pf_cp_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF667C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_crk
			"Vbx_pf_crk"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF667D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_crk_nr
			"Vbx_pf_crk_nr"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF667E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_cru
			"Vbx_pf_cru"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6748
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_cru_brk_cnt1
			"Vbx_pf_cru_brk_cnt1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF667F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_cru_brk_cnt2
			"Vbx_pf_cru_brk_cnt2"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6680
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_cru_on_off_chr
			"Vbx_pf_cru_on_off_chr"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6681
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_cru_whl_cmd
			"Vbx_pf_cru_whl_cmd"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6682
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_cyc
			"Vbx_pf_cyc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7F26
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_el_wind_rcpt
			"Vbx_pf_el_wind_rcpt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6683
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_eng_temp
			"Vbx_pf_eng_temp"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF674A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_eng_temp_oc
			"Vbx_pf_eng_temp_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6684
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_eng_temp_scg
			"Vbx_pf_eng_temp_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6685
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_eng_temp_vb_sc
			"Vbx_pf_eng_temp_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6686
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_eng_whl
			"Vbx_pf_eng_whl"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6687
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_fsys
			"Vbx_pf_fsys"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6688
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_fsys_lpg
			"Vbx_pf_fsys_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6689
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_gas_pump
			"Vbx_pf_gas_pump"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF674E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_gas_pump_oc
			"Vbx_pf_gas_pump_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF668A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_gas_pump_scg
			"Vbx_pf_gas_pump_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF668B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_gas_pump_vb_sc
			"Vbx_pf_gas_pump_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF668C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_igc_1
			"Vbx_pf_igc_1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF674F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_igc_1_oc
			"Vbx_pf_igc_1_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF668D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_igc_1_vb_sc
			"Vbx_pf_igc_1_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF668E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_igc_2
			"Vbx_pf_igc_2"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6750
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_igc_2_oc
			"Vbx_pf_igc_2_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF668F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_igc_2_vb_sc
			"Vbx_pf_igc_2_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6690
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_igc_3
			"Vbx_pf_igc_3"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6751
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_igc_3_oc
			"Vbx_pf_igc_3_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6691
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_igc_3_vb_sc
			"Vbx_pf_igc_3_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6692
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_igc_4
			"Vbx_pf_igc_4"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6752
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_igc_4_oc
			"Vbx_pf_igc_4_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6693
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_igc_4_vb_sc
			"Vbx_pf_igc_4_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6694
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_inj1
			"Vbx_pf_inj1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6753
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_inj1_oc
			"Vbx_pf_inj1_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6695
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_inj1_scg
			"Vbx_pf_inj1_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6696
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_inj1_vb_sc
			"Vbx_pf_inj1_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6697
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_inj2
			"Vbx_pf_inj2"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6754
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_inj2_oc
			"Vbx_pf_inj2_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6698
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_inj2_scg
			"Vbx_pf_inj2_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6699
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_inj2_vb_sc
			"Vbx_pf_inj2_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF669A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_inj3
			"Vbx_pf_inj3"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6755
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_inj3_oc
			"Vbx_pf_inj3_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF669B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_inj3_scg
			"Vbx_pf_inj3_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF669C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_inj3_vb_sc
			"Vbx_pf_inj3_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF669D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_inj4
			"Vbx_pf_inj4"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6756
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_inj4_oc
			"Vbx_pf_inj4_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF669E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_inj4_scg
			"Vbx_pf_inj4_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF669F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_inj4_vb_sc
			"Vbx_pf_inj4_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66A0
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_inj_ecu
			"Vbx_pf_inj_ecu"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66A1
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_inj_srs1
			"Vbx_pf_inj_srs1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7874
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_inj_srs2
			"Vbx_pf_inj_srs2"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7875
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_ip_inj_cnt
			"Vbx_pf_ip_inj_cnt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66A2
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_knk
			"Vbx_pf_knk"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66A3
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_lbdw
			"Vbx_pf_lbdw"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF675A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_lbdw_hot
			"Vbx_pf_lbdw_hot"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF675B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_lbdw_hot_oc
			"Vbx_pf_lbdw_hot_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66A7
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_lbdw_hot_scg
			"Vbx_pf_lbdw_hot_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66A8
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_lbdw_hot_vb_sc
			"Vbx_pf_lbdw_hot_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66A9
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_lbdw_oc
			"Vbx_pf_lbdw_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66A4
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_lbdw_pump_crt
			"Vbx_pf_lbdw_pump_crt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66AA
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_lbdw_scg
			"Vbx_pf_lbdw_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66A5
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_lbdw_vb_sc
			"Vbx_pf_lbdw_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66A6
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_lbup
			"Vbx_pf_lbup"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF675D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_lbup_hot
			"Vbx_pf_lbup_hot"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF675E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_lbup_hot_oc
			"Vbx_pf_lbup_hot_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66AE
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_lbup_hot_scg
			"Vbx_pf_lbup_hot_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66AF
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_lbup_hot_vb_sc
			"Vbx_pf_lbup_hot_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66B0
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_lbup_oc
			"Vbx_pf_lbup_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66AB
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_lbup_pump_crt
			"Vbx_pf_lbup_pump_crt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66B1
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_lbup_scg
			"Vbx_pf_lbup_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66AC
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_lbup_vb_sc
			"Vbx_pf_lbup_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66AD
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_lpg_rcpt
			"Vbx_pf_lpg_rcpt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66B2
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_map
			"Vbx_pf_map"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66B3
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_map_chr
			"Vbx_pf_map_chr"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66B4
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_mastervac
			"Vbx_pf_mastervac"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6763
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_mastervac_cc
			"Vbx_pf_mastervac_cc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66B5
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_mastervac_oc
			"Vbx_pf_mastervac_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66B6
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_mcut_sens1
			"Vbx_pf_mcut_sens1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66B7
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_mdf1
			"Vbx_pf_mdf1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6765
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_mdf1_oc
			"Vbx_pf_mdf1_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66B8
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_mdf1_scg
			"Vbx_pf_mdf1_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66B9
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_mdf1_vb_sc
			"Vbx_pf_mdf1_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66BA
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_mdf2
			"Vbx_pf_mdf2"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6766
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_mdf2_oc
			"Vbx_pf_mdf2_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66BB
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_mdf2_scg
			"Vbx_pf_mdf2_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66BC
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_mdf2_vb_sc
			"Vbx_pf_mdf2_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66BD
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_min_gas_lvl
			"Vbx_pf_min_gas_lvl"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66BE
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_min_lpg_lvl
			"Vbx_pf_min_lpg_lvl"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66BF
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_mis_cata
			"Vbx_pf_mis_cata"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66C0
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_mis_cata_1
			"Vbx_pf_mis_cata_1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66C1
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_mis_cata_1_lpg
			"Vbx_pf_mis_cata_1_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66C2
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_mis_cata_2
			"Vbx_pf_mis_cata_2"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66C3
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_mis_cata_2_lpg
			"Vbx_pf_mis_cata_2_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66C4
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_mis_cata_3
			"Vbx_pf_mis_cata_3"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66C5
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_mis_cata_3_lpg
			"Vbx_pf_mis_cata_3_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66C6
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_mis_cata_4
			"Vbx_pf_mis_cata_4"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66C7
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_mis_cata_4_lpg
			"Vbx_pf_mis_cata_4_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66C8
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_mis_cata_gas
			"Vbx_pf_mis_cata_gas"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66C9
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_mis_cata_lpg
			"Vbx_pf_mis_cata_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66CA
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_mis_fast
			"Vbx_pf_mis_fast"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66CB
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_mis_lih
			"Vbx_pf_mis_lih"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66CC
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_mis_polu
			"Vbx_pf_mis_polu"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66CD
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_mis_polu_1
			"Vbx_pf_mis_polu_1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66CE
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_mis_polu_1_lpg
			"Vbx_pf_mis_polu_1_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66CF
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_mis_polu_2
			"Vbx_pf_mis_polu_2"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66D0
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_mis_polu_2_lpg
			"Vbx_pf_mis_polu_2_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66D1
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_mis_polu_3
			"Vbx_pf_mis_polu_3"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66D2
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_mis_polu_3_lpg
			"Vbx_pf_mis_polu_3_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66D3
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_mis_polu_4
			"Vbx_pf_mis_polu_4"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66D4
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_mis_polu_4_lpg
			"Vbx_pf_mis_polu_4_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66D5
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_mis_polu_gas
			"Vbx_pf_mis_polu_gas"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66D6
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_mis_polu_lpg
			"Vbx_pf_mis_polu_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66D7
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_mvac_pump
			"Vbx_pf_mvac_pump"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6781
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_mvac_pump_oc
			"Vbx_pf_mvac_pump_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66D8
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_mvac_pump_scg
			"Vbx_pf_mvac_pump_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66D9
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_mvac_pump_vb_sc
			"Vbx_pf_mvac_pump_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66DA
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_mvac_sys
			"Vbx_pf_mvac_sys"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66DB
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_obd_cata
			"Vbx_pf_obd_cata"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66DC
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_obd_lamb
			"Vbx_pf_obd_lamb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66DD
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_obd_sa
			"Vbx_pf_obd_sa"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66DE
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_oil
			"Vbx_pf_oil"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6786
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_oil_cc
			"Vbx_pf_oil_cc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66DF
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_oil_co
			"Vbx_pf_oil_co"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66E0
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_pdl
			"Vbx_pf_pdl"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6787
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_pdl_sens1
			"Vbx_pf_pdl_sens1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7BD9
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_pdl_sens1_oc
			"Vbx_pf_pdl_sens1_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66E1
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_pdl_sens1_vb_sc
			"Vbx_pf_pdl_sens1_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66E2
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_pdl_sens2
			"Vbx_pf_pdl_sens2"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7BDA
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_pdl_sens2_oc
			"Vbx_pf_pdl_sens2_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66E3
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_pdl_sens2_vb_sc
			"Vbx_pf_pdl_sens2_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66E4
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_pdl_sens_chr
			"Vbx_pf_pdl_sens_chr"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66E5
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_pmh
			"Vbx_pf_pmh"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6788
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_pmh_cc
			"Vbx_pf_pmh_cc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66E6
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_pmh_co
			"Vbx_pf_pmh_co"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66E7
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_pow_lbdw
			"Vbx_pf_pow_lbdw"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66E8
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_pow_lbup
			"Vbx_pf_pow_lbup"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66E9
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_ptc
			"Vbx_pf_ptc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66EA
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_ptc_rov
			"Vbx_pf_ptc_rov"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF678C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_ptc_rov_oc
			"Vbx_pf_ptc_rov_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66EB
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_ptc_rov_scg
			"Vbx_pf_ptc_rov_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66EC
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_ptc_rov_vb_sc
			"Vbx_pf_ptc_rov_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66ED
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_pws
			"Vbx_pf_pws"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF678D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_pws_1
			"Vbx_pf_pws_1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66EE
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_pws_2
			"Vbx_pf_pws_2"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66EF
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_pws_pdl2
			"Vbx_pf_pws_pdl2"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66F0
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_pws_thr_pdl1
			"Vbx_pf_pws_thr_pdl1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66F1
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_rams
			"Vbx_pf_rams"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF678E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_rams_map_tq
			"Vbx_pf_rams_map_tq"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66F2
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_rams_pdl
			"Vbx_pf_rams_pdl"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66F5
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_rams_tq_ctl
			"Vbx_pf_rams_tq_ctl"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66F3
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_rams_tq_req
			"Vbx_pf_rams_tq_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66F4
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_reserve_3
			"Vbx_pf_reserve_3"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6790
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_reserve_3_oc
			"Vbx_pf_reserve_3_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66F6
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_reserve_3_scg
			"Vbx_pf_reserve_3_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66F7
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_reserve_3_vb_sc
			"Vbx_pf_reserve_3_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66F8
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_rmc
			"Vbx_pf_rmc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6791
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_rmc_algopp
			"Vbx_pf_rmc_algopp"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66F9
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_rmc_clockpp
			"Vbx_pf_rmc_clockpp"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66FA
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_rmc_comspipp
			"Vbx_pf_rmc_comspipp"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66FB
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_rmc_inhwp
			"Vbx_pf_rmc_inhwp"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66FC
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_rmc_monitpp
			"Vbx_pf_rmc_monitpp"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66FD
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_rmc_papmpp
			"Vbx_pf_rmc_papmpp"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66FE
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_rmc_pedmpp
			"Vbx_pf_rmc_pedmpp"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF66FF
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_rmc_timeoutpp
			"Vbx_pf_rmc_timeoutpp"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6700
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_sa
			"Vbx_pf_sa"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6792
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_sa_ev
			"Vbx_pf_sa_ev"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6793
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_sa_ev_oc
			"Vbx_pf_sa_ev_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6704
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_sa_ev_scg
			"Vbx_pf_sa_ev_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6705
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_sa_ev_vb_sc
			"Vbx_pf_sa_ev_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6706
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_sa_oc
			"Vbx_pf_sa_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6701
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_sa_scg
			"Vbx_pf_sa_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6702
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_sa_vb_sc
			"Vbx_pf_sa_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6703
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_spg
			"Vbx_pf_spg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6707
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_spg_sys
			"Vbx_pf_spg_sys"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6708
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_spi_cc
			"Vbx_pf_spi_cc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6709
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_svkl
			"Vbx_pf_svkl"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6797
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_svkl_chk_springs
			"Vbx_pf_svkl_chk_springs"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF670A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_svkl_lih
			"Vbx_pf_svkl_lih"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF670B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_svkl_oc
			"Vbx_pf_svkl_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF670C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_svkl_psn
			"Vbx_pf_svkl_psn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF670D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_svkl_sge
			"Vbx_pf_svkl_sge"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF670E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_svkl_trt_srch
			"Vbx_pf_svkl_trt_srch"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF670F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_swlk
			"Vbx_pf_swlk"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6798
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_swlk_mem
			"Vbx_pf_swlk_mem"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6710
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_tco
			"Vbx_pf_tco"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6799
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_tco_acq
			"Vbx_pf_tco_acq"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6711
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_tco_chr
			"Vbx_pf_tco_chr"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6712
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_thpl
			"Vbx_pf_thpl"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF679A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_thpl_oc
			"Vbx_pf_thpl_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6713
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_thpl_scg
			"Vbx_pf_thpl_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6714
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_thpl_vb_sc
			"Vbx_pf_thpl_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6715
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_thr
			"Vbx_pf_thr"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF679B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_thr_cmd
			"Vbx_pf_thr_cmd"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF679C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_thr_cmd_cpt
			"Vbx_pf_thr_cmd_cpt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF671B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_thr_cmd_vb_sc
			"Vbx_pf_thr_cmd_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF671C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_thr_sens1_oc
			"Vbx_pf_thr_sens1_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6716
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_thr_sens1_vb_sc
			"Vbx_pf_thr_sens1_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6717
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_thr_sens2_scg
			"Vbx_pf_thr_sens2_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6718
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_thr_sens2_vb_sc
			"Vbx_pf_thr_sens2_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6719
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_thr_sens_chr
			"Vbx_pf_thr_sens_chr"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF671A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_tia
			"Vbx_pf_tia"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF679D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_tia_high
			"Vbx_pf_tia_high"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF671D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_tia_low
			"Vbx_pf_tia_low"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF671E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_tia_tco
			"Vbx_pf_tia_tco"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6D0C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_tjy_ctl
			"Vbx_pf_tjy_ctl"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF671F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_tlz_ad_b
			"Vbx_pf_tlz_ad_b"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6720
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_vb
			"Vbx_pf_vb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67A0
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_vb_high
			"Vbx_pf_vb_high"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6721
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_vb_low
			"Vbx_pf_vb_low"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6722
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_vs
			"Vbx_pf_vs"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67A1
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_vs_eal
			"Vbx_pf_vs_eal"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6723
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_vs_mux
			"Vbx_pf_vs_mux"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6724
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_vs_parasite
			"Vbx_pf_vs_parasite"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6725
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_vta_intake
			"Vbx_pf_vta_intake"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67A2
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_vta_intake_pmh
			"Vbx_pf_vta_intake_pmh"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6726
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_vta_intake_shift
			"Vbx_pf_vta_intake_shift"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6727
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_vvt_int
			"Vbx_pf_vvt_int"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67A3
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_vvt_int_ev
			"Vbx_pf_vvt_int_ev"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67A4
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_vvt_int_ev_oc
			"Vbx_pf_vvt_int_ev_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6729
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_vvt_int_ev_scg
			"Vbx_pf_vvt_int_ev_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF672A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_vvt_int_ev_vb_sc
			"Vbx_pf_vvt_int_ev_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF672B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_vvt_int_old_off
			"Vbx_pf_vvt_int_old_off"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6728
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_vvt_intake
			"Vbx_pf_vvt_intake"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67A5
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_vvt_intake_blk
			"Vbx_pf_vvt_intake_blk"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF672C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_vvt_intake_bound
			"Vbx_pf_vvt_intake_bound"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF672D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_vvt_intake_dyn
			"Vbx_pf_vvt_intake_dyn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF672E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_vvt_intake_int
			"Vbx_pf_vvt_intake_int"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF672F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_vvtc_toth_3
			"Vbx_pf_vvtc_toth_3"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6730
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_wat_temp
			"Vbx_pf_wat_temp"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67A7
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_wat_temp_high
			"Vbx_pf_wat_temp_high"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6731
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_wat_temp_low
			"Vbx_pf_wat_temp_low"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6732
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_wgc
			"Vbx_pf_wgc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67A8
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_wgc_oc
			"Vbx_pf_wgc_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6733
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_wgc_scg
			"Vbx_pf_wgc_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6734
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_wgc_vb_sc
			"Vbx_pf_wgc_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6735
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_wpmp
			"Vbx_pf_wpmp"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67A9
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_wpmp_oc
			"Vbx_pf_wpmp_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6736
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_wpmp_scg
			"Vbx_pf_wpmp_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6737
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pf_wpmp_vb_sc
			"Vbx_pf_wpmp_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6738
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pred_map_lean_ena
			"Vbx_pred_map_lean_ena"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8025
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pred_map_psi_fac_cor
			"Vbx_pred_map_psi_fac_cor"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8026
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_prev_cp
			"Vbx_prev_cp"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A8C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_prmt_n_ac_dsb
			"Vbx_prmt_n_ac_dsb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF744F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_prot_stt
			"Vbx_prot_stt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF86BE
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_prs_ac_swi_dsb
			"Vbx_prs_ac_swi_dsb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7450
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_prs_sp_dsb
			"Vbx_prs_sp_dsb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7BDB
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_prs_trs_iga_cor_dsb
			"Vbx_prs_trs_iga_cor_dsb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7BDC
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_ptc_cut
			"Vbx_ptc_cut"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF807C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_ptc_cut_eal_cdn
			"Vbx_ptc_cut_eal_cdn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF807D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_ptc_cut_eng_cdn
			"Vbx_ptc_cut_eng_cdn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF807E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_ptc_cut_n_cdn
			"Vbx_ptc_cut_n_cdn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF807F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_ptc_cut_tkof_cdn
			"Vbx_ptc_cut_tkof_cdn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8080
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_ptc_is_acel
			"Vbx_ptc_is_acel"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8081
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_ptc_lk_stt
			"Vbx_ptc_lk_stt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6EA8
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_ptc_mem
			"Vbx_ptc_mem"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8082
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_ptc_mem_test
			"Vbx_ptc_mem_test"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8083
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_ptc_ofs_dsb
			"Vbx_ptc_ofs_dsb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF79BE
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_ptc_rov_cmd
			"Vbx_ptc_rov_cmd"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF815D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_ptc_rov_lk_stt
			"Vbx_ptc_rov_lk_stt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF815A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pwst_prs_stt
			"Vbx_pwst_prs_stt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF77B6
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pwst_prs_stt_on
			"Vbx_pwst_prs_stt_on"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF77B7
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_pwst_wf_in
			"Vbx_pwst_wf_in"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF77B8
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_rams_ct_pdl_psn_err
			"Vbx_rams_ct_pdl_psn_err"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF824D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_rams_ena_diag
			"Vbx_rams_ena_diag"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8303
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_rams_ena_diag_prec
			"Vbx_rams_ena_diag_prec"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8304
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_rams_ena_ovt
			"Vbx_rams_ena_ovt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8305
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_rams_esti_tq_det_fail
			"Vbx_rams_esti_tq_det_fail"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8306
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_rams_esti_tq_vld_fail
			"Vbx_rams_esti_tq_vld_fail"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8307
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_rams_fl
			"Vbx_rams_fl"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8308
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_rams_pdl_dif
			"Vbx_rams_pdl_dif"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF824E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_rams_tq_req_det_fail
			"Vbx_rams_tq_req_det_fail"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8309
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_rams_tq_req_vld_fail
			"Vbx_rams_tq_req_vld_fail"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF830A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_rest_cdn
			"Vbx_rest_cdn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF80D9
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_rest_set_pws
			"Vbx_rest_set_pws"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF80DA
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_rest_stal
			"Vbx_rest_stal"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF80DB
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_rgb_dyn_iga_cor_dsb
			"Vbx_rgb_dyn_iga_cor_dsb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7BDD
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_rich_cl_cylr_mem
			"Vbx_rich_cl_cylr_mem"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6BCB
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_rly_cmd_vld
			"Vbx_rly_cmd_vld"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF814E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_rst_cor_thr_adj
			"Vbx_rst_cor_thr_adj"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6C14
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_rtn_cata_diag_done
			"Vbx_rtn_cata_diag_done"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D55
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_rtn_clos_o2_phs
			"Vbx_rtn_clos_o2_phs"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8629
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_rtn_cnt_diag_done
			"Vbx_rtn_cnt_diag_done"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D56
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_rtn_fsys_diag_done
			"Vbx_rtn_fsys_diag_done"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D57
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_rtn_lbup_diag_done
			"Vbx_rtn_lbup_diag_done"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D58
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_rtn_mis_diag_done
			"Vbx_rtn_mis_diag_done"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D59
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_rtn_sa_diag_done
			"Vbx_rtn_sa_diag_done"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D5A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_run_cylr_mem
			"Vbx_run_cylr_mem"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6BCC
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_run_eng_det
			"Vbx_run_eng_det"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7F27
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_run_pinj
			"Vbx_run_pinj"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7BA4
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_run_vh
			"Vbx_run_vh"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8288
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_run_vh1
			"Vbx_run_vh1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8289
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_sa_diag_stop
			"Vbx_sa_diag_stop"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D5B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_sa_lk_stt
			"Vbx_sa_lk_stt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8498
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_sa_mes
			"Vbx_sa_mes"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D5C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_sa_req
			"Vbx_sa_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D5D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_schd_asd_cata_stt
			"Vbx_schd_asd_cata_stt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D5E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_schd_asd_lbup_stt
			"Vbx_schd_asd_lbup_stt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D5F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_schd_asd_sa_stt
			"Vbx_schd_asd_sa_stt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D60
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_schd_diag_cata_act
			"Vbx_schd_diag_cata_act"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D61
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_schd_diag_fsys_act
			"Vbx_schd_diag_fsys_act"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D62
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_schd_diag_lamb_act
			"Vbx_schd_diag_lamb_act"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D63
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_schd_diag_mis_act
			"Vbx_schd_diag_mis_act"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D64
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_schd_diag_sa_act
			"Vbx_schd_diag_sa_act"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D65
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_schd_dsb_ad_rich
			"Vbx_schd_dsb_ad_rich"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D66
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_schd_dsb_cp
			"Vbx_schd_dsb_cp"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D67
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_schd_ena_diag_cata
			"Vbx_schd_ena_diag_cata"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D68
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_schd_ena_diag_fsys
			"Vbx_schd_ena_diag_fsys"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D69
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_schd_ena_diag_lamb
			"Vbx_schd_ena_diag_lamb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D6A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_schd_ena_diag_mis
			"Vbx_schd_ena_diag_mis"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D6B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_schd_ena_diag_sa
			"Vbx_schd_ena_diag_sa"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D6C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_schd_eol_diag_stt
			"Vbx_schd_eol_diag_stt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D6D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_sens1_pdl_mf
			"Vbx_sens1_pdl_mf"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8251
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_sens1_thr_mf
			"Vbx_sens1_thr_mf"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8252
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_sens2_pdl_mf
			"Vbx_sens2_pdl_mf"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8253
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_sens2_thr_mf
			"Vbx_sens2_thr_mf"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8254
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_sens_pdl_mf
			"Vbx_sens_pdl_mf"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF824F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_sens_thr_mf
			"Vbx_sens_thr_mf"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8250
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_sl_lk_stt
			"Vbx_sl_lk_stt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF81A6
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_sl_mf_det
			"Vbx_sl_mf_det"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF81A7
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_sl_mstr
			"Vbx_sl_mstr"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF81A8
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_sl_on_off_in
			"Vbx_sl_on_off_in"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF81A9
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_sl_oor_vs
			"Vbx_sl_oor_vs"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF81AA
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_sl_pf_det
			"Vbx_sl_pf_det"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF81AB
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_slop_ac_dsb
			"Vbx_slop_ac_dsb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7451
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_spg_alti_upd
			"Vbx_spg_alti_upd"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8499
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_spg_diag_done
			"Vbx_spg_diag_done"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF849A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_spg_prs_ini_ok
			"Vbx_spg_prs_ini_ok"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF849B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_spg_sys_diag_cdn
			"Vbx_spg_sys_diag_cdn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF849C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_spg_sys_diag_done
			"Vbx_spg_sys_diag_done"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF849D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_sta_ac_dsb
			"Vbx_sta_ac_dsb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7452
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_sta_dsb
			"Vbx_sta_dsb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6C0C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_sta_gas_pump
			"Vbx_sta_gas_pump"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF814F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_sta_gas_pump_ena
			"Vbx_sta_gas_pump_ena"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8150
		/end MEASUREMENT
		/begin MEASUREMENT VBX_STA_IGA_STT
			"VBX_STA_IGA_STT"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6DA4
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_sta_inj_stt
			"Vbx_sta_inj_stt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A8D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_sta_n_lim
			"Vbx_sta_n_lim"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF78DE
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_sta_n_lim_dsb
			"Vbx_sta_n_lim_dsb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6D85
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_sta_stal
			"Vbx_sta_stal"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF78DF
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_sta_tco_ti_fac_mod
			"Vbx_sta_tco_ti_fac_mod"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A8E
		/end MEASUREMENT
		/begin MEASUREMENT VBX_STAB_DYN_IGA
			"VBX_STAB_DYN_IGA"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6D9B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_stal_ac_dsb
			"Vbx_stal_ac_dsb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7453
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_stat_neut_agb
			"Vbx_stat_neut_agb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6EA9
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_svkl_oc_cond
			"Vbx_svkl_oc_cond"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7664
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_svkl_oc_dsb_tmp
			"Vbx_svkl_oc_dsb_tmp"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7665
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_swlk_pws
			"Vbx_swlk_pws"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6BF0
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_swlk_stal
			"Vbx_swlk_stal"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF78E0
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_syn_eng
			"Vbx_syn_eng"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7F28
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tco_ac_dsb
			"Vbx_tco_ac_dsb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7927
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tco_chr_mon
			"Vbx_tco_chr_mon"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8588
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tdc1
			"Vbx_tdc1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7F29
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tdc_re_syn_ctr_req
			"Vbx_tdc_re_syn_ctr_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6BCD
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_temp_ac_dsb
			"Vbx_temp_ac_dsb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7454
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_temp_shift_fil
			"Vbx_temp_shift_fil"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7666
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_ac_prs
			"Vbx_tf_ac_prs"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67AA
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_ac_rcpt
			"Vbx_tf_ac_rcpt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67AB
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_acr_oc
			"Vbx_tf_acr_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67AC
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_acr_scg
			"Vbx_tf_acr_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67AD
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_acr_vb_sc
			"Vbx_tf_acr_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67AE
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_actr_rly
			"Vbx_tf_actr_rly"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67AF
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_actr_rly_cut
			"Vbx_tf_actr_rly_cut"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67B0
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_agb_conv_stt
			"Vbx_tf_agb_conv_stt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67B1
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_agb_gear
			"Vbx_tf_agb_gear"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67B2
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_agb_rcpt
			"Vbx_tf_agb_rcpt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67B3
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_agb_tq_nok
			"Vbx_tf_agb_tq_nok"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67B4
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_air
			"Vbx_tf_air"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67B5
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_alt_ecu
			"Vbx_tf_alt_ecu"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67B6
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_alt_load_in
			"Vbx_tf_alt_load_in"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67B8
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_alt_mux
			"Vbx_tf_alt_mux"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67B7
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_bkup_mem
			"Vbx_tf_bkup_mem"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67B9
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_checksum
			"Vbx_tf_checksum"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67BA
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_clu
			"Vbx_tf_clu"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67BB
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_cp_oc
			"Vbx_tf_cp_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67BC
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_cp_scg
			"Vbx_tf_cp_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67BD
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_cp_vb_sc
			"Vbx_tf_cp_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67BE
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_crk
			"Vbx_tf_crk"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67BF
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_crk_nr
			"Vbx_tf_crk_nr"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67C0
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_cru_brk_cnt1
			"Vbx_tf_cru_brk_cnt1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67C1
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_cru_brk_cnt2
			"Vbx_tf_cru_brk_cnt2"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67C2
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_cru_on_off_chr
			"Vbx_tf_cru_on_off_chr"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67C3
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_cru_whl_cmd
			"Vbx_tf_cru_whl_cmd"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67C4
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_el_wind_rcpt
			"Vbx_tf_el_wind_rcpt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67C5
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_eng_temp_oc
			"Vbx_tf_eng_temp_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67C6
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_eng_temp_scg
			"Vbx_tf_eng_temp_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67C7
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_eng_temp_vb_sc
			"Vbx_tf_eng_temp_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67C8
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_eng_whl
			"Vbx_tf_eng_whl"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67C9
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_fsys
			"Vbx_tf_fsys"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67CA
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_fsys_lpg
			"Vbx_tf_fsys_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67CB
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_gas_pump_oc
			"Vbx_tf_gas_pump_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67CC
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_gas_pump_scg
			"Vbx_tf_gas_pump_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67CD
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_gas_pump_vb_sc
			"Vbx_tf_gas_pump_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67CE
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_igc_1_oc
			"Vbx_tf_igc_1_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67CF
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_igc_1_vb_sc
			"Vbx_tf_igc_1_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67D0
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_igc_2_oc
			"Vbx_tf_igc_2_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67D1
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_igc_2_vb_sc
			"Vbx_tf_igc_2_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67D2
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_igc_3_oc
			"Vbx_tf_igc_3_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67D3
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_igc_3_vb_sc
			"Vbx_tf_igc_3_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67D4
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_igc_4_oc
			"Vbx_tf_igc_4_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67D5
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_igc_4_vb_sc
			"Vbx_tf_igc_4_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67D6
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_inj1_oc
			"Vbx_tf_inj1_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67D7
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_inj1_scg
			"Vbx_tf_inj1_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67D8
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_inj1_vb_sc
			"Vbx_tf_inj1_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67D9
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_inj2_oc
			"Vbx_tf_inj2_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67DA
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_inj2_scg
			"Vbx_tf_inj2_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67DB
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_inj2_vb_sc
			"Vbx_tf_inj2_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67DC
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_inj3_oc
			"Vbx_tf_inj3_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67DD
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_inj3_scg
			"Vbx_tf_inj3_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67DE
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_inj3_vb_sc
			"Vbx_tf_inj3_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67DF
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_inj4_oc
			"Vbx_tf_inj4_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67E0
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_inj4_scg
			"Vbx_tf_inj4_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67E1
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_inj4_vb_sc
			"Vbx_tf_inj4_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67E2
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_inj_ecu
			"Vbx_tf_inj_ecu"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67E3
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_ip_inj_cnt
			"Vbx_tf_ip_inj_cnt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67E4
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_knk
			"Vbx_tf_knk"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67E5
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_lbdw_hot_oc
			"Vbx_tf_lbdw_hot_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67E9
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_lbdw_hot_scg
			"Vbx_tf_lbdw_hot_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67EA
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_lbdw_hot_vb_sc
			"Vbx_tf_lbdw_hot_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67EB
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_lbdw_oc
			"Vbx_tf_lbdw_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67E6
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_lbdw_pump_crt
			"Vbx_tf_lbdw_pump_crt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67EC
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_lbdw_scg
			"Vbx_tf_lbdw_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67E7
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_lbdw_vb_sc
			"Vbx_tf_lbdw_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67E8
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_lbup_hot_oc
			"Vbx_tf_lbup_hot_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67F0
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_lbup_hot_scg
			"Vbx_tf_lbup_hot_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67F1
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_lbup_hot_vb_sc
			"Vbx_tf_lbup_hot_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67F2
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_lbup_oc
			"Vbx_tf_lbup_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67ED
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_lbup_pump_crt
			"Vbx_tf_lbup_pump_crt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67F3
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_lbup_scg
			"Vbx_tf_lbup_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67EE
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_lbup_vb_sc
			"Vbx_tf_lbup_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67EF
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_lpg_rcpt
			"Vbx_tf_lpg_rcpt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67F4
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_map
			"Vbx_tf_map"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67F5
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_map_chr
			"Vbx_tf_map_chr"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67F6
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_mastervac_cc
			"Vbx_tf_mastervac_cc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67F7
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_mastervac_oc
			"Vbx_tf_mastervac_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67F8
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_mcut_sens1
			"Vbx_tf_mcut_sens1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67F9
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_mdf1_oc
			"Vbx_tf_mdf1_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67FA
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_mdf1_scg
			"Vbx_tf_mdf1_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67FB
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_mdf1_vb_sc
			"Vbx_tf_mdf1_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67FC
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_mdf2_oc
			"Vbx_tf_mdf2_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67FD
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_mdf2_scg
			"Vbx_tf_mdf2_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67FE
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_mdf2_vb_sc
			"Vbx_tf_mdf2_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF67FF
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_min_gas_lvl
			"Vbx_tf_min_gas_lvl"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6800
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_min_lpg_lvl
			"Vbx_tf_min_lpg_lvl"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6801
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_mis_cata
			"Vbx_tf_mis_cata"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6802
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_mis_cata_1
			"Vbx_tf_mis_cata_1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6803
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_mis_cata_1_lpg
			"Vbx_tf_mis_cata_1_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6804
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_mis_cata_2
			"Vbx_tf_mis_cata_2"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6805
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_mis_cata_2_lpg
			"Vbx_tf_mis_cata_2_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6806
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_mis_cata_3
			"Vbx_tf_mis_cata_3"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6807
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_mis_cata_3_lpg
			"Vbx_tf_mis_cata_3_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6808
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_mis_cata_4
			"Vbx_tf_mis_cata_4"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6809
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_mis_cata_4_lpg
			"Vbx_tf_mis_cata_4_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF680A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_mis_cata_gas
			"Vbx_tf_mis_cata_gas"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF680B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_mis_cata_lpg
			"Vbx_tf_mis_cata_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF680C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_mis_fast
			"Vbx_tf_mis_fast"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF680D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_mis_lih
			"Vbx_tf_mis_lih"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF680E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_mis_polu
			"Vbx_tf_mis_polu"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF680F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_mis_polu_1
			"Vbx_tf_mis_polu_1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6810
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_mis_polu_1_lpg
			"Vbx_tf_mis_polu_1_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6811
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_mis_polu_2
			"Vbx_tf_mis_polu_2"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6812
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_mis_polu_2_lpg
			"Vbx_tf_mis_polu_2_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6813
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_mis_polu_3
			"Vbx_tf_mis_polu_3"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6814
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_mis_polu_3_lpg
			"Vbx_tf_mis_polu_3_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6815
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_mis_polu_4
			"Vbx_tf_mis_polu_4"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6816
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_mis_polu_4_lpg
			"Vbx_tf_mis_polu_4_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6817
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_mis_polu_gas
			"Vbx_tf_mis_polu_gas"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6818
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_mis_polu_lpg
			"Vbx_tf_mis_polu_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6819
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_mvac_pump_oc
			"Vbx_tf_mvac_pump_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF681A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_mvac_pump_scg
			"Vbx_tf_mvac_pump_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF681B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_mvac_pump_vb_sc
			"Vbx_tf_mvac_pump_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF681C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_mvac_sys
			"Vbx_tf_mvac_sys"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF681D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_obd_cata
			"Vbx_tf_obd_cata"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF681E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_obd_lamb
			"Vbx_tf_obd_lamb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF681F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_obd_sa
			"Vbx_tf_obd_sa"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6820
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_oil_cc
			"Vbx_tf_oil_cc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6821
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_oil_co
			"Vbx_tf_oil_co"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6822
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_pdl_sens1_oc
			"Vbx_tf_pdl_sens1_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6823
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_pdl_sens1_vb_sc
			"Vbx_tf_pdl_sens1_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6824
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_pdl_sens2_oc
			"Vbx_tf_pdl_sens2_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6825
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_pdl_sens2_vb_sc
			"Vbx_tf_pdl_sens2_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6826
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_pdl_sens_chr
			"Vbx_tf_pdl_sens_chr"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6827
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_pmh_cc
			"Vbx_tf_pmh_cc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6828
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_pmh_co
			"Vbx_tf_pmh_co"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6829
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_pow_lbdw
			"Vbx_tf_pow_lbdw"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF682A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_pow_lbup
			"Vbx_tf_pow_lbup"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF682B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_ptc
			"Vbx_tf_ptc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF682C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_ptc_rov_oc
			"Vbx_tf_ptc_rov_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF682D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_ptc_rov_scg
			"Vbx_tf_ptc_rov_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF682E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_ptc_rov_vb_sc
			"Vbx_tf_ptc_rov_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF682F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_pws_1
			"Vbx_tf_pws_1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6830
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_pws_2
			"Vbx_tf_pws_2"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6831
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_pws_pdl2
			"Vbx_tf_pws_pdl2"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6832
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_pws_thr_pdl1
			"Vbx_tf_pws_thr_pdl1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6833
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_rams_map_tq
			"Vbx_tf_rams_map_tq"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6834
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_rams_pdl
			"Vbx_tf_rams_pdl"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6837
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_rams_tq_ctl
			"Vbx_tf_rams_tq_ctl"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6835
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_rams_tq_req
			"Vbx_tf_rams_tq_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6836
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_reserve_3_oc
			"Vbx_tf_reserve_3_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6838
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_reserve_3_scg
			"Vbx_tf_reserve_3_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6839
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_reserve_3_vb_sc
			"Vbx_tf_reserve_3_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF683A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_rmc_algopp
			"Vbx_tf_rmc_algopp"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF683B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_rmc_clockpp
			"Vbx_tf_rmc_clockpp"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF683C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_rmc_comspipp
			"Vbx_tf_rmc_comspipp"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF683D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_rmc_inhwp
			"Vbx_tf_rmc_inhwp"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF683E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_rmc_monitpp
			"Vbx_tf_rmc_monitpp"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF683F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_rmc_papmpp
			"Vbx_tf_rmc_papmpp"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6840
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_rmc_pedmpp
			"Vbx_tf_rmc_pedmpp"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6841
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_rmc_timeoutpp
			"Vbx_tf_rmc_timeoutpp"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6842
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_sa_ev_oc
			"Vbx_tf_sa_ev_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6846
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_sa_ev_scg
			"Vbx_tf_sa_ev_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6847
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_sa_ev_vb_sc
			"Vbx_tf_sa_ev_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6848
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_sa_oc
			"Vbx_tf_sa_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6843
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_sa_scg
			"Vbx_tf_sa_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6844
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_sa_vb_sc
			"Vbx_tf_sa_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6845
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_spg
			"Vbx_tf_spg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6849
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_spg_sys
			"Vbx_tf_spg_sys"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF684A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_spi_cc
			"Vbx_tf_spi_cc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF684B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_svkl_chk_springs
			"Vbx_tf_svkl_chk_springs"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF684C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_svkl_lih
			"Vbx_tf_svkl_lih"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF684D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_svkl_oc
			"Vbx_tf_svkl_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF684E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_svkl_psn
			"Vbx_tf_svkl_psn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF684F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_svkl_sge
			"Vbx_tf_svkl_sge"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6850
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_svkl_trt_srch
			"Vbx_tf_svkl_trt_srch"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6851
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_swlk_mem
			"Vbx_tf_swlk_mem"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6852
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_tco_acq
			"Vbx_tf_tco_acq"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6853
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_tco_chr
			"Vbx_tf_tco_chr"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6854
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_thpl_oc
			"Vbx_tf_thpl_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6855
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_thpl_scg
			"Vbx_tf_thpl_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6856
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_thpl_vb_sc
			"Vbx_tf_thpl_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6857
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_thr_cmd_cpt
			"Vbx_tf_thr_cmd_cpt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF685D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_thr_cmd_vb_sc
			"Vbx_tf_thr_cmd_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF685E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_thr_sens1_oc
			"Vbx_tf_thr_sens1_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6858
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_thr_sens1_vb_sc
			"Vbx_tf_thr_sens1_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6859
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_thr_sens2_scg
			"Vbx_tf_thr_sens2_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF685A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_thr_sens2_vb_sc
			"Vbx_tf_thr_sens2_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF685B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_thr_sens_chr
			"Vbx_tf_thr_sens_chr"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF685C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_tia_high
			"Vbx_tf_tia_high"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF685F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_tia_low
			"Vbx_tf_tia_low"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6860
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_tjy_ctl
			"Vbx_tf_tjy_ctl"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6861
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_tlz_ad_b
			"Vbx_tf_tlz_ad_b"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6862
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_vb_high
			"Vbx_tf_vb_high"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6863
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_vb_low
			"Vbx_tf_vb_low"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6864
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_vs_eal
			"Vbx_tf_vs_eal"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6865
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_vs_mux
			"Vbx_tf_vs_mux"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6866
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_vs_parasite
			"Vbx_tf_vs_parasite"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6867
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_vta_intake_pmh
			"Vbx_tf_vta_intake_pmh"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6868
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_vta_intake_shift
			"Vbx_tf_vta_intake_shift"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6869
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_vvt_int_ev_oc
			"Vbx_tf_vvt_int_ev_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF686B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_vvt_int_ev_scg
			"Vbx_tf_vvt_int_ev_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF686C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_vvt_int_ev_vb_sc
			"Vbx_tf_vvt_int_ev_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF686D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_vvt_int_old_off
			"Vbx_tf_vvt_int_old_off"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF686A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_vvt_intake_blk
			"Vbx_tf_vvt_intake_blk"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF686E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_vvt_intake_bound
			"Vbx_tf_vvt_intake_bound"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF686F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_vvt_intake_dyn
			"Vbx_tf_vvt_intake_dyn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6870
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_vvt_intake_int
			"Vbx_tf_vvt_intake_int"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6871
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_vvtc_toth_3
			"Vbx_tf_vvtc_toth_3"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6872
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_wat_temp_high
			"Vbx_tf_wat_temp_high"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6873
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_wat_temp_low
			"Vbx_tf_wat_temp_low"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6874
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_wgc_oc
			"Vbx_tf_wgc_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6875
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_wgc_scg
			"Vbx_tf_wgc_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6876
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_wgc_vb_sc
			"Vbx_tf_wgc_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6877
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_wpmp_oc
			"Vbx_tf_wpmp_oc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6878
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_wpmp_scg
			"Vbx_tf_wpmp_scg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6879
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tf_wpmp_vb_sc
			"Vbx_tf_wpmp_vb_sc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF687A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_thpl1_cmd
			"Vbx_thpl1_cmd"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF82DE
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_thpl2_cmd
			"Vbx_thpl2_cmd"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF82DF
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_thpl_cnt_stt
			"Vbx_thpl_cnt_stt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF82DA
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_thpl_ena
			"Vbx_thpl_ena"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF82DB
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_thpl_inc_is_req
			"Vbx_thpl_inc_is_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF82DC
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_thpl_on_req
			"Vbx_thpl_on_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF82DD
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_thr_ad
			"Vbx_thr_ad"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7667
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_thr_ad_prev
			"Vbx_thr_ad_prev"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7668
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_thr_ar_cor_dsb
			"Vbx_thr_ar_cor_dsb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7BDE
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_thr_ar_h_lim_dsb
			"Vbx_thr_ar_h_lim_dsb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7BDF
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_thr_ar_l_lim_dsb
			"Vbx_thr_ar_l_lim_dsb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7BE0
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_thr_chk_springs_dft
			"Vbx_thr_chk_springs_dft"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7669
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_thr_cmd_cut
			"Vbx_thr_cmd_cut"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF766A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_thr_cor_ena
			"Vbx_thr_cor_ena"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF830B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_thr_ct
			"Vbx_thr_ct"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7FBC
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_thr_def_lh_chk_ena
			"Vbx_thr_def_lh_chk_ena"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF766B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_thr_dft_inj_stop
			"Vbx_thr_dft_inj_stop"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF80E6
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_thr_eng_dft_0
			"Vbx_thr_eng_dft_0"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8255
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_thr_eng_dft_1
			"Vbx_thr_eng_dft_1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8256
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_thr_eng_dft_2
			"Vbx_thr_eng_dft_2"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8257
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_thr_eng_dft_3
			"Vbx_thr_eng_dft_3"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8258
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_thr_eng_dft_4
			"Vbx_thr_eng_dft_4"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8259
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_thr_eng_dft_5
			"Vbx_thr_eng_dft_5"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF825A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_thr_frst_ad
			"Vbx_thr_frst_ad"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF766C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_thr_frst_ad_prev
			"Vbx_thr_frst_ad_prev"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF766D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_thr_h_trt_lim_1
			"Vbx_thr_h_trt_lim_1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF766E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_thr_h_trt_lim_2
			"Vbx_thr_h_trt_lim_2"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF766F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_thr_l_trt_lim_1
			"Vbx_thr_l_trt_lim_1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7670
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_thr_l_trt_lim_2
			"Vbx_thr_l_trt_lim_2"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7671
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_thr_lh_lim_1
			"Vbx_thr_lh_lim_1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7672
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_thr_lh_lim_2
			"Vbx_thr_lh_lim_2"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7673
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_thr_lh_psn_chk
			"Vbx_thr_lh_psn_chk"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7674
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_thr_mcut_sens1
			"Vbx_thr_mcut_sens1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7675
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_thr_mcut_svkl_frz
			"Vbx_thr_mcut_svkl_frz"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7676
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_thr_mcut_svkl_frz_1_0
			"Vbx_thr_mcut_svkl_frz_1_0"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7677
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_thr_mcut_svkl_frz_prec
			"Vbx_thr_mcut_svkl_frz_prec"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7678
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_thr_pws
			"Vbx_thr_pws"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7679
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_thr_sens_shift_diag_ena
			"Vbx_thr_sens_shift_diag_ena"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF767A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_thr_sge
			"Vbx_thr_sge"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF767B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_thr_sge_1_0
			"Vbx_thr_sge_1_0"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF767C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_thr_sge_prec
			"Vbx_thr_sge_prec"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF767D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_thr_svkl_dsb
			"Vbx_thr_svkl_dsb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF825B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_thr_trt_ad
			"Vbx_thr_trt_ad"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF767E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_thr_trt_frst_srch
			"Vbx_thr_trt_frst_srch"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF767F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_ti_ad1_zon0
			"Vbx_ti_ad1_zon0"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8692
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_ti_ad1_zon1
			"Vbx_ti_ad1_zon1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x2
			ECU_ADDRESS 0xFFFF8692
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_ti_ad1_zon2
			"Vbx_ti_ad1_zon2"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x4
			ECU_ADDRESS 0xFFFF8692
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_ti_ad1_zon3
			"Vbx_ti_ad1_zon3"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x8
			ECU_ADDRESS 0xFFFF8692
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_ti_ad1_zon4
			"Vbx_ti_ad1_zon4"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x10
			ECU_ADDRESS 0xFFFF8692
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_ti_cl2_act
			"Vbx_ti_cl2_act"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A8F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_ti_cor_rest_pws_set
			"Vbx_ti_cor_rest_pws_set"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A90
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_ti_sum_dft_ini_req
			"Vbx_ti_sum_dft_ini_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF75CA
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tjy_ctl_dsb
			"Vbx_tjy_ctl_dsb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF73AF
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tjy_lk_stt
			"Vbx_tjy_lk_stt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6EAA
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tkof_ac_dsb
			"Vbx_tkof_ac_dsb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7455
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tkof_fl_ena
			"Vbx_tkof_fl_ena"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF77EC
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tkof_tq_ena
			"Vbx_tkof_tq_ena"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF77ED
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tkof_tq_ena_old
			"Vbx_tkof_tq_ena_old"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF77EE
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tkof_tq_vs_ena
			"Vbx_tkof_tq_vs_ena"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF77EF
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tkof_vs_ena
			"Vbx_tkof_vs_ena"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF77F0
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tlz_ad_b_clc
			"Vbx_tlz_ad_b_clc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF74F2
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tlz_ad_b_done
			"Vbx_tlz_ad_b_done"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF74F3
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tlz_ad_cor_ok
			"Vbx_tlz_ad_cor_ok"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF74F4
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tlz_clc
			"Vbx_tlz_clc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D6E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tlz_err
			"Vbx_tlz_err"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF74F5
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tlz_raw_clc
			"Vbx_tlz_raw_clc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF74F6
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tlz_raw_err
			"Vbx_tlz_raw_err"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF74F7
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tlz_slow_ad_b_ena
			"Vbx_tlz_slow_ad_b_ena"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF74F8
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_toil_pws
			"Vbx_toil_pws"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7CD8
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tot_dyn_iga_cor_dsb
			"Vbx_tot_dyn_iga_cor_dsb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7BE1
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tq_cor_ctr
			"Vbx_tq_cor_ctr"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF830C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tq_cor_ovn
			"Vbx_tq_cor_ovn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF830D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tq_ctl
			"Vbx_tq_ctl"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF830E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tq_ctl_mux
			"Vbx_tq_ctl_mux"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF830F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tq_ctl_typ
			"Vbx_tq_ctl_typ"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8310
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tq_loss_ad_cdn
			"Vbx_tq_loss_ad_cdn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8311
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_tq_trs_ctl_mux
			"Vbx_tq_trs_ctl_mux"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8312
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_trame_gpl_pmh_ok
			"Vbx_trame_gpl_pmh_ok"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6EAB
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_trs_fail_det_cdn
			"Vbx_trs_fail_det_cdn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7EB2
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_trt_zon_stop
			"Vbx_trt_zon_stop"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF77B9
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_trz_clc_ena
			"Vbx_trz_clc_ena"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF80E7
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_trz_clc_ok
			"Vbx_trz_clc_ok"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF74F9
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_trz_cor_err
			"Vbx_trz_cor_err"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF74FA
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_trz_dft_in_req
			"Vbx_trz_dft_in_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF75CB
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_trz_raw_clc
			"Vbx_trz_raw_clc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF74FB
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_trz_raw_err
			"Vbx_trz_raw_err"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF74FC
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_trz_val_neg
			"Vbx_trz_val_neg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF74FD
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_ufld_cut
			"Vbx_ufld_cut"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A91
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_up_prmt_hot_cmd
			"Vbx_up_prmt_hot_cmd"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7EB3
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_up_tq_req
			"Vbx_up_tq_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8313
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_agb_rcpt
			"Vbx_vf_agb_rcpt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A8E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_air
			"Vbx_vf_air"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A8F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_bkup_mem
			"Vbx_vf_bkup_mem"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A90
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_clu
			"Vbx_vf_clu"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A91
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_cp
			"Vbx_vf_cp"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6ABD
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_crk
			"Vbx_vf_crk"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A92
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_crk_nr
			"Vbx_vf_crk_nr"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A93
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_eng_whl
			"Vbx_vf_eng_whl"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A94
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_fsys
			"Vbx_vf_fsys"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A95
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_fsys_lpg
			"Vbx_vf_fsys_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A96
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_gas_pump
			"Vbx_vf_gas_pump"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6ABE
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_igc_1
			"Vbx_vf_igc_1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6ABF
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_igc_2
			"Vbx_vf_igc_2"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AC0
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_igc_3
			"Vbx_vf_igc_3"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AC1
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_igc_4
			"Vbx_vf_igc_4"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AC2
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_inj1
			"Vbx_vf_inj1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AC3
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_inj2
			"Vbx_vf_inj2"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AC4
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_inj3
			"Vbx_vf_inj3"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AC5
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_inj4
			"Vbx_vf_inj4"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AC6
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_inj_ecu
			"Vbx_vf_inj_ecu"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A97
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_knk
			"Vbx_vf_knk"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A98
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_lbdw
			"Vbx_vf_lbdw"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AC7
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_lbdw_hot
			"Vbx_vf_lbdw_hot"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AC8
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_lbup
			"Vbx_vf_lbup"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AC9
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_lbup_hot
			"Vbx_vf_lbup_hot"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6ACA
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_lpg_rcpt
			"Vbx_vf_lpg_rcpt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A99
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_map
			"Vbx_vf_map"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A9A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_min_gas_lvl
			"Vbx_vf_min_gas_lvl"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A9B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_mis_cata
			"Vbx_vf_mis_cata"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A9C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_mis_cata_1
			"Vbx_vf_mis_cata_1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A9D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_mis_cata_1_lpg
			"Vbx_vf_mis_cata_1_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A9E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_mis_cata_2
			"Vbx_vf_mis_cata_2"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6A9F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_mis_cata_2_lpg
			"Vbx_vf_mis_cata_2_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AA0
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_mis_cata_3
			"Vbx_vf_mis_cata_3"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AA1
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_mis_cata_3_lpg
			"Vbx_vf_mis_cata_3_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AA2
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_mis_cata_4
			"Vbx_vf_mis_cata_4"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AA3
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_mis_cata_4_lpg
			"Vbx_vf_mis_cata_4_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AA4
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_mis_cata_gas
			"Vbx_vf_mis_cata_gas"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AA5
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_mis_cata_lpg
			"Vbx_vf_mis_cata_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AA6
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_mis_polu
			"Vbx_vf_mis_polu"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AA7
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_mis_polu_1
			"Vbx_vf_mis_polu_1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AA8
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_mis_polu_1_lpg
			"Vbx_vf_mis_polu_1_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AA9
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_mis_polu_2
			"Vbx_vf_mis_polu_2"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AAA
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_mis_polu_2_lpg
			"Vbx_vf_mis_polu_2_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AAB
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_mis_polu_3
			"Vbx_vf_mis_polu_3"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AAC
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_mis_polu_3_lpg
			"Vbx_vf_mis_polu_3_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AAD
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_mis_polu_4
			"Vbx_vf_mis_polu_4"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AAE
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_mis_polu_4_lpg
			"Vbx_vf_mis_polu_4_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AAF
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_mis_polu_gas
			"Vbx_vf_mis_polu_gas"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AB0
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_mis_polu_lpg
			"Vbx_vf_mis_polu_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AB1
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_obd_cata
			"Vbx_vf_obd_cata"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AB2
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_obd_lamb
			"Vbx_vf_obd_lamb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AB3
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_obd_sa
			"Vbx_vf_obd_sa"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AB4
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_pow_lbdw
			"Vbx_vf_pow_lbdw"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AB5
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_pow_lbup
			"Vbx_vf_pow_lbup"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AB6
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_rams_pdl
			"Vbx_vf_rams_pdl"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AB7
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_sa
			"Vbx_vf_sa"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6ACB
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_sa_ev
			"Vbx_vf_sa_ev"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6ACC
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_spg
			"Vbx_vf_spg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AB8
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_spg_sys
			"Vbx_vf_spg_sys"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AB9
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_tco
			"Vbx_vf_tco"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6ACD
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_tia
			"Vbx_vf_tia"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6ACE
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_tlz_ad_b
			"Vbx_vf_tlz_ad_b"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6ABA
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_vs
			"Vbx_vf_vs"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6ACF
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_vta_intake
			"Vbx_vf_vta_intake"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AD0
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_vvt_int_ev
			"Vbx_vf_vvt_int_ev"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AD1
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_vvt_int_old_off
			"Vbx_vf_vvt_int_old_off"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6ABB
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_vvt_intake
			"Vbx_vf_vvt_intake"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AD2
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_vvtc_toth_3
			"Vbx_vf_vvtc_toth_3"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6ABC
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vf_wgc
			"Vbx_vf_wgc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6AD3
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vh_mov
			"Vbx_vh_mov"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF77BA
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vld_tco
			"Vbx_vld_tco"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8589
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vld_tia
			"Vbx_vld_tia"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6D0D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vlv_eai_cmd
			"Vbx_vlv_eai_cmd"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF849E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vs_ini
			"Vbx_vs_ini"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF77BB
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vs_ip_nok
			"Vbx_vs_ip_nok"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF81AC
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vs_lk_stt
			"Vbx_vs_lk_stt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF828A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vs_main_nok
			"Vbx_vs_main_nok"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF81AD
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vs_nok
			"Vbx_vs_nok"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF81AE
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vvt_cart_iga
			"Vbx_vvt_cart_iga"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF77A4
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vvt_cart_ti
			"Vbx_vvt_cart_ti"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A92
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vvt_mov
			"Vbx_vvt_mov"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF77A5
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vvtc_3_toth_learn_dft
			"Vbx_vvtc_3_toth_learn_dft"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8512
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vvtc_act_cdn
			"Vbx_vvtc_act_cdn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF77A6
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vvtc_dft_0
			"Vbx_vvtc_dft_0"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF825C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_vvtc_dft_1
			"Vbx_vvtc_dft_1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF825D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_wet_acel_decl_ena
			"Vbx_wet_acel_decl_ena"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A93
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_wet_acel_tb_cor_ena
			"Vbx_wet_acel_tb_cor_ena"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A94
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_wet_decl_tb_cor_ena
			"Vbx_wet_decl_tb_cor_ena"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A95
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_wet_ini_acel_cdn
			"Vbx_wet_ini_acel_cdn"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF863E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_wet_ini_acel_rest_cdn
			"Vbx_wet_ini_acel_rest_cdn"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF863F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_wet_ti_clc_ena
			"Vbx_wet_ti_clc_ena"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A96
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_wf_brk_lk_stt
			"Vbx_wf_brk_lk_stt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7901
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_wf_pwst_prs
			"Vbx_wf_pwst_prs"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF77BC
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_whl_inv
			"Vbx_whl_inv"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF77BD
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_whl_lk_stt
			"Vbx_whl_lk_stt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF81AF
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_whl_psn
			"Vbx_whl_psn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF77BE
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_wpmp_cmd
			"Vbx_wpmp_cmd"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7F0E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_wpmp_cnt_stt
			"Vbx_wpmp_cnt_stt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7F0F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_wpmp_pws
			"Vbx_wpmp_pws"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7F10
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_wpmp_stop
			"Vbx_wpmp_stop"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7F11
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_wup_det
			"Vbx_wup_det"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7876
		/end MEASUREMENT
		/begin MEASUREMENT Vcpi_actual_retard
			"Vcpi_actual_retard"
			UWORD
			F_0v09375_p0_282
			2
			2
			0
			6143.90625
			ECU_ADDRESS 0xFFFF854E
		/end MEASUREMENT
		/begin MEASUREMENT Vcpi_cam_offsets_0
			"Vcpi_cam_offsets_0"
			UWORD
			F_0v09375_p0_282
			2
			2
			0
			6143.90625
			ECU_ADDRESS 0xFFFF8550
		/end MEASUREMENT
		/begin MEASUREMENT Vcpi_cam_offsets_1
			"Vcpi_cam_offsets_1"
			UWORD
			F_0v09375_p0_282
			2
			2
			0
			6143.90625
			ECU_ADDRESS 0xFFFF8552
		/end MEASUREMENT
		/begin MEASUREMENT Vcpi_cam_offsets_2
			"Vcpi_cam_offsets_2"
			UWORD
			F_0v09375_p0_282
			2
			2
			0
			6143.90625
			ECU_ADDRESS 0xFFFF8554
		/end MEASUREMENT
		/begin MEASUREMENT Vcpi_cam_offsets_3
			"Vcpi_cam_offsets_3"
			UWORD
			F_0v09375_p0_282
			2
			2
			0
			6143.90625
			ECU_ADDRESS 0xFFFF8556
		/end MEASUREMENT
		/begin MEASUREMENT Vcpi_cam_offsets_are_learned
			"Vcpi_cam_offsets_are_learned"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8513
		/end MEASUREMENT
		/begin MEASUREMENT Vcpi_cam_position_error
			"Vcpi_cam_position_error"
			SWORD
			F_0v09375_p0_282
			2
			2
			-3072
			3071.90625
			ECU_ADDRESS 0xFFFF8534
		/end MEASUREMENT
		/begin MEASUREMENT Vcpi_cam_position_error_prec
			"Vcpi_cam_position_error_prec"
			SWORD
			F_0v09375_p0_282
			2
			2
			-3072
			3071.90625
			ECU_ADDRESS 0xFFFF8536
		/end MEASUREMENT
		/begin MEASUREMENT Vcpi_current_integral
			"Vcpi_current_integral"
			UWORD
			F_0v09765625_p0_71
			2
			2
			0
			6399.902344
			ECU_ADDRESS 0xFFFF8558
		/end MEASUREMENT
		/begin MEASUREMENT Vcpi_derivative_gain
			"Vcpi_derivative_gain"
			UWORD
			F_0v0040690102_p0_326
			2
			2
			0
			266.6625835
			ECU_ADDRESS 0xFFFF855A
		/end MEASUREMENT
		/begin MEASUREMENT Vcpi_derivative_term
			"Vcpi_derivative_term"
			SWORD
			F_0v0061035156_p0_23
			2
			2
			-200
			199.9938965
			ECU_ADDRESS 0xFFFF8538
		/end MEASUREMENT
		/begin MEASUREMENT Vcpi_desired_retard
			"Vcpi_desired_retard"
			UWORD
			F_0v09375_p0_282
			2
			2
			0
			6143.90625
			ECU_ADDRESS 0xFFFF855C
		/end MEASUREMENT
		/begin MEASUREMENT Vcpi_duty_cycle
			"Vcpi_duty_cycle"
			UWORD
			F_0v09765625_p0_71
			2
			2
			0
			6399.902344
			ECU_ADDRESS 0xFFFF855E
		/end MEASUREMENT
		/begin MEASUREMENT Vcpi_edge_count
			"Vcpi_edge_count"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8528
		/end MEASUREMENT
		/begin MEASUREMENT Vcpi_high_peak_noise
			"Vcpi_high_peak_noise"
			UBYTE
			F_0v09375_p0_282
			2
			2
			0
			23.90625
			ECU_ADDRESS 0xFFFF8529
		/end MEASUREMENT
		/begin MEASUREMENT Vcpi_initial_integral_is_lrnd
			"Vcpi_initial_integral_is_lrnd"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8514
		/end MEASUREMENT
		/begin MEASUREMENT Vcpi_integral_duty_cycle
			"Vcpi_integral_duty_cycle"
			UWORD
			F_0v09765625_p0_71
			2
			2
			0
			6399.902344
			ECU_ADDRESS 0xFFFF8560
		/end MEASUREMENT
		/begin MEASUREMENT Vcpi_integral_gain
			"Vcpi_integral_gain"
			UWORD
			F_0v016276041_p0_327
			2
			2
			0
			1066.650347
			ECU_ADDRESS 0xFFFF8562
		/end MEASUREMENT
		/begin MEASUREMENT Vcpi_integral_term
			"Vcpi_integral_term"
			SWORD
			F_0v0015258789_p0_115
			2
			2
			-50
			49.99847412
			ECU_ADDRESS 0xFFFF853A
		/end MEASUREMENT
		/begin MEASUREMENT Vcpi_integral_value
			"Vcpi_integral_value"
			UWORD
			F_0v0015258789_p0_115
			2
			2
			0
			99.99847412
			ECU_ADDRESS 0xFFFF8564
		/end MEASUREMENT
		/begin MEASUREMENT Vcpi_learn_zero_counter
			"Vcpi_learn_zero_counter"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF8566
		/end MEASUREMENT
		/begin MEASUREMENT Vcpi_learning_finished
			"Vcpi_learning_finished"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8515
		/end MEASUREMENT
		/begin MEASUREMENT Vcpi_low_peak_noise
			"Vcpi_low_peak_noise"
			UBYTE
			F_0v09375_p0_282
			2
			2
			0
			23.90625
			ECU_ADDRESS 0xFFFF852A
		/end MEASUREMENT
		/begin MEASUREMENT Vcpi_noise_count
			"Vcpi_noise_count"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF8568
		/end MEASUREMENT
		/begin MEASUREMENT Vcpi_noise_is_learned
			"Vcpi_noise_is_learned"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8516
		/end MEASUREMENT
		/begin MEASUREMENT Vcpi_offset_learn_delay
			"Vcpi_offset_learn_delay"
			UWORD
			F_0v064_p0_283
			2
			2
			0
			4194.24
			ECU_ADDRESS 0xFFFF856A
		/end MEASUREMENT
		/begin MEASUREMENT Vcpi_peak_to_peak_noise
			"Vcpi_peak_to_peak_noise"
			UBYTE
			F_0v09375_p0_282
			2
			2
			0
			23.90625
			ECU_ADDRESS 0xFFFF852B
		/end MEASUREMENT
		/begin MEASUREMENT Vcpi_pid_duty_cycle
			"Vcpi_pid_duty_cycle"
			UWORD
			F_0v09765625_p0_71
			2
			2
			0
			6399.902344
			ECU_ADDRESS 0xFFFF856C
		/end MEASUREMENT
		/begin MEASUREMENT Vcpi_proportional_gain
			"Vcpi_proportional_gain"
			UWORD
			F_0v065104164_p0_328
			2
			2
			0
			4266.601388
			ECU_ADDRESS 0xFFFF856E
		/end MEASUREMENT
		/begin MEASUREMENT Vcpi_proportional_term
			"Vcpi_proportional_term"
			SWORD
			F_0v0061035156_p0_23
			2
			2
			-200
			199.9938965
			ECU_ADDRESS 0xFFFF853C
		/end MEASUREMENT
		/begin MEASUREMENT Vcpi_zero_set_timer
			"Vcpi_zero_set_timer"
			UWORD
			F_0v064_p0_283
			2
			2
			0
			4194.24
			ECU_ADDRESS 0xFFFF8570
		/end MEASUREMENT
		/begin MEASUREMENT Version_eeprom
			"Version_eeprom"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF8656
		/end MEASUREMENT
		/begin MEASUREMENT Vitesse_parasite_comptage_panne
			"Vitesse_parasite_comptage_panne"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF828B
		/end MEASUREMENT
		/begin MEASUREMENT Vsx_acc
			"Vsx_acc"
			UBYTE
			Vsx_acc_conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF7456
		/end MEASUREMENT
		/begin MEASUREMENT Vsx_aj_fil
			"Vsx_aj_fil"
			UBYTE
			Vsx_aj_fil_conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF8328
		/end MEASUREMENT
		/begin MEASUREMENT Vsx_cl_ti
			"Vsx_cl_ti"
			UBYTE
			Vsx_cl_ti_conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF7AB7
		/end MEASUREMENT
		/begin MEASUREMENT Vsx_cl_ti_lean
			"Vsx_cl_ti_lean"
			UBYTE
			Vsx_cl_ti_lean_conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF7AB8
		/end MEASUREMENT
		/begin MEASUREMENT Vsx_clos_brk_ecu_stt
			"Vsx_clos_brk_ecu_stt"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF81D4
		/end MEASUREMENT
		/begin MEASUREMENT Vsx_cp
			"Vsx_cp"
			UBYTE
			Vsx_cp_conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF80A9
		/end MEASUREMENT
		/begin MEASUREMENT Vsx_cru_sl_on_off
			"Vsx_cru_sl_on_off"
			UBYTE
			Vsx_cru_sl_on_off_conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF81D5
		/end MEASUREMENT
		/begin MEASUREMENT Vsx_cru_sl_on_off_raw
			"Vsx_cru_sl_on_off_raw"
			UBYTE
			Vsx_cru_sl_on_off_raw_conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF81D6
		/end MEASUREMENT
		/begin MEASUREMENT Vsx_cru_sl_whl_cmd_raw
			"Vsx_cru_sl_whl_cmd_raw"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF81D7
		/end MEASUREMENT
		/begin MEASUREMENT Vsx_cru_sl_whl_cmd_stt
			"Vsx_cru_sl_whl_cmd_stt"
			UBYTE
			Vsx_cru_sl_whl_cmd_stt_conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF81D8
		/end MEASUREMENT
		/begin MEASUREMENT Vsx_cru_stt
			"Vsx_cru_stt"
			UBYTE
			Vsx_cru_stt_conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF81D9
		/end MEASUREMENT
		/begin MEASUREMENT Vsx_cyl_cut
			"Vsx_cyl_cut"
			UBYTE
			Vsx_cyl_cut_conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF7D83
		/end MEASUREMENT
		/begin MEASUREMENT Vsx_eng
			"Vsx_eng"
			UBYTE
			Vsx_eng_conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF78E1
		/end MEASUREMENT
		/begin MEASUREMENT Vsx_fsys_stt
			"Vsx_fsys_stt"
			UBYTE
			Vsx_fsys_stt_conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF7D84
		/end MEASUREMENT
		/begin MEASUREMENT Vsx_gest_coup_pomp
			"Vsx_gest_coup_pomp"
			UBYTE
			Vsx_gest_coup_pomp_conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF796B
		/end MEASUREMENT
		/begin MEASUREMENT Vsx_iga
			"Vsx_iga"
			UBYTE
			Vsx_iga_conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF6DA4
		/end MEASUREMENT
		/begin MEASUREMENT Vsx_inj
			"Vsx_inj"
			UBYTE
			Vsx_inj_conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF7AB9
		/end MEASUREMENT
		/begin MEASUREMENT Vsx_is
			"Vsx_is"
			UBYTE
			Vsx_is_conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF79C2
		/end MEASUREMENT
		/begin MEASUREMENT Vsx_lpg_coup_aut
			"Vsx_lpg_coup_aut"
			UBYTE
			Vsx_lpg_coup_aut_conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF796C
		/end MEASUREMENT
		/begin MEASUREMENT Vsx_lpg_eng_run_mod
			"Vsx_lpg_eng_run_mod"
			UBYTE
			Vsx_lpg_eng_run_mod_conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF796D
		/end MEASUREMENT
		/begin MEASUREMENT Vsx_lpg_mod
			"Vsx_lpg_mod"
			UBYTE
			Vsx_lpg_mod_conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF796E
		/end MEASUREMENT
		/begin MEASUREMENT Vsx_lpg_mod_req
			"Vsx_lpg_mod_req"
			UBYTE
			Vsx_lpg_mod_req_conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF796F
		/end MEASUREMENT
		/begin MEASUREMENT Vsx_mdf_cmd
			"Vsx_mdf_cmd"
			UBYTE
			Vsx_mdf_cmd_conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF792A
		/end MEASUREMENT
		/begin MEASUREMENT Vsx_mis_lih_cyl_chk
			"Vsx_mis_lih_cyl_chk"
			UBYTE
			Vsx_mis_lih_cyl_chk_conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF7D85
		/end MEASUREMENT
		/begin MEASUREMENT Vsx_mis_lih_stt
			"Vsx_mis_lih_stt"
			UBYTE
			Vsx_mis_lih_stt_conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF7D86
		/end MEASUREMENT
		/begin MEASUREMENT Vsx_mvac_pump
			"Vsx_mvac_pump"
			UBYTE
			Vsx_mvac_pump_conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF7905
		/end MEASUREMENT
		/begin MEASUREMENT Vsx_rich_cl
			"Vsx_rich_cl"
			UBYTE
			Vsx_rich_cl_conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF7ABA
		/end MEASUREMENT
		/begin MEASUREMENT Vsx_rvr_mgb_ecu_stt
			"Vsx_rvr_mgb_ecu_stt"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF81DA
		/end MEASUREMENT
		/begin MEASUREMENT Vsx_sl_stt
			"Vsx_sl_stt"
			UBYTE
			Vsx_sl_stt_conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF81DB
		/end MEASUREMENT
		/begin MEASUREMENT Vsx_slow_tq_lh_sp
			"Vsx_slow_tq_lh_sp"
			UBYTE
			Vsx_slow_tq_lh_sp_conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF8329
		/end MEASUREMENT
		/begin MEASUREMENT Vsx_tlz_ad_cor_stt
			"Vsx_tlz_ad_cor_stt"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7520
		/end MEASUREMENT
		/begin MEASUREMENT Vsx_vs_ecu_stt
			"Vsx_vs_ecu_stt"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF81DC
		/end MEASUREMENT
		/begin MEASUREMENT Vsx_warn_stt
			"Vsx_warn_stt"
			UBYTE
			Vsx_warn_stt_conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF81DD
		/end MEASUREMENT
		/begin MEASUREMENT Vsx_wpmp
			"Vsx_wpmp"
			UBYTE
			Vsx_wpmp_conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF7F17
		/end MEASUREMENT
		/begin MEASUREMENT Vta_intake_allow_delay
			"Vta_intake_allow_delay"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8517
		/end MEASUREMENT
		/begin MEASUREMENT Vta_intake_allow_learning
			"Vta_intake_allow_learning"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8518
		/end MEASUREMENT
		/begin MEASUREMENT Vta_intake_allow_run_learning
			"Vta_intake_allow_run_learning"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8519
		/end MEASUREMENT
		/begin MEASUREMENT Vta_intake_block_failure_tempo
			"Vta_intake_block_failure_tempo"
			UBYTE
			F_16_p0_10
			2
			2
			0
			4080
			ECU_ADDRESS 0xFFFF852C
		/end MEASUREMENT
		/begin MEASUREMENT Vta_intake_cam_off_mes_0
			"Vta_intake_cam_off_mes_0"
			UWORD
			F_0v09375_p0_282
			2
			2
			0
			6143.90625
			ECU_ADDRESS 0xFFFF8572
		/end MEASUREMENT
		/begin MEASUREMENT Vta_intake_cam_off_mes_1
			"Vta_intake_cam_off_mes_1"
			UWORD
			F_0v09375_p0_282
			2
			2
			0
			6143.90625
			ECU_ADDRESS 0xFFFF8574
		/end MEASUREMENT
		/begin MEASUREMENT Vta_intake_cam_off_mes_2
			"Vta_intake_cam_off_mes_2"
			UWORD
			F_0v09375_p0_282
			2
			2
			0
			6143.90625
			ECU_ADDRESS 0xFFFF8576
		/end MEASUREMENT
		/begin MEASUREMENT Vta_intake_cam_off_mes_3
			"Vta_intake_cam_off_mes_3"
			UWORD
			F_0v09375_p0_282
			2
			2
			0
			6143.90625
			ECU_ADDRESS 0xFFFF8578
		/end MEASUREMENT
		/begin MEASUREMENT Vta_intake_cam_old_off_eep_0
			"Vta_intake_cam_old_off_eep_0"
			UWORD
			F_0v09375_p0_282
			2
			2
			0
			6143.90625
			ECU_ADDRESS 0xFFFF88CC
		/end MEASUREMENT
		/begin MEASUREMENT Vta_intake_cam_old_off_eep_1
			"Vta_intake_cam_old_off_eep_1"
			UWORD
			F_0v09375_p0_282
			2
			2
			0
			6143.90625
			ECU_ADDRESS 0xFFFF88CE
		/end MEASUREMENT
		/begin MEASUREMENT Vta_intake_cam_old_off_eep_2
			"Vta_intake_cam_old_off_eep_2"
			UWORD
			F_0v09375_p0_282
			2
			2
			0
			6143.90625
			ECU_ADDRESS 0xFFFF88D0
		/end MEASUREMENT
		/begin MEASUREMENT Vta_intake_cam_old_off_eep_3
			"Vta_intake_cam_old_off_eep_3"
			UWORD
			F_0v09375_p0_282
			2
			2
			0
			6143.90625
			ECU_ADDRESS 0xFFFF88D2
		/end MEASUREMENT
		/begin MEASUREMENT Vta_intake_camshaft_angle
			"Vta_intake_camshaft_angle"
			UWORD
			F_0v09375_p0_282
			2
			2
			0
			6143.90625
			ECU_ADDRESS 0xFFFF857A
		/end MEASUREMENT
		/begin MEASUREMENT Vta_intake_camshaft_shift
			"Vta_intake_camshaft_shift"
			SWORD
			F_0v09375_p0_282
			2
			2
			-3072
			3071.90625
			ECU_ADDRESS 0xFFFF853E
		/end MEASUREMENT
		/begin MEASUREMENT Vta_intake_camshaft_velocity
			"Vta_intake_camshaft_velocity"
			SWORD
			F_0v09375_p0_329
			2
			2
			-3072
			3071.90625
			ECU_ADDRESS 0xFFFF8540
		/end MEASUREMENT
		/begin MEASUREMENT Vta_intake_camshaft_velocity_1
			"Vta_intake_camshaft_velocity_1"
			SWORD
			F_0v09375_p0_330
			2
			2
			-3072
			3071.90625
			ECU_ADDRESS 0xFFFF8542
		/end MEASUREMENT
		/begin MEASUREMENT Vta_intake_camshaft_velocity_2
			"Vta_intake_camshaft_velocity_2"
			SWORD
			F_0v09375_p0_330
			2
			2
			-3072
			3071.90625
			ECU_ADDRESS 0xFFFF8544
		/end MEASUREMENT
		/begin MEASUREMENT Vta_intake_filt_velocity
			"Vta_intake_filt_velocity"
			SWORD
			F_0v09375_p0_330
			2
			2
			-3072
			3071.90625
			ECU_ADDRESS 0xFFFF8546
		/end MEASUREMENT
		/begin MEASUREMENT Vta_intake_force_off_learn_prev
			"Vta_intake_force_off_learn_prev"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF851A
		/end MEASUREMENT
		/begin MEASUREMENT Vta_intake_hot_learning
			"Vta_intake_hot_learning"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF851B
		/end MEASUREMENT
		/begin MEASUREMENT Vta_intake_hot_offsets
			"Vta_intake_hot_offsets"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF851C
		/end MEASUREMENT
		/begin MEASUREMENT Vta_intake_inh_old_off_eep
			"Vta_intake_inh_old_off_eep"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF88D4
		/end MEASUREMENT
		/begin MEASUREMENT Vta_intake_int_failure_tempo
			"Vta_intake_int_failure_tempo"
			UBYTE
			F_16_p0_10
			2
			2
			0
			4080
			ECU_ADDRESS 0xFFFF852D
		/end MEASUREMENT
		/begin MEASUREMENT Vta_intake_learn_failure
			"Vta_intake_learn_failure"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF851D
		/end MEASUREMENT
		/begin MEASUREMENT Vta_intake_learn_tempo
			"Vta_intake_learn_tempo"
			UBYTE
			F_4v096_p0_12
			2
			2
			0
			1044.48
			ECU_ADDRESS 0xFFFF852E
		/end MEASUREMENT
		/begin MEASUREMENT Vta_intake_min_reg_ok
			"Vta_intake_min_reg_ok"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF851E
		/end MEASUREMENT
		/begin MEASUREMENT Vta_intake_pmh_counter
			"Vta_intake_pmh_counter"
			UBYTE
			F_1_p0_53
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6BAD
		/end MEASUREMENT
		/begin MEASUREMENT Vta_intake_speed_sp
			"Vta_intake_speed_sp"
			SWORD
			F_0v09375_p0_330
			2
			2
			-3072
			3071.90625
			ECU_ADDRESS 0xFFFF77B0
		/end MEASUREMENT
		/begin MEASUREMENT Vta_intake_time
			"Vta_intake_time"
			UWORD
			F_3v2_p0_152
			2
			2
			0
			209712
			ECU_ADDRESS 0xFFFF857C
		/end MEASUREMENT
		/begin MEASUREMENT Vta_intake_time_prec
			"Vta_intake_time_prec"
			UWORD
			F_3v2_p0_152
			2
			2
			0
			209712
			ECU_ADDRESS 0xFFFF857E
		/end MEASUREMENT
		/begin MEASUREMENT Vta_intake_tooth_counter
			"Vta_intake_tooth_counter"
			UBYTE
			F_1_p0_9
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF852F
		/end MEASUREMENT
		/begin MEASUREMENT Vta_intake_tooth_time
			"Vta_intake_tooth_time"
			UWORD
			F_0v0078125_p0_335
			2
			2
			0
			511.9921875
			ECU_ADDRESS 0xFFFF8580
		/end MEASUREMENT
		/begin MEASUREMENT Vta_intake_velocity_set
			"Vta_intake_velocity_set"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF851F
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_cor_thr_ar_elt_0
			"Vtb_cor_thr_ar_elt_0"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6C32
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_cor_thr_ar_elt_1
			"Vtb_cor_thr_ar_elt_1"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6C34
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_cor_thr_ar_elt_10
			"Vtb_cor_thr_ar_elt_10"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6C46
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_cor_thr_ar_elt_11
			"Vtb_cor_thr_ar_elt_11"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6C48
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_cor_thr_ar_elt_12
			"Vtb_cor_thr_ar_elt_12"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6C4A
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_cor_thr_ar_elt_13
			"Vtb_cor_thr_ar_elt_13"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6C4C
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_cor_thr_ar_elt_14
			"Vtb_cor_thr_ar_elt_14"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6C4E
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_cor_thr_ar_elt_15
			"Vtb_cor_thr_ar_elt_15"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6C50
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_cor_thr_ar_elt_16
			"Vtb_cor_thr_ar_elt_16"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6C52
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_cor_thr_ar_elt_2
			"Vtb_cor_thr_ar_elt_2"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6C36
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_cor_thr_ar_elt_3
			"Vtb_cor_thr_ar_elt_3"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6C38
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_cor_thr_ar_elt_4
			"Vtb_cor_thr_ar_elt_4"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6C3A
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_cor_thr_ar_elt_5
			"Vtb_cor_thr_ar_elt_5"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6C3C
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_cor_thr_ar_elt_6
			"Vtb_cor_thr_ar_elt_6"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6C3E
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_cor_thr_ar_elt_7
			"Vtb_cor_thr_ar_elt_7"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6C40
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_cor_thr_ar_elt_8
			"Vtb_cor_thr_ar_elt_8"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6C42
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_cor_thr_ar_elt_9
			"Vtb_cor_thr_ar_elt_9"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6C44
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_int_thr_ar_elt_0
			"Vtb_int_thr_ar_elt_0"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6C54
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_int_thr_ar_elt_1
			"Vtb_int_thr_ar_elt_1"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6C56
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_int_thr_ar_elt_10
			"Vtb_int_thr_ar_elt_10"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6C68
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_int_thr_ar_elt_11
			"Vtb_int_thr_ar_elt_11"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6C6A
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_int_thr_ar_elt_12
			"Vtb_int_thr_ar_elt_12"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6C6C
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_int_thr_ar_elt_13
			"Vtb_int_thr_ar_elt_13"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6C6E
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_int_thr_ar_elt_14
			"Vtb_int_thr_ar_elt_14"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6C70
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_int_thr_ar_elt_15
			"Vtb_int_thr_ar_elt_15"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6C72
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_int_thr_ar_elt_16
			"Vtb_int_thr_ar_elt_16"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6C74
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_int_thr_ar_elt_2
			"Vtb_int_thr_ar_elt_2"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6C58
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_int_thr_ar_elt_3
			"Vtb_int_thr_ar_elt_3"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6C5A
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_int_thr_ar_elt_4
			"Vtb_int_thr_ar_elt_4"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6C5C
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_int_thr_ar_elt_5
			"Vtb_int_thr_ar_elt_5"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6C5E
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_int_thr_ar_elt_6
			"Vtb_int_thr_ar_elt_6"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6C60
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_int_thr_ar_elt_7
			"Vtb_int_thr_ar_elt_7"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6C62
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_int_thr_ar_elt_8
			"Vtb_int_thr_ar_elt_8"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6C64
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_int_thr_ar_elt_9
			"Vtb_int_thr_ar_elt_9"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6C66
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_lim_thr_ar_elt_0
			"Vtb_lim_thr_ar_elt_0"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6C76
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_lim_thr_ar_elt_1
			"Vtb_lim_thr_ar_elt_1"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6C78
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_lim_thr_ar_elt_10
			"Vtb_lim_thr_ar_elt_10"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6C8A
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_lim_thr_ar_elt_11
			"Vtb_lim_thr_ar_elt_11"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6C8C
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_lim_thr_ar_elt_12
			"Vtb_lim_thr_ar_elt_12"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6C8E
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_lim_thr_ar_elt_13
			"Vtb_lim_thr_ar_elt_13"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6C90
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_lim_thr_ar_elt_14
			"Vtb_lim_thr_ar_elt_14"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6C92
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_lim_thr_ar_elt_15
			"Vtb_lim_thr_ar_elt_15"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6C94
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_lim_thr_ar_elt_16
			"Vtb_lim_thr_ar_elt_16"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6C96
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_lim_thr_ar_elt_2
			"Vtb_lim_thr_ar_elt_2"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6C7A
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_lim_thr_ar_elt_3
			"Vtb_lim_thr_ar_elt_3"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6C7C
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_lim_thr_ar_elt_4
			"Vtb_lim_thr_ar_elt_4"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6C7E
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_lim_thr_ar_elt_5
			"Vtb_lim_thr_ar_elt_5"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6C80
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_lim_thr_ar_elt_6
			"Vtb_lim_thr_ar_elt_6"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6C82
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_lim_thr_ar_elt_7
			"Vtb_lim_thr_ar_elt_7"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6C84
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_lim_thr_ar_elt_8
			"Vtb_lim_thr_ar_elt_8"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6C86
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_lim_thr_ar_elt_9
			"Vtb_lim_thr_ar_elt_9"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6C88
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_thr_ar_elt_0
			"Vtb_thr_ar_elt_0"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6C98
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_thr_ar_elt_1
			"Vtb_thr_ar_elt_1"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6C9A
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_thr_ar_elt_10
			"Vtb_thr_ar_elt_10"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6CAC
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_thr_ar_elt_11
			"Vtb_thr_ar_elt_11"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6CAE
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_thr_ar_elt_12
			"Vtb_thr_ar_elt_12"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6CB0
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_thr_ar_elt_13
			"Vtb_thr_ar_elt_13"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6CB2
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_thr_ar_elt_14
			"Vtb_thr_ar_elt_14"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6CB4
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_thr_ar_elt_15
			"Vtb_thr_ar_elt_15"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6CB6
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_thr_ar_elt_16
			"Vtb_thr_ar_elt_16"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6CB8
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_thr_ar_elt_2
			"Vtb_thr_ar_elt_2"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6C9C
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_thr_ar_elt_3
			"Vtb_thr_ar_elt_3"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6C9E
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_thr_ar_elt_4
			"Vtb_thr_ar_elt_4"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6CA0
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_thr_ar_elt_5
			"Vtb_thr_ar_elt_5"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6CA2
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_thr_ar_elt_6
			"Vtb_thr_ar_elt_6"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6CA4
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_thr_ar_elt_7
			"Vtb_thr_ar_elt_7"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6CA6
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_thr_ar_elt_8
			"Vtb_thr_ar_elt_8"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6CA8
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_thr_ar_elt_9
			"Vtb_thr_ar_elt_9"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6CAA
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_thr_ar_mem_elt_0
			"Vtb_thr_ar_mem_elt_0"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF894A
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_thr_ar_mem_elt_1
			"Vtb_thr_ar_mem_elt_1"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF894C
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_thr_ar_mem_elt_10
			"Vtb_thr_ar_mem_elt_10"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF895E
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_thr_ar_mem_elt_11
			"Vtb_thr_ar_mem_elt_11"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF8960
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_thr_ar_mem_elt_12
			"Vtb_thr_ar_mem_elt_12"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF8962
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_thr_ar_mem_elt_13
			"Vtb_thr_ar_mem_elt_13"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF8964
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_thr_ar_mem_elt_14
			"Vtb_thr_ar_mem_elt_14"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF8966
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_thr_ar_mem_elt_15
			"Vtb_thr_ar_mem_elt_15"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF8968
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_thr_ar_mem_elt_16
			"Vtb_thr_ar_mem_elt_16"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF896A
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_thr_ar_mem_elt_2
			"Vtb_thr_ar_mem_elt_2"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF894E
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_thr_ar_mem_elt_3
			"Vtb_thr_ar_mem_elt_3"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF8950
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_thr_ar_mem_elt_4
			"Vtb_thr_ar_mem_elt_4"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF8952
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_thr_ar_mem_elt_5
			"Vtb_thr_ar_mem_elt_5"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF8954
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_thr_ar_mem_elt_6
			"Vtb_thr_ar_mem_elt_6"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF8956
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_thr_ar_mem_elt_7
			"Vtb_thr_ar_mem_elt_7"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF8958
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_thr_ar_mem_elt_8
			"Vtb_thr_ar_mem_elt_8"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF895A
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_thr_ar_mem_elt_9
			"Vtb_thr_ar_mem_elt_9"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF895C
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_thr_ar_raw_elt_0
			"Vtb_thr_ar_raw_elt_0"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6CBA
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_thr_ar_raw_elt_1
			"Vtb_thr_ar_raw_elt_1"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6CBC
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_thr_ar_raw_elt_10
			"Vtb_thr_ar_raw_elt_10"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6CCE
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_thr_ar_raw_elt_11
			"Vtb_thr_ar_raw_elt_11"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6CD0
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_thr_ar_raw_elt_12
			"Vtb_thr_ar_raw_elt_12"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6CD2
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_thr_ar_raw_elt_13
			"Vtb_thr_ar_raw_elt_13"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6CD4
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_thr_ar_raw_elt_14
			"Vtb_thr_ar_raw_elt_14"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6CD6
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_thr_ar_raw_elt_15
			"Vtb_thr_ar_raw_elt_15"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6CD8
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_thr_ar_raw_elt_16
			"Vtb_thr_ar_raw_elt_16"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6CDA
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_thr_ar_raw_elt_2
			"Vtb_thr_ar_raw_elt_2"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6CBE
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_thr_ar_raw_elt_3
			"Vtb_thr_ar_raw_elt_3"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6CC0
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_thr_ar_raw_elt_4
			"Vtb_thr_ar_raw_elt_4"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6CC2
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_thr_ar_raw_elt_5
			"Vtb_thr_ar_raw_elt_5"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6CC4
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_thr_ar_raw_elt_6
			"Vtb_thr_ar_raw_elt_6"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6CC6
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_thr_ar_raw_elt_7
			"Vtb_thr_ar_raw_elt_7"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6CC8
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_thr_ar_raw_elt_8
			"Vtb_thr_ar_raw_elt_8"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6CCA
		/end MEASUREMENT
		/begin MEASUREMENT Vtb_thr_ar_raw_elt_9
			"Vtb_thr_ar_raw_elt_9"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF6CCC
		/end MEASUREMENT
		/begin MEASUREMENT Vtd_acq_knk_cyl1
			"Vtd_acq_knk_cyl1"
			UWORD
			F_0v0763_p0_336
			2
			2
			0
			5000.3205
			ECU_ADDRESS 0xFFFF74D6
		/end MEASUREMENT
		/begin MEASUREMENT Vtd_acq_knk_cyl2
			"Vtd_acq_knk_cyl2"
			UWORD
			F_0v0763_p0_336
			2
			2
			0
			5000.3205
			ECU_ADDRESS 0xFFFF74DC
		/end MEASUREMENT
		/begin MEASUREMENT Vtd_acq_knk_cyl3
			"Vtd_acq_knk_cyl3"
			UWORD
			F_0v0763_p0_336
			2
			2
			0
			5000.3205
			ECU_ADDRESS 0xFFFF74D8
		/end MEASUREMENT
		/begin MEASUREMENT Vtd_acq_knk_cyl4
			"Vtd_acq_knk_cyl4"
			UWORD
			F_0v0763_p0_336
			2
			2
			0
			5000.3205
			ECU_ADDRESS 0xFFFF74DA
		/end MEASUREMENT
		/begin MEASUREMENT Vtd_cyl_aftr_inj
			"Vtd_cyl_aftr_inj"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7BA9
		/end MEASUREMENT
		/begin MEASUREMENT Vtd_fil_acq_knk_cyl1
			"Vtd_fil_acq_knk_cyl1"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7486
		/end MEASUREMENT
		/begin MEASUREMENT Vtd_fil_acq_knk_cyl2
			"Vtd_fil_acq_knk_cyl2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7489
		/end MEASUREMENT
		/begin MEASUREMENT Vtd_fil_acq_knk_cyl3
			"Vtd_fil_acq_knk_cyl3"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7487
		/end MEASUREMENT
		/begin MEASUREMENT Vtd_fil_acq_knk_cyl4
			"Vtd_fil_acq_knk_cyl4"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7488
		/end MEASUREMENT
		/begin MEASUREMENT Vtd_fil_knk_noi_cyl1
			"Vtd_fil_knk_noi_cyl1"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF74DE
		/end MEASUREMENT
		/begin MEASUREMENT Vtd_fil_knk_noi_cyl2
			"Vtd_fil_knk_noi_cyl2"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF74E4
		/end MEASUREMENT
		/begin MEASUREMENT Vtd_fil_knk_noi_cyl3
			"Vtd_fil_knk_noi_cyl3"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF74E0
		/end MEASUREMENT
		/begin MEASUREMENT Vtd_fil_knk_noi_cyl4
			"Vtd_fil_knk_noi_cyl4"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF74E2
		/end MEASUREMENT
		/begin MEASUREMENT Vtd_knk_ctr_cyl1
			"Vtd_knk_ctr_cyl1"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF86C4
		/end MEASUREMENT
		/begin MEASUREMENT Vtd_knk_ctr_cyl2
			"Vtd_knk_ctr_cyl2"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF86CA
		/end MEASUREMENT
		/begin MEASUREMENT Vtd_knk_ctr_cyl3
			"Vtd_knk_ctr_cyl3"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF86C6
		/end MEASUREMENT
		/begin MEASUREMENT Vtd_knk_ctr_cyl4
			"Vtd_knk_ctr_cyl4"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF86C8
		/end MEASUREMENT
		/begin MEASUREMENT Vtd_knk_det_cyl1
			"Vtd_knk_det_cyl1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF748A
		/end MEASUREMENT
		/begin MEASUREMENT Vtd_knk_det_cyl2
			"Vtd_knk_det_cyl2"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF748D
		/end MEASUREMENT
		/begin MEASUREMENT Vtd_knk_det_cyl3
			"Vtd_knk_det_cyl3"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF748B
		/end MEASUREMENT
		/begin MEASUREMENT Vtd_knk_det_cyl4
			"Vtd_knk_det_cyl4"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF748C
		/end MEASUREMENT
		/begin MEASUREMENT Vtd_knk_det_err_cyl1
			"Vtd_knk_det_err_cyl1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6DA5
		/end MEASUREMENT
		/begin MEASUREMENT Vtd_knk_det_err_cyl2
			"Vtd_knk_det_err_cyl2"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x8
			ECU_ADDRESS 0xFFFF6DA5
		/end MEASUREMENT
		/begin MEASUREMENT Vtd_knk_det_err_cyl3
			"Vtd_knk_det_err_cyl3"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x2
			ECU_ADDRESS 0xFFFF6DA5
		/end MEASUREMENT
		/begin MEASUREMENT Vtd_knk_det_err_cyl4
			"Vtd_knk_det_err_cyl4"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x4
			ECU_ADDRESS 0xFFFF6DA5
		/end MEASUREMENT
		/begin MEASUREMENT Vtd_knk_fast_cor_iga_cyl1
			"Vtd_knk_fast_cor_iga_cyl1"
			UBYTE
			F_0v375_p0_29
			2
			2
			0
			95.625
			ECU_ADDRESS 0xFFFF6DA6
		/end MEASUREMENT
		/begin MEASUREMENT Vtd_knk_fast_cor_iga_cyl2
			"Vtd_knk_fast_cor_iga_cyl2"
			UBYTE
			F_0v375_p0_29
			2
			2
			0
			95.625
			ECU_ADDRESS 0xFFFF6DA9
		/end MEASUREMENT
		/begin MEASUREMENT Vtd_knk_fast_cor_iga_cyl3
			"Vtd_knk_fast_cor_iga_cyl3"
			UBYTE
			F_0v375_p0_29
			2
			2
			0
			95.625
			ECU_ADDRESS 0xFFFF6DA7
		/end MEASUREMENT
		/begin MEASUREMENT Vtd_knk_fast_cor_iga_cyl4
			"Vtd_knk_fast_cor_iga_cyl4"
			UBYTE
			F_0v375_p0_29
			2
			2
			0
			95.625
			ECU_ADDRESS 0xFFFF6DA8
		/end MEASUREMENT
		/begin MEASUREMENT Vtd_knk_iga_cor_appl_cyl1
			"Vtd_knk_iga_cor_appl_cyl1"
			UBYTE
			F_0v375_p0_29
			2
			2
			0
			95.625
			ECU_ADDRESS 0xFFFF6DAA
		/end MEASUREMENT
		/begin MEASUREMENT Vtd_knk_iga_cor_appl_cyl2
			"Vtd_knk_iga_cor_appl_cyl2"
			UBYTE
			F_0v375_p0_29
			2
			2
			0
			95.625
			ECU_ADDRESS 0xFFFF6DAD
		/end MEASUREMENT
		/begin MEASUREMENT Vtd_knk_iga_cor_appl_cyl3
			"Vtd_knk_iga_cor_appl_cyl3"
			UBYTE
			F_0v375_p0_29
			2
			2
			0
			95.625
			ECU_ADDRESS 0xFFFF6DAB
		/end MEASUREMENT
		/begin MEASUREMENT Vtd_knk_iga_cor_appl_cyl4
			"Vtd_knk_iga_cor_appl_cyl4"
			UBYTE
			F_0v375_p0_29
			2
			2
			0
			95.625
			ECU_ADDRESS 0xFFFF6DAC
		/end MEASUREMENT
		/begin MEASUREMENT Vtd_knk_slow_cor_iga_cyl1
			"Vtd_knk_slow_cor_iga_cyl1"
			UBYTE
			F_0v375_p0_29
			2
			2
			0
			95.625
			ECU_ADDRESS 0xFFFF86D0
		/end MEASUREMENT
		/begin MEASUREMENT Vtd_knk_slow_cor_iga_cyl2
			"Vtd_knk_slow_cor_iga_cyl2"
			UBYTE
			F_0v375_p0_29
			2
			2
			0
			95.625
			ECU_ADDRESS 0xFFFF86D3
		/end MEASUREMENT
		/begin MEASUREMENT Vtd_knk_slow_cor_iga_cyl3
			"Vtd_knk_slow_cor_iga_cyl3"
			UBYTE
			F_0v375_p0_29
			2
			2
			0
			95.625
			ECU_ADDRESS 0xFFFF86D1
		/end MEASUREMENT
		/begin MEASUREMENT Vtd_knk_slow_cor_iga_cyl4
			"Vtd_knk_slow_cor_iga_cyl4"
			UBYTE
			F_0v375_p0_29
			2
			2
			0
			95.625
			ECU_ADDRESS 0xFFFF86D2
		/end MEASUREMENT
		/begin MEASUREMENT Vtd_ti_ad1_zon
			"Vtd_ti_ad1_zon"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8692
		/end MEASUREMENT
		/begin MEASUREMENT Vtd_ti_ad4_zon
			"Vtd_ti_ad4_zon"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A97
		/end MEASUREMENT
		/begin MEASUREMENT Vtd_ti_b_med
			"Vtd_ti_b_med"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7AC0
		/end MEASUREMENT
		/begin MEASUREMENT Vtp_act_ocl_dly
			"Vtp_act_ocl_dly"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A98
		/end MEASUREMENT
		/begin MEASUREMENT Vtp_n_thr_ar_elt_0
			"Vtp_n_thr_ar_elt_0"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF7FCA
		/end MEASUREMENT
		/begin MEASUREMENT Vtp_n_thr_ar_elt_1
			"Vtp_n_thr_ar_elt_1"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF7FCC
		/end MEASUREMENT
		/begin MEASUREMENT Vtp_n_thr_ar_elt_10
			"Vtp_n_thr_ar_elt_10"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF7FDE
		/end MEASUREMENT
		/begin MEASUREMENT Vtp_n_thr_ar_elt_11
			"Vtp_n_thr_ar_elt_11"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF7FE0
		/end MEASUREMENT
		/begin MEASUREMENT Vtp_n_thr_ar_elt_12
			"Vtp_n_thr_ar_elt_12"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF7FE2
		/end MEASUREMENT
		/begin MEASUREMENT Vtp_n_thr_ar_elt_13
			"Vtp_n_thr_ar_elt_13"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF7FE4
		/end MEASUREMENT
		/begin MEASUREMENT Vtp_n_thr_ar_elt_14
			"Vtp_n_thr_ar_elt_14"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF7FE6
		/end MEASUREMENT
		/begin MEASUREMENT Vtp_n_thr_ar_elt_15
			"Vtp_n_thr_ar_elt_15"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF7FE8
		/end MEASUREMENT
		/begin MEASUREMENT Vtp_n_thr_ar_elt_16
			"Vtp_n_thr_ar_elt_16"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF7FEA
		/end MEASUREMENT
		/begin MEASUREMENT Vtp_n_thr_ar_elt_2
			"Vtp_n_thr_ar_elt_2"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF7FCE
		/end MEASUREMENT
		/begin MEASUREMENT Vtp_n_thr_ar_elt_3
			"Vtp_n_thr_ar_elt_3"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF7FD0
		/end MEASUREMENT
		/begin MEASUREMENT Vtp_n_thr_ar_elt_4
			"Vtp_n_thr_ar_elt_4"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF7FD2
		/end MEASUREMENT
		/begin MEASUREMENT Vtp_n_thr_ar_elt_5
			"Vtp_n_thr_ar_elt_5"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF7FD4
		/end MEASUREMENT
		/begin MEASUREMENT Vtp_n_thr_ar_elt_6
			"Vtp_n_thr_ar_elt_6"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF7FD6
		/end MEASUREMENT
		/begin MEASUREMENT Vtp_n_thr_ar_elt_7
			"Vtp_n_thr_ar_elt_7"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF7FD8
		/end MEASUREMENT
		/begin MEASUREMENT Vtp_n_thr_ar_elt_8
			"Vtp_n_thr_ar_elt_8"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF7FDA
		/end MEASUREMENT
		/begin MEASUREMENT Vtp_n_thr_ar_elt_9
			"Vtp_n_thr_ar_elt_9"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF7FDC
		/end MEASUREMENT
		/begin MEASUREMENT Vtx_fac_cor_thr_adj_elt_0
			"Vtx_fac_cor_thr_adj_elt_0"
			UWORD
			F_3v05176_p900000_337
			2
			2
			900000
			1099997.092
			ECU_ADDRESS 0xFFFF6CDC
		/end MEASUREMENT
		/begin MEASUREMENT Vtx_fac_cor_thr_adj_elt_1
			"Vtx_fac_cor_thr_adj_elt_1"
			UWORD
			F_3v05176_p900000_337
			2
			2
			900000
			1099997.092
			ECU_ADDRESS 0xFFFF6CDE
		/end MEASUREMENT
		/begin MEASUREMENT Vtx_fac_cor_thr_adj_elt_10
			"Vtx_fac_cor_thr_adj_elt_10"
			UWORD
			F_3v05176_p900000_337
			2
			2
			900000
			1099997.092
			ECU_ADDRESS 0xFFFF6CF0
		/end MEASUREMENT
		/begin MEASUREMENT Vtx_fac_cor_thr_adj_elt_11
			"Vtx_fac_cor_thr_adj_elt_11"
			UWORD
			F_3v05176_p900000_337
			2
			2
			900000
			1099997.092
			ECU_ADDRESS 0xFFFF6CF2
		/end MEASUREMENT
		/begin MEASUREMENT Vtx_fac_cor_thr_adj_elt_12
			"Vtx_fac_cor_thr_adj_elt_12"
			UWORD
			F_3v05176_p900000_337
			2
			2
			900000
			1099997.092
			ECU_ADDRESS 0xFFFF6CF4
		/end MEASUREMENT
		/begin MEASUREMENT Vtx_fac_cor_thr_adj_elt_13
			"Vtx_fac_cor_thr_adj_elt_13"
			UWORD
			F_3v05176_p900000_337
			2
			2
			900000
			1099997.092
			ECU_ADDRESS 0xFFFF6CF6
		/end MEASUREMENT
		/begin MEASUREMENT Vtx_fac_cor_thr_adj_elt_14
			"Vtx_fac_cor_thr_adj_elt_14"
			UWORD
			F_3v05176_p900000_337
			2
			2
			900000
			1099997.092
			ECU_ADDRESS 0xFFFF6CF8
		/end MEASUREMENT
		/begin MEASUREMENT Vtx_fac_cor_thr_adj_elt_15
			"Vtx_fac_cor_thr_adj_elt_15"
			UWORD
			F_3v05176_p900000_337
			2
			2
			900000
			1099997.092
			ECU_ADDRESS 0xFFFF6CFA
		/end MEASUREMENT
		/begin MEASUREMENT Vtx_fac_cor_thr_adj_elt_16
			"Vtx_fac_cor_thr_adj_elt_16"
			UWORD
			F_3v05176_p900000_337
			2
			2
			900000
			1099997.092
			ECU_ADDRESS 0xFFFF6CFC
		/end MEASUREMENT
		/begin MEASUREMENT Vtx_fac_cor_thr_adj_elt_2
			"Vtx_fac_cor_thr_adj_elt_2"
			UWORD
			F_3v05176_p900000_337
			2
			2
			900000
			1099997.092
			ECU_ADDRESS 0xFFFF6CE0
		/end MEASUREMENT
		/begin MEASUREMENT Vtx_fac_cor_thr_adj_elt_3
			"Vtx_fac_cor_thr_adj_elt_3"
			UWORD
			F_3v05176_p900000_337
			2
			2
			900000
			1099997.092
			ECU_ADDRESS 0xFFFF6CE2
		/end MEASUREMENT
		/begin MEASUREMENT Vtx_fac_cor_thr_adj_elt_4
			"Vtx_fac_cor_thr_adj_elt_4"
			UWORD
			F_3v05176_p900000_337
			2
			2
			900000
			1099997.092
			ECU_ADDRESS 0xFFFF6CE4
		/end MEASUREMENT
		/begin MEASUREMENT Vtx_fac_cor_thr_adj_elt_5
			"Vtx_fac_cor_thr_adj_elt_5"
			UWORD
			F_3v05176_p900000_337
			2
			2
			900000
			1099997.092
			ECU_ADDRESS 0xFFFF6CE6
		/end MEASUREMENT
		/begin MEASUREMENT Vtx_fac_cor_thr_adj_elt_6
			"Vtx_fac_cor_thr_adj_elt_6"
			UWORD
			F_3v05176_p900000_337
			2
			2
			900000
			1099997.092
			ECU_ADDRESS 0xFFFF6CE8
		/end MEASUREMENT
		/begin MEASUREMENT Vtx_fac_cor_thr_adj_elt_7
			"Vtx_fac_cor_thr_adj_elt_7"
			UWORD
			F_3v05176_p900000_337
			2
			2
			900000
			1099997.092
			ECU_ADDRESS 0xFFFF6CEA
		/end MEASUREMENT
		/begin MEASUREMENT Vtx_fac_cor_thr_adj_elt_8
			"Vtx_fac_cor_thr_adj_elt_8"
			UWORD
			F_3v05176_p900000_337
			2
			2
			900000
			1099997.092
			ECU_ADDRESS 0xFFFF6CEC
		/end MEASUREMENT
		/begin MEASUREMENT Vtx_fac_cor_thr_adj_elt_9
			"Vtx_fac_cor_thr_adj_elt_9"
			UWORD
			F_3v05176_p900000_337
			2
			2
			900000
			1099997.092
			ECU_ADDRESS 0xFFFF6CEE
		/end MEASUREMENT
		/begin MEASUREMENT Vtx_thr_ar_n_grd_elt_0
			"Vtx_thr_ar_n_grd_elt_0"
			UWORD
			F_0v00305176_p0_50
			2
			2
			0
			199.9970916
			ECU_ADDRESS 0xFFFF7FEC
		/end MEASUREMENT
		/begin MEASUREMENT Vtx_thr_ar_n_grd_elt_1
			"Vtx_thr_ar_n_grd_elt_1"
			UWORD
			F_0v00305176_p0_50
			2
			2
			0
			199.9970916
			ECU_ADDRESS 0xFFFF7FEE
		/end MEASUREMENT
		/begin MEASUREMENT Vtx_thr_ar_n_grd_elt_10
			"Vtx_thr_ar_n_grd_elt_10"
			UWORD
			F_0v00305176_p0_50
			2
			2
			0
			199.9970916
			ECU_ADDRESS 0xFFFF8000
		/end MEASUREMENT
		/begin MEASUREMENT Vtx_thr_ar_n_grd_elt_11
			"Vtx_thr_ar_n_grd_elt_11"
			UWORD
			F_0v00305176_p0_50
			2
			2
			0
			199.9970916
			ECU_ADDRESS 0xFFFF8002
		/end MEASUREMENT
		/begin MEASUREMENT Vtx_thr_ar_n_grd_elt_12
			"Vtx_thr_ar_n_grd_elt_12"
			UWORD
			F_0v00305176_p0_50
			2
			2
			0
			199.9970916
			ECU_ADDRESS 0xFFFF8004
		/end MEASUREMENT
		/begin MEASUREMENT Vtx_thr_ar_n_grd_elt_13
			"Vtx_thr_ar_n_grd_elt_13"
			UWORD
			F_0v00305176_p0_50
			2
			2
			0
			199.9970916
			ECU_ADDRESS 0xFFFF8006
		/end MEASUREMENT
		/begin MEASUREMENT Vtx_thr_ar_n_grd_elt_14
			"Vtx_thr_ar_n_grd_elt_14"
			UWORD
			F_0v00305176_p0_50
			2
			2
			0
			199.9970916
			ECU_ADDRESS 0xFFFF8008
		/end MEASUREMENT
		/begin MEASUREMENT Vtx_thr_ar_n_grd_elt_15
			"Vtx_thr_ar_n_grd_elt_15"
			UWORD
			F_0v00305176_p0_50
			2
			2
			0
			199.9970916
			ECU_ADDRESS 0xFFFF800A
		/end MEASUREMENT
		/begin MEASUREMENT Vtx_thr_ar_n_grd_elt_16
			"Vtx_thr_ar_n_grd_elt_16"
			UWORD
			F_0v00305176_p0_50
			2
			2
			0
			199.9970916
			ECU_ADDRESS 0xFFFF800C
		/end MEASUREMENT
		/begin MEASUREMENT Vtx_thr_ar_n_grd_elt_2
			"Vtx_thr_ar_n_grd_elt_2"
			UWORD
			F_0v00305176_p0_50
			2
			2
			0
			199.9970916
			ECU_ADDRESS 0xFFFF7FF0
		/end MEASUREMENT
		/begin MEASUREMENT Vtx_thr_ar_n_grd_elt_3
			"Vtx_thr_ar_n_grd_elt_3"
			UWORD
			F_0v00305176_p0_50
			2
			2
			0
			199.9970916
			ECU_ADDRESS 0xFFFF7FF2
		/end MEASUREMENT
		/begin MEASUREMENT Vtx_thr_ar_n_grd_elt_4
			"Vtx_thr_ar_n_grd_elt_4"
			UWORD
			F_0v00305176_p0_50
			2
			2
			0
			199.9970916
			ECU_ADDRESS 0xFFFF7FF4
		/end MEASUREMENT
		/begin MEASUREMENT Vtx_thr_ar_n_grd_elt_5
			"Vtx_thr_ar_n_grd_elt_5"
			UWORD
			F_0v00305176_p0_50
			2
			2
			0
			199.9970916
			ECU_ADDRESS 0xFFFF7FF6
		/end MEASUREMENT
		/begin MEASUREMENT Vtx_thr_ar_n_grd_elt_6
			"Vtx_thr_ar_n_grd_elt_6"
			UWORD
			F_0v00305176_p0_50
			2
			2
			0
			199.9970916
			ECU_ADDRESS 0xFFFF7FF8
		/end MEASUREMENT
		/begin MEASUREMENT Vtx_thr_ar_n_grd_elt_7
			"Vtx_thr_ar_n_grd_elt_7"
			UWORD
			F_0v00305176_p0_50
			2
			2
			0
			199.9970916
			ECU_ADDRESS 0xFFFF7FFA
		/end MEASUREMENT
		/begin MEASUREMENT Vtx_thr_ar_n_grd_elt_8
			"Vtx_thr_ar_n_grd_elt_8"
			UWORD
			F_0v00305176_p0_50
			2
			2
			0
			199.9970916
			ECU_ADDRESS 0xFFFF7FFC
		/end MEASUREMENT
		/begin MEASUREMENT Vtx_thr_ar_n_grd_elt_9
			"Vtx_thr_ar_n_grd_elt_9"
			UWORD
			F_0v00305176_p0_50
			2
			2
			0
			199.9970916
			ECU_ADDRESS 0xFFFF7FFE
		/end MEASUREMENT
		/begin MEASUREMENT Vvt_angle_fac1_para
			"Vvt_angle_fac1_para"
			UBYTE
			F_0v00390625_p0_74
			2
			2
			0
			0.99609375
			ECU_ADDRESS 0xFFFF6DAE
		/end MEASUREMENT
		/begin MEASUREMENT Vvt_angle_fac2_para
			"Vvt_angle_fac2_para"
			UBYTE
			F_0v00390625_p0_74
			2
			2
			0
			0.99609375
			ECU_ADDRESS 0xFFFF6DAF
		/end MEASUREMENT
		/begin MEASUREMENT Vxb_alti
			"Vxb_alti"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF84D2
		/end MEASUREMENT
		/begin MEASUREMENT Vxb_eal
			"Vxb_eal"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF837E
		/end MEASUREMENT
		/begin MEASUREMENT Vxb_lamb_diag_n
			"Vxb_lamb_diag_n"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF8112
		/end MEASUREMENT
		/begin MEASUREMENT Vxb_mv_prs
			"Vxb_mv_prs"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF800E
		/end MEASUREMENT
		/begin MEASUREMENT Vxb_n
			"Vxb_n"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF8114
		/end MEASUREMENT
		/begin MEASUREMENT Vxb_n_knk
			"Vxb_n_knk"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF8116
		/end MEASUREMENT
		/begin MEASUREMENT Vxb_prev2_n
			"Vxb_prev2_n"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7DEC
		/end MEASUREMENT
		/begin MEASUREMENT Vxb_prs
			"Vxb_prs"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF805A
		/end MEASUREMENT
		/begin MEASUREMENT Vxb_prs2
			"Vxb_prs2"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7B42
		/end MEASUREMENT
		/begin MEASUREMENT Vxb_tq
			"Vxb_tq"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF84D4
		/end MEASUREMENT
		/begin MEASUREMENT Vxb_vvt_n
			"Vxb_vvt_n"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF8118
		/end MEASUREMENT
		/begin MEASUREMENT Vxb_wet_eal
			"Vxb_wet_eal"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF8380
		/end MEASUREMENT
		/begin MEASUREMENT Vxb_wet_n
			"Vxb_wet_n"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF811A
		/end MEASUREMENT
		/begin MEASUREMENT Vxb_wet_prs
			"Vxb_wet_prs"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF802E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_abs_abst_ctr
			"Vxx_abs_abst_ctr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF731F
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_abs_abst_mem
			"Vxx_abs_abst_mem"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF88C2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_abs_ecu_stt
			"Vxx_abs_ecu_stt"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7320
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_abs_ref_whl_angl_dif
			"Vxx_abs_ref_whl_angl_dif"
			UWORD
			F_0v04376_p0_180
			2
			2
			0
			2867.8116
			ECU_ADDRESS 0xFFFF77D6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ac_abst_ctr
			"Vxx_ac_abst_ctr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF73E5
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ac_abst_mem
			"Vxx_ac_abst_mem"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF88C6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ac_acel_is_req_dly
			"Vxx_ac_acel_is_req_dly"
			UBYTE
			F_256_p0_142
			2
			2
			0
			65280
			ECU_ADDRESS 0xFFFF7457
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ac_ecu_stt
			"Vxx_ac_ecu_stt"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF73E6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ac_is_cor_appl_dly
			"Vxx_ac_is_cor_appl_dly"
			UBYTE
			F_16_p0_10
			2
			2
			0
			4080
			ECU_ADDRESS 0xFFFF79C3
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ac_max_mdf_dly
			"Vxx_ac_max_mdf_dly"
			UBYTE
			F_1v024_p0_119
			2
			2
			0
			261.12
			ECU_ADDRESS 0xFFFF7458
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ac_min_is_n
			"Vxx_ac_min_is_n"
			UBYTE
			F_16_p0_83
			2
			2
			0
			4080
			ECU_ADDRESS 0xFFFF80F2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ac_pow
			"Vxx_ac_pow"
			UBYTE
			F_20_p0_63
			2
			2
			0
			5100
			ECU_ADDRESS 0xFFFF7459
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ac_pow_csm
			"Vxx_ac_pow_csm"
			UBYTE
			F_20_p0_63
			2
			2
			0
			5100
			ECU_ADDRESS 0xFFFF745A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ac_prs
			"Vxx_ac_prs"
			UWORD
			F_0v1_p0_141
			2
			2
			0
			6553.5
			ECU_ADDRESS 0xFFFF7468
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ac_prs_lvl
			"Vxx_ac_prs_lvl"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF745B
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ac_req_dly
			"Vxx_ac_req_dly"
			UBYTE
			F_64_p0_145
			2
			2
			0
			16320
			ECU_ADDRESS 0xFFFF745C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_acc_abst_ctr
			"Vxx_acc_abst_ctr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7321
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_acc_abst_mem
			"Vxx_acc_abst_mem"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF88C5
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_acc_brk_sp
			"Vxx_acc_brk_sp"
			UBYTE
			F_0v05_m10_338
			2
			2
			-10
			2.75
			ECU_ADDRESS 0xFFFF73C2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_acc_ctl_typ
			"Vxx_acc_ctl_typ"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF73C3
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_acc_ctr
			"Vxx_acc_ctr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF73C4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_acc_ctr_prec
			"Vxx_acc_ctr_prec"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7322
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_acc_dclu_clu_dly
			"Vxx_acc_dclu_clu_dly"
			UBYTE
			F_16_p0_10
			2
			2
			0
			4080
			ECU_ADDRESS 0xFFFF745D
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_acc_ecu_stt
			"Vxx_acc_ecu_stt"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7323
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_acc_tq_sp
			"Vxx_acc_tq_sp"
			UBYTE
			F_2_m100_36
			2
			2
			-100
			410
			ECU_ADDRESS 0xFFFF73C5
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_acc_tq_stt_ctl
			"Vxx_acc_tq_stt_ctl"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF81DE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_acel_aj_tqe_l_thd
			"Vxx_acel_aj_tqe_l_thd"
			UWORD
			F_0v0078125_m100_35
			2
			2
			-100
			411.9921875
			ECU_ADDRESS 0xFFFF8382
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_acel_aj_tqe_up_thd
			"Vxx_acel_aj_tqe_up_thd"
			UWORD
			F_0v0078125_m100_35
			2
			2
			-100
			411.9921875
			ECU_ADDRESS 0xFFFF8384
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_acel_is_ac_dsb_dly
			"Vxx_acel_is_ac_dsb_dly"
			UBYTE
			F_128_p0_125
			2
			2
			0
			32640
			ECU_ADDRESS 0xFFFF745E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ad_cp_dly
			"Vxx_ad_cp_dly"
			UBYTE
			F_4_p0_163
			2
			2
			0
			1020
			ECU_ADDRESS 0xFFFF80AA
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ad_cp_fct_dly
			"Vxx_ad_cp_fct_dly"
			UBYTE
			F_4_p0_163
			2
			2
			0
			1020
			ECU_ADDRESS 0xFFFF80AB
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ad_h_thr_trt1
			"Vxx_ad_h_thr_trt1"
			UWORD
			F_0v097656_p0_5
			2
			2
			0
			6399.88596
			ECU_ADDRESS 0xFFFF8642
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ad_h_thr_trt2
			"Vxx_ad_h_thr_trt2"
			UWORD
			F_0v097656_p0_5
			2
			2
			0
			6399.88596
			ECU_ADDRESS 0xFFFF8646
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ad_l_thr_trt1
			"Vxx_ad_l_thr_trt1"
			UWORD
			F_0v097656_p0_5
			2
			2
			0
			6399.88596
			ECU_ADDRESS 0xFFFF8640
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ad_l_thr_trt2
			"Vxx_ad_l_thr_trt2"
			UWORD
			F_0v097656_p0_5
			2
			2
			0
			6399.88596
			ECU_ADDRESS 0xFFFF8644
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ad_lamb_swi_ctr
			"Vxx_ad_lamb_swi_ctr"
			UBYTE
			F_1_p0_148
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7AC1
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ad_max_psn_thr
			"Vxx_ad_max_psn_thr"
			UBYTE
			F_0v390625_p0_4
			2
			2
			0
			99.609375
			ECU_ADDRESS 0xFFFF76B0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ad_min_psn_thr
			"Vxx_ad_min_psn_thr"
			UBYTE
			F_0v390625_p0_4
			2
			2
			0
			99.609375
			ECU_ADDRESS 0xFFFF76B1
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ad_tq_ofs
			"Vxx_ad_tq_ofs"
			SWORD
			F_0v0078125_p0_15
			2
			2
			-256
			255.9921875
			ECU_ADDRESS 0xFFFF8694
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_adac_efv_ti
			"Vxx_adac_efv_ti"
			UWORD
			F_4_p0_149
			2
			2
			0
			262140
			ECU_ADDRESS 0xFFFF7B44
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_adac_efv_ti_lpg
			"Vxx_adac_efv_ti_lpg"
			UWORD
			F_4_p0_149
			2
			2
			0
			262140
			ECU_ADDRESS 0xFFFF7992
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_adac_ti
			"Vxx_adac_ti"
			UWORD
			F_4_p0_149
			2
			2
			0
			262140
			ECU_ADDRESS 0xFFFF738A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_adac_ti_lpg
			"Vxx_adac_ti_lpg"
			UWORD
			F_4_p0_149
			2
			2
			0
			262140
			ECU_ADDRESS 0xFFFF738C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_aftr_crsh_dly
			"Vxx_aftr_crsh_dly"
			UWORD
			F_1v024_p0_119
			2
			2
			0
			67107.84
			ECU_ADDRESS 0xFFFF738E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_aftr_ti
			"Vxx_aftr_ti"
			UWORD
			F_0v004_p0_201
			2
			2
			0
			262.14
			ECU_ADDRESS 0xFFFF7B46
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_agb_abst_ctr
			"Vxx_agb_abst_ctr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7324
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_agb_abst_mem
			"Vxx_agb_abst_mem"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF88C1
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_agb_clck_val
			"Vxx_agb_clck_val"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF73D0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_agb_clck_val_prec
			"Vxx_agb_clck_val_prec"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7325
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_agb_conv_stt
			"Vxx_agb_conv_stt"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF73D1
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_agb_conv_trs_dly
			"Vxx_agb_conv_trs_dly"
			UBYTE
			F_32_p0_122
			2
			2
			0
			8160
			ECU_ADDRESS 0xFFFF7326
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_agb_csm_tq
			"Vxx_agb_csm_tq"
			UWORD
			F_0v0078125_p0_15
			2
			2
			0
			511.9921875
			ECU_ADDRESS 0xFFFF7390
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_agb_dri_dly
			"Vxx_agb_dri_dly"
			UBYTE
			F_16_p0_10
			2
			2
			0
			4080
			ECU_ADDRESS 0xFFFF7327
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_agb_ecu_stt
			"Vxx_agb_ecu_stt"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7328
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_agb_min_is_n
			"Vxx_agb_min_is_n"
			UBYTE
			F_16_p0_83
			2
			2
			0
			4080
			ECU_ADDRESS 0xFFFF80F3
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_agb_min_is_sp_req
			"Vxx_agb_min_is_sp_req"
			UBYTE
			F_16_p0_83
			2
			2
			0
			4080
			ECU_ADDRESS 0xFFFF7329
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_agb_min_tqe_cor
			"Vxx_agb_min_tqe_cor"
			UWORD
			F_0v0078125_p0_15
			2
			2
			0
			511.9921875
			ECU_ADDRESS 0xFFFF8386
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_agb_neut_dly
			"Vxx_agb_neut_dly"
			UWORD
			F_16_p0_10
			2
			2
			0
			1048560
			ECU_ADDRESS 0xFFFF7392
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_agb_sli
			"Vxx_agb_sli"
			UBYTE
			F_0v78125_p0_16
			2
			2
			0
			199.21875
			ECU_ADDRESS 0xFFFF732A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_agb_sli_tq
			"Vxx_agb_sli_tq"
			UWORD
			F_0v0078125_p0_15
			2
			2
			0
			511.9921875
			ECU_ADDRESS 0xFFFF7394
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_agb_toil_cor
			"Vxx_agb_toil_cor"
			UBYTE
			F_0v015625_p0_13
			2
			2
			0
			3.984375
			ECU_ADDRESS 0xFFFF732B
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_agb_tq_pwm
			"Vxx_agb_tq_pwm"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF79E0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_agb_tq_sp_lim
			"Vxx_agb_tq_sp_lim"
			UBYTE
			F_2_m100_36
			2
			2
			-100
			410
			ECU_ADDRESS 0xFFFF732C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_air_pump_ctr1
			"Vxx_air_pump_ctr1"
			UBYTE
			F_128_p0_125
			2
			2
			0
			32640
			ECU_ADDRESS 0xFFFF84B5
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_air_pump_phs
			"Vxx_air_pump_phs"
			UBYTE
			Vxx_air_pump_phs_conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF84B6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_airb_frm_rcpt
			"Vxx_airb_frm_rcpt"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF732D
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_airb_frm_rcpt_mem
			"Vxx_airb_frm_rcpt_mem"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF88C0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_aj_driv_tqe_sp
			"Vxx_aj_driv_tqe_sp"
			UWORD
			F_0v0078125_m100_35
			2
			2
			-100
			411.9921875
			ECU_ADDRESS 0xFFFF8388
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_aj_fast_tq_cor
			"Vxx_aj_fast_tq_cor"
			SWORD
			F_0v0078125_p0_15
			2
			2
			-256
			255.9921875
			ECU_ADDRESS 0xFFFF6DD2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_aj_tqe_fil_fac
			"Vxx_aj_tqe_fil_fac"
			UWORD
			F_0v0015259_p0_92
			2
			2
			0
			99.9998565
			ECU_ADDRESS 0xFFFF838A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_alt_crt
			"Vxx_alt_crt"
			UBYTE
			F_0v0472_p0_154
			2
			2
			0
			12.036
			ECU_ADDRESS 0xFFFF832A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_alt_crt_ecu
			"Vxx_alt_crt_ecu"
			UBYTE
			F_0v0472_p0_154
			2
			2
			0
			12.036
			ECU_ADDRESS 0xFFFF6D39
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_alt_crt_esti_dly
			"Vxx_alt_crt_esti_dly"
			UBYTE
			F_8_p0_56
			2
			2
			0
			2040
			ECU_ADDRESS 0xFFFF6D3A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_alt_crt_mux
			"Vxx_alt_crt_mux"
			UBYTE
			F_0v0472_p0_154
			2
			2
			0
			12.036
			ECU_ADDRESS 0xFFFF732E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_alt_esti_temp
			"Vxx_alt_esti_temp"
			UWORD
			F_0v0390625_p0_339
			2
			2
			0
			2559.960938
			ECU_ADDRESS 0xFFFF6D42
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_alt_fil_pwm
			"Vxx_alt_fil_pwm"
			UBYTE
			F_0v39215686_p0_209
			2
			2
			0
			99.9999993
			ECU_ADDRESS 0xFFFF6D3B
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_alt_fil_pwm_mem
			"Vxx_alt_fil_pwm_mem"
			ULONG
			Id_0x00
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF6D30
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_alt_n
			"Vxx_alt_n"
			UWORD
			F_1_p0_14
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF838C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_alt_pow
			"Vxx_alt_pow"
			UWORD
			F_20_p0_63
			2
			2
			0
			1310700
			ECU_ADDRESS 0xFFFF838E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_alt_pwm
			"Vxx_alt_pwm"
			UBYTE
			F_0v3921569_p0_340
			2
			2
			0
			100.0000095
			ECU_ADDRESS 0xFFFF6D3C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_alt_pwm_act_edg_capt_value
			"Vxx_alt_pwm_act_edg_capt_value"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF6D44
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_alt_pwm_act_t
			"Vxx_alt_pwm_act_t"
			UWORD
			F_0v0032_p0_8
			2
			2
			0
			209.712
			ECU_ADDRESS 0xFFFF6D46
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_alt_pwm_edg_max_dly
			"Vxx_alt_pwm_edg_max_dly"
			UBYTE
			F_4_p0_128
			2
			2
			0
			1020
			ECU_ADDRESS 0xFFFF6BAE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_alt_pwm_frst_lvl_t
			"Vxx_alt_pwm_frst_lvl_t"
			UWORD
			F_0v0032_p0_8
			2
			2
			0
			209.712
			ECU_ADDRESS 0xFFFF6D48
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_alt_pwm_last_lvl_t
			"Vxx_alt_pwm_last_lvl_t"
			UWORD
			F_0v0032_p0_8
			2
			2
			0
			209.712
			ECU_ADDRESS 0xFFFF6D4A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_alt_pwm_per
			"Vxx_alt_pwm_per"
			UWORD
			F_0v0032_p0_8
			2
			2
			0
			209.712
			ECU_ADDRESS 0xFFFF6D4C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_alt_pwm_per_capt_value
			"Vxx_alt_pwm_per_capt_value"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF6D4E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_alt_r
			"Vxx_alt_r"
			UBYTE
			F_0v03125_p0_341
			2
			2
			0
			7.96875
			ECU_ADDRESS 0xFFFF6D3D
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_alt_rat_fail_dly
			"Vxx_alt_rat_fail_dly"
			UWORD
			F_8_p0_56
			2
			2
			0
			524280
			ECU_ADDRESS 0xFFFF6D50
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_alt_tq
			"Vxx_alt_tq"
			UWORD
			F_0v0078125_p0_15
			2
			2
			0
			511.9921875
			ECU_ADDRESS 0xFFFF8390
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_alt_typ
			"Vxx_alt_typ"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF832B
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_alt_v
			"Vxx_alt_v"
			UWORD
			F_0v023583984_p0_196
			2
			2
			0
			1545.576391
			ECU_ADDRESS 0xFFFF6D52
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_alt_v_mem
			"Vxx_alt_v_mem"
			ULONG
			Id_0x00
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF6D34
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_alti
			"Vxx_alti"
			UBYTE
			F_3v7_p0_21
			2
			2
			0
			943.5
			ECU_ADDRESS 0xFFFF8604
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_alti_255
			"Vxx_alti_255"
			UBYTE
			F_3v7_p0_21
			2
			2
			0
			943.5
			ECU_ADDRESS 0xFFFF7612
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_alti_cor_map_sp
			"Vxx_alti_cor_map_sp"
			UWORD
			F_3v7_p103_37
			2
			2
			103
			242582.5
			ECU_ADDRESS 0xFFFF84D6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_alti_inj_cor
			"Vxx_alti_inj_cor"
			SBYTE
			F_3v7_p0_21
			2
			2
			-473.6
			469.9
			ECU_ADDRESS 0xFFFF7AA0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_alti_is_cor
			"Vxx_alti_is_cor"
			UWORD
			F_0v0030517578_p0_157
			2
			2
			0
			199.9969482
			ECU_ADDRESS 0xFFFF79E2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_alti_map
			"Vxx_alti_map"
			UWORD
			F_3v7_p103_37
			2
			2
			103
			242582.5
			ECU_ADDRESS 0xFFFF7F04
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_alti_map_mem
			"Vxx_alti_map_mem"
			ULONG
			F_0v014453125_p103_342
			2
			2
			103
			62075802.19
			ECU_ADDRESS 0xFFFF7EF8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_amp
			"Vxx_amp"
			UBYTE
			F_3v7_p103v5_343
			2
			2
			103.5
			1047
			ECU_ADDRESS 0xFFFF7906
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_amp_mmv
			"Vxx_amp_mmv"
			UWORD
			F_0v0578125_p103_96
			2
			2
			103
			3891.742188
			ECU_ADDRESS 0xFFFF8010
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_amp_spg_dif
			"Vxx_amp_spg_dif"
			UBYTE
			F_3v7_p0_21
			2
			2
			0
			943.5
			ECU_ADDRESS 0xFFFF8606
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_aod_dly
			"Vxx_aod_dly"
			UBYTE
			F_16_p0_10
			2
			2
			0
			4080
			ECU_ADDRESS 0xFFFF77C1
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_aod_vs
			"Vxx_aod_vs"
			UBYTE
			F_4_p0_344
			2
			2
			0
			1020
			ECU_ADDRESS 0xFFFF73B1
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_aod_vs_i_1
			"Vxx_aod_vs_i_1"
			UBYTE
			F_4_p0_344
			2
			2
			0
			1020
			ECU_ADDRESS 0xFFFF73B2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_appl_iga_efy
			"Vxx_appl_iga_efy"
			UWORD
			F_0v0015258_p0_48
			2
			2
			0
			99.993303
			ECU_ADDRESS 0xFFFF8392
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_appl_iga_efy1
			"Vxx_appl_iga_efy1"
			UWORD
			F_0v001526_p0_42
			2
			2
			0
			100.00641
			ECU_ADDRESS 0xFFFF8396
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_appl_iga_efy2
			"Vxx_appl_iga_efy2"
			UWORD
			F_0v001526_p0_42
			2
			2
			0
			100.00641
			ECU_ADDRESS 0xFFFF8398
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_appl_iga_efy3
			"Vxx_appl_iga_efy3"
			UWORD
			F_0v001526_p0_42
			2
			2
			0
			100.00641
			ECU_ADDRESS 0xFFFF839A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_appl_iga_efy4
			"Vxx_appl_iga_efy4"
			UWORD
			F_0v001526_p0_42
			2
			2
			0
			100.00641
			ECU_ADDRESS 0xFFFF839C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_appl_iga_efy_mv
			"Vxx_appl_iga_efy_mv"
			UWORD
			F_0v001526_p0_42
			2
			2
			0
			100.00641
			ECU_ADDRESS 0xFFFF8394
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_appl_ovt_tqi_fac
			"Vxx_appl_ovt_tqi_fac"
			UWORD
			F_0v0078125_p0_15
			2
			2
			0
			511.9921875
			ECU_ADDRESS 0xFFFF839E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_appl_rest_cor
			"Vxx_appl_rest_cor"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF80E0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_appl_ti
			"Vxx_appl_ti"
			UWORD
			F_3v2_p0_152
			2
			2
			0
			209712
			ECU_ADDRESS 0xFFFF7B48
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_appl_ti_ofs_ctr
			"Vxx_appl_ti_ofs_ctr"
			UBYTE
			F_1_p0_53
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7AC2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ar_flr_tmp_val
			"Vxx_ar_flr_tmp_val"
			UWORD
			F_0v9537_p0_73
			2
			2
			0
			62500.7295
			ECU_ADDRESS 0xFFFF83A0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_asr_ctr
			"Vxx_asr_ctr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF732F
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_asr_ctr_mem
			"Vxx_asr_ctr_mem"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7330
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_bas_iga
			"Vxx_bas_iga"
			UBYTE
			F_0v375_m23v625_6
			2
			2
			-23.625
			72
			ECU_ADDRESS 0xFFFF6DB0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_bas_rich_fac
			"Vxx_bas_rich_fac"
			UWORD
			F_0v00260417_p0v667_32
			2
			2
			0.667
			171.331281
			ECU_ADDRESS 0xFFFF7B4A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_bch_mod_ctr
			"Vxx_bch_mod_ctr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF832C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_bch_mod_cyc_nr
			"Vxx_bch_mod_cyc_nr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF832D
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_bch_mod_dyn_inc
			"Vxx_bch_mod_dyn_inc"
			SBYTE
			F_0v0625_p0_84
			2
			2
			-8
			7.9375
			ECU_ADDRESS 0xFFFF8320
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_bch_mod_dyn_ofs
			"Vxx_bch_mod_dyn_ofs"
			SWORD
			F_0v0625_p0_84
			2
			2
			-2048
			2047.9375
			ECU_ADDRESS 0xFFFF8356
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_bch_mod_stat_inc
			"Vxx_bch_mod_stat_inc"
			SBYTE
			F_0v0625_p0_84
			2
			2
			-8
			7.9375
			ECU_ADDRESS 0xFFFF8321
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_bch_mod_stat_ofs
			"Vxx_bch_mod_stat_ofs"
			SWORD
			F_0v0625_p0_84
			2
			2
			-2048
			2047.9375
			ECU_ADDRESS 0xFFFF8358
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_bfr_cl_ctr
			"Vxx_bfr_cl_ctr"
			UBYTE
			F_1_p0_53
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7AC3
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_brk_mvac_dp_dec
			"Vxx_brk_mvac_dp_dec"
			UBYTE
			F_3v7_p0_21
			2
			2
			0
			943.5
			ECU_ADDRESS 0xFFFF7907
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_brk_prs_acq
			"Vxx_brk_prs_acq"
			UWORD
			F_0v925_p103_345
			2
			2
			103
			60722.875
			ECU_ADDRESS 0xFFFF7F0A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cam_psn
			"Vxx_cam_psn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6BCE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cam_toth_phs_ctr
			"Vxx_cam_toth_phs_ctr"
			UWORD
			F_1_p0_165
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF6BDE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_can_stt
			"Vxx_can_stt"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7331
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cart_iga
			"Vxx_cart_iga"
			UBYTE
			F_0v375_m23v625_6
			2
			2
			-23.625
			72
			ECU_ADDRESS 0xFFFF6DB1
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cart_iga_fil_ctr
			"Vxx_cart_iga_fil_ctr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6DB2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cata_air_wht
			"Vxx_cata_air_wht"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7EE4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cata_asd_diag_ctr
			"Vxx_cata_asd_diag_ctr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7D87
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cata_asd_sf
			"Vxx_cata_asd_sf"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7D88
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cata_asd_sf_ctr
			"Vxx_cata_asd_sf_ctr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7D89
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cata_cl_ti_fac
			"Vxx_cata_cl_ti_fac"
			UWORD
			F_0v001526_p0_42
			2
			2
			0
			100.00641
			ECU_ADDRESS 0xFFFF7DEE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cata_fail_thd
			"Vxx_cata_fail_thd"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7D8A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cata_fail_thd_rtn
			"Vxx_cata_fail_thd_rtn"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8926
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cata_in_ctr
			"Vxx_cata_in_ctr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7D8B
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cata_lbdw_h_fil_val
			"Vxx_cata_lbdw_h_fil_val"
			UWORD
			F_0v038125_p0_237
			2
			2
			0
			2498.521875
			ECU_ADDRESS 0xFFFF7DF0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cata_lbdw_mes
			"Vxx_cata_lbdw_mes"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7DF2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cata_lbdw_mes_rtn
			"Vxx_cata_lbdw_mes_rtn"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF892B
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cata_maf_cata
			"Vxx_cata_maf_cata"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7DF4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cata_maf_cata_rtn
			"Vxx_cata_maf_cata_rtn"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF8922
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cata_maf_mem
			"Vxx_cata_maf_mem"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7D8C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cata_mem_ol_cl_ti_fac
			"Vxx_cata_mem_ol_cl_ti_fac"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7DF6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cata_ol_mv_cl_ti_fac
			"Vxx_cata_ol_mv_cl_ti_fac"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7DF8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cata_ol_per_ctr
			"Vxx_cata_ol_per_ctr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7D8D
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cata_ol_per_dly
			"Vxx_cata_ol_per_dly"
			UBYTE
			F_8_p0_56
			2
			2
			0
			2040
			ECU_ADDRESS 0xFFFF7D8E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cata_ol_per_dly_clc
			"Vxx_cata_ol_per_dly_clc"
			UBYTE
			F_8_p0_56
			2
			2
			0
			2040
			ECU_ADDRESS 0xFFFF7D8F
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cata_ol_stab_test
			"Vxx_cata_ol_stab_test"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7D90
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cata_stab_dly
			"Vxx_cata_stab_dly"
			UBYTE
			F_64_p0_145
			2
			2
			0
			16320
			ECU_ADDRESS 0xFFFF7D91
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cata_stt
			"Vxx_cata_stt"
			UBYTE
			Vxx_cata_stt_conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF7D92
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cata_trs_lean_rich_mv
			"Vxx_cata_trs_lean_rich_mv"
			UBYTE
			F_8_p0_56
			2
			2
			0
			2040
			ECU_ADDRESS 0xFFFF7D93
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cata_trs_lean_rich_nr
			"Vxx_cata_trs_lean_rich_nr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7D94
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cata_trs_lean_rich_t
			"Vxx_cata_trs_lean_rich_t"
			UBYTE
			F_8_p0_56
			2
			2
			0
			2040
			ECU_ADDRESS 0xFFFF7D95
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cata_trs_lean_sum
			"Vxx_cata_trs_lean_sum"
			UWORD
			F_8_p0_56
			2
			2
			0
			524280
			ECU_ADDRESS 0xFFFF7DFA
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cata_trs_rich_lean_nr
			"Vxx_cata_trs_rich_lean_nr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7D96
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cata_trs_rich_lean_t
			"Vxx_cata_trs_rich_lean_t"
			UBYTE
			F_8_p0_56
			2
			2
			0
			2040
			ECU_ADDRESS 0xFFFF7D97
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cata_trs_rich_sum
			"Vxx_cata_trs_rich_sum"
			UWORD
			F_8_p0_56
			2
			2
			0
			524280
			ECU_ADDRESS 0xFFFF7DFC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cata_wup_ctr
			"Vxx_cata_wup_ctr"
			UWORD
			F_1_p0_53
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF6D6E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cata_wup_phs
			"Vxx_cata_wup_phs"
			UBYTE
			Vxx_cata_wup_phs_conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF6D61
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cata_wup_rel_tq
			"Vxx_cata_wup_rel_tq"
			UBYTE
			F_0v390625_p0_4
			2
			2
			0
			99.609375
			ECU_ADDRESS 0xFFFF6DB3
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ccu_abst_ctr
			"Vxx_ccu_abst_ctr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7332
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ccu_abst_mem
			"Vxx_ccu_abst_mem"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF88C3
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ccu_ecu_stt
			"Vxx_ccu_ecu_stt"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7333
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cl2_act_ctr
			"Vxx_cl2_act_ctr"
			UBYTE
			F_512_p0_104
			2
			2
			0
			130560
			ECU_ADDRESS 0xFFFF7AC5
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cl2_ena_ctr
			"Vxx_cl2_ena_ctr"
			UWORD
			F_1_p0_53
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7B52
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cl_dsb_dly
			"Vxx_cl_dsb_dly"
			UWORD
			F_0v512_p0_121
			2
			2
			0
			33553.92
			ECU_ADDRESS 0xFFFF7B4C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cl_dsb_dly_ini
			"Vxx_cl_dsb_dly_ini"
			UWORD
			F_0v512_p0_121
			2
			2
			0
			33553.92
			ECU_ADDRESS 0xFFFF7B4E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cl_lean_ctr
			"Vxx_cl_lean_ctr"
			UBYTE
			F_8_p0_56
			2
			2
			0
			2040
			ECU_ADDRESS 0xFFFF7AC4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cl_ti_fac
			"Vxx_cl_ti_fac"
			UWORD
			F_0v0015259_p0_92
			2
			2
			0
			99.9998565
			ECU_ADDRESS 0xFFFF7B50
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_clc_ar_cp_air_gas_maf
			"Vxx_clc_ar_cp_air_gas_maf"
			UWORD
			F_0v0078125_p0_346
			2
			2
			0
			511.9921875
			ECU_ADDRESS 0xFFFF83A2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_clc_cor_rel_pdl_psn
			"Vxx_clc_cor_rel_pdl_psn"
			UWORD
			F_0v001526_p0_42
			2
			2
			0
			100.00641
			ECU_ADDRESS 0xFFFF8214
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_clc_gear_rat_mem
			"Vxx_clc_gear_rat_mem"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF80CC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_clc_gear_rat_stab_dly
			"Vxx_clc_gear_rat_stab_dly"
			UBYTE
			F_64_p0_145
			2
			2
			0
			16320
			ECU_ADDRESS 0xFFFF80CD
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_clc_rel_pdl_psn
			"Vxx_clc_rel_pdl_psn"
			UWORD
			F_0v390625_p0_4
			2
			2
			0
			25599.60938
			ECU_ADDRESS 0xFFFF8216
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_clc_tia
			"Vxx_clc_tia"
			UBYTE
			F_0v625_m40_25
			2
			2
			-40
			119.375
			ECU_ADDRESS 0xFFFF7AC6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_clc_tia_fil
			"Vxx_clc_tia_fil"
			UWORD
			F_0v00244_m40_134
			2
			2
			-40
			119.9054
			ECU_ADDRESS 0xFFFF7B54
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_clc_tia_fil_fac
			"Vxx_clc_tia_fil_fac"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7AC7
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_clc_tia_fil_mem
			"Vxx_clc_tia_fil_mem"
			ULONG
			F_0v00000953_m40_347
			2
			2
			-40
			40891.03832
			ECU_ADDRESS 0xFFFF7A9C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_clos_brk_swi
			"Vxx_clos_brk_swi"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7908
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_clu_ctr
			"Vxx_clu_ctr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF78C2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_clu_mdf_dly
			"Vxx_clu_mdf_dly"
			UBYTE
			F_64_p0_145
			2
			2
			0
			16320
			ECU_ADDRESS 0xFFFF792B
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_clu_stal_ctr
			"Vxx_clu_stal_ctr"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF866C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cmd_mdf_dly
			"Vxx_cmd_mdf_dly"
			UWORD
			F_4v096_p0_12
			2
			2
			0
			268431.36
			ECU_ADDRESS 0xFFFF792E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cold_wup_iga_cor_tmp
			"Vxx_cold_wup_iga_cor_tmp"
			UBYTE
			F_0v375_m48_41
			2
			2
			-48
			47.625
			ECU_ADDRESS 0xFFFF6DB4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cor_cata_hot_fil_ctr
			"Vxx_cor_cata_hot_fil_ctr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF79C4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cor_mes_map
			"Vxx_cor_mes_map"
			UWORD
			F_0v0578_p103_348
			2
			2
			103
			3890.923
			ECU_ADDRESS 0xFFFF805C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cor_mes_spg
			"Vxx_cor_mes_spg"
			UWORD
			F_0v0578125_p103_96
			2
			2
			103
			3891.742188
			ECU_ADDRESS 0xFFFF84D8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cor_min_iga
			"Vxx_cor_min_iga"
			UBYTE
			F_0v375_m23v625_34
			2
			2
			-23.625
			72
			ECU_ADDRESS 0xFFFF7A21
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cor_n
			"Vxx_cor_n"
			UBYTE
			F_16_p800_57
			2
			2
			800
			4880
			ECU_ADDRESS 0xFFFF80F4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cor_pump_maf
			"Vxx_cor_pump_maf"
			UWORD
			F_0v0000152588_p0_27
			2
			2
			0
			0.9999847412
			ECU_ADDRESS 0xFFFF83A4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cor_thr_pos_mes
			"Vxx_cor_thr_pos_mes"
			UWORD
			F_0v097656_p0_5
			2
			2
			0
			6399.88596
			ECU_ADDRESS 0xFFFF7754
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cor_tia
			"Vxx_cor_tia"
			UWORD
			F_0v0078_p0_349
			2
			2
			0
			511.173
			ECU_ADDRESS 0xFFFF83A6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cor_tq_rat_ovn
			"Vxx_cor_tq_rat_ovn"
			UBYTE
			F_0v390625_p0_4
			2
			2
			0
			99.609375
			ECU_ADDRESS 0xFFFF832E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cor_tq_thr_ar_sp
			"Vxx_cor_tq_thr_ar_sp"
			UWORD
			F_0v0596046448_p0_151
			2
			2
			0
			3906.190395
			ECU_ADDRESS 0xFFFF83A8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cp_air_gas_maf
			"Vxx_cp_air_gas_maf"
			UWORD
			F_0v0009536743_p0_350
			2
			2
			0
			62.49904633
			ECU_ADDRESS 0xFFFF83AA
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cp_air_maf
			"Vxx_cp_air_maf"
			UWORD
			F_0v0009536743_p0_350
			2
			2
			0
			62.49904633
			ECU_ADDRESS 0xFFFF83AC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cp_dly
			"Vxx_cp_dly"
			UBYTE
			F_4_p0_163
			2
			2
			0
			1020
			ECU_ADDRESS 0xFFFF80AC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cp_efv_ar
			"Vxx_cp_efv_ar"
			UWORD
			F_0v0037253_p0_113
			2
			2
			0
			244.1375355
			ECU_ADDRESS 0xFFFF83AE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cp_egr_sta_dly
			"Vxx_cp_egr_sta_dly"
			UBYTE
			F_32_p0_122
			2
			2
			0
			8160
			ECU_ADDRESS 0xFFFF7AC8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cp_egr_stop_dly
			"Vxx_cp_egr_stop_dly"
			UBYTE
			F_32_p0_122
			2
			2
			0
			8160
			ECU_ADDRESS 0xFFFF7AC9
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cp_mv_cl_ti_fac
			"Vxx_cp_mv_cl_ti_fac"
			UWORD
			F_0v001526_p0_42
			2
			2
			0
			100.00641
			ECU_ADDRESS 0xFFFF80BA
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cp_pwm
			"Vxx_cp_pwm"
			UWORD
			F_0v0039_p0_114
			2
			2
			0
			255.5865
			ECU_ADDRESS 0xFFFF80BC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cp_pwm_appl
			"Vxx_cp_pwm_appl"
			UWORD
			F_0v0039_p0_114
			2
			2
			0
			255.5865
			ECU_ADDRESS 0xFFFF80BE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cp_pwm_cor
			"Vxx_cp_pwm_cor"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF80C0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cp_pwm_efv_fac
			"Vxx_cp_pwm_efv_fac"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF80AD
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cp_pwm_fac
			"Vxx_cp_pwm_fac"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF80C2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cp_pwm_sp
			"Vxx_cp_pwm_sp"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF80AE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cp_pwm_step
			"Vxx_cp_pwm_step"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF80C4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cp_rich_cor
			"Vxx_cp_rich_cor"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF80C6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cp_rich_cor_appl
			"Vxx_cp_rich_cor_appl"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF80AF
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cp_rich_cor_clc
			"Vxx_cp_rich_cor_clc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF80B0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cp_rich_int_cor
			"Vxx_cp_rich_int_cor"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF80B1
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cp_rtn_dly
			"Vxx_cp_rtn_dly"
			UBYTE
			F_4_p0_163
			2
			2
			0
			1020
			ECU_ADDRESS 0xFFFF80B2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cp_ti_fac
			"Vxx_cp_ti_fac"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF80B3
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cru_sl_acel
			"Vxx_cru_sl_acel"
			SBYTE
			F_0v1_p0v8_293
			2
			2
			-12
			13.5
			ECU_ADDRESS 0xFFFF81B9
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cru_sl_dacn
			"Vxx_cru_sl_dacn"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF88B6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cru_sl_dacn_prev
			"Vxx_cru_sl_dacn_prev"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF81DF
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cru_sl_driv_vs_sp
			"Vxx_cru_sl_driv_vs_sp"
			UBYTE
			F_1_p0_58
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF81E0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cru_sl_dyn_forc_ini
			"Vxx_cru_sl_dyn_forc_ini"
			UBYTE
			F_25_p0_85
			2
			2
			0
			6375
			ECU_ADDRESS 0xFFFF81E1
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cru_sl_fil_vs_ref
			"Vxx_cru_sl_fil_vs_ref"
			UWORD
			F_0v01_p0_62
			2
			2
			0
			655.35
			ECU_ADDRESS 0xFFFF821C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cru_sl_forc_ini
			"Vxx_cru_sl_forc_ini"
			SWORD
			F_1_p0_351
			2
			2
			-32768
			32767
			ECU_ADDRESS 0xFFFF81FA
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cru_sl_gear
			"Vxx_cru_sl_gear"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF81E2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cru_sl_raw_acel
			"Vxx_cru_sl_raw_acel"
			SBYTE
			F_0v1_p0v8_293
			2
			2
			-12
			13.5
			ECU_ADDRESS 0xFFFF81BA
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cru_sl_raw_vs
			"Vxx_cru_sl_raw_vs"
			UWORD
			F_0v01_p0_62
			2
			2
			0
			655.35
			ECU_ADDRESS 0xFFFF821E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cru_sl_svkl_acel_ref
			"Vxx_cru_sl_svkl_acel_ref"
			SWORD
			F_0v0019073_p0_176
			2
			2
			-62.4984064
			62.4964991
			ECU_ADDRESS 0xFFFF81FC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cru_sl_svkl_delt
			"Vxx_cru_sl_svkl_delt"
			SWORD
			F_0v01_p0_62
			2
			2
			-327.68
			327.67
			ECU_ADDRESS 0xFFFF81FE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cru_sl_svkl_forc
			"Vxx_cru_sl_svkl_forc"
			SWORD
			F_1_p0_351
			2
			2
			-32768
			32767
			ECU_ADDRESS 0xFFFF8200
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cru_sl_svkl_forc_ref
			"Vxx_cru_sl_svkl_forc_ref"
			SWORD
			F_1_p0_351
			2
			2
			-32768
			32767
			ECU_ADDRESS 0xFFFF8202
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cru_sl_svkl_i_cor
			"Vxx_cru_sl_svkl_i_cor"
			SLONG
			F_0v0000000291_p0_352
			2
			2
			-62.49177416
			62.49177413
			ECU_ADDRESS 0xFFFF8238
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cru_sl_svkl_ig
			"Vxx_cru_sl_svkl_ig"
			UWORD
			F_0v0298023_p0_175
			2
			2
			0
			1953.093731
			ECU_ADDRESS 0xFFFF8220
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cru_sl_svkl_max_i_cor
			"Vxx_cru_sl_svkl_max_i_cor"
			SWORD
			F_0v0019073_p0_176
			2
			2
			-62.4984064
			62.4964991
			ECU_ADDRESS 0xFFFF8204
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cru_sl_svkl_min_i_cor
			"Vxx_cru_sl_svkl_min_i_cor"
			SWORD
			F_0v0019073_p0_176
			2
			2
			-62.4984064
			62.4964991
			ECU_ADDRESS 0xFFFF8206
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cru_sl_svkl_p_cor
			"Vxx_cru_sl_svkl_p_cor"
			SWORD
			F_0v0019073_p0_176
			2
			2
			-62.4984064
			62.4964991
			ECU_ADDRESS 0xFFFF8208
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cru_sl_svkl_pg
			"Vxx_cru_sl_svkl_pg"
			UWORD
			F_0v0019073_p0_177
			2
			2
			0
			124.9949055
			ECU_ADDRESS 0xFFFF8222
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cru_sl_tqe_ini
			"Vxx_cru_sl_tqe_ini"
			UBYTE
			F_2_m100_36
			2
			2
			-100
			410
			ECU_ADDRESS 0xFFFF81E3
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cru_sl_tqe_ref
			"Vxx_cru_sl_tqe_ref"
			UBYTE
			F_2_m100_36
			2
			2
			-100
			410
			ECU_ADDRESS 0xFFFF81E4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cru_sl_vs
			"Vxx_cru_sl_vs"
			UWORD
			F_0v01_p0_62
			2
			2
			0
			655.35
			ECU_ADDRESS 0xFFFF8224
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cru_sl_vs_in
			"Vxx_cru_sl_vs_in"
			UWORD
			F_0v01_p0_62
			2
			2
			0
			655.35
			ECU_ADDRESS 0xFFFF8226
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cru_sl_vs_prev
			"Vxx_cru_sl_vs_prev"
			UWORD
			F_0v01_p0_62
			2
			2
			0
			655.35
			ECU_ADDRESS 0xFFFF8228
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cru_sl_whl_cmd_in
			"Vxx_cru_sl_whl_cmd_in"
			UWORD
			F_0v0000762951_p0_353
			2
			2
			0
			4.999999378
			ECU_ADDRESS 0xFFFF822A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cru_sl_whl_tq_ref
			"Vxx_cru_sl_whl_tq_ref"
			SWORD
			F_0v125_p0_354
			2
			2
			-4096
			4095.875
			ECU_ADDRESS 0xFFFF820A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cru_tqe_sp
			"Vxx_cru_tqe_sp"
			UBYTE
			F_2_m100_36
			2
			2
			-100
			410
			ECU_ADDRESS 0xFFFF81E5
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cru_tqe_sp_temp
			"Vxx_cru_tqe_sp_temp"
			UWORD
			F_0v0078125_m100_35
			2
			2
			-100
			411.9921875
			ECU_ADDRESS 0xFFFF822C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cru_vs_ref_ofs
			"Vxx_cru_vs_ref_ofs"
			UWORD
			F_0v01_p0_355
			2
			2
			0
			655.35
			ECU_ADDRESS 0xFFFF822E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_csm
			"Vxx_csm"
			UWORD
			F_0v01_p0_356
			2
			2
			0
			655.35
			ECU_ADDRESS 0xFFFF75A6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_csm_tq_loss
			"Vxx_csm_tq_loss"
			UWORD
			F_0v0078125_p0_15
			2
			2
			0
			511.9921875
			ECU_ADDRESS 0xFFFF83B0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ct_fil_pdl_psn
			"Vxx_ct_fil_pdl_psn"
			UWORD
			F_0v0015258789_p0_115
			2
			2
			0
			99.99847412
			ECU_ADDRESS 0xFFFF8012
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ct_pdl_psn
			"Vxx_ct_pdl_psn"
			UBYTE
			F_0v390625_p0_4
			2
			2
			0
			99.609375
			ECU_ADDRESS 0xFFFF85FE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ct_pdl_psn_max
			"Vxx_ct_pdl_psn_max"
			UBYTE
			F_0v390625_p0_4
			2
			2
			0
			99.609375
			ECU_ADDRESS 0xFFFF7D98
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ct_pdl_psn_min
			"Vxx_ct_pdl_psn_min"
			UBYTE
			F_0v390625_p0_4
			2
			2
			0
			99.609375
			ECU_ADDRESS 0xFFFF7D99
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ct_pdl_psn_thd
			"Vxx_ct_pdl_psn_thd"
			UBYTE
			F_0v390625_p0_4
			2
			2
			0
			99.609375
			ECU_ADDRESS 0xFFFF7FC0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ct_thr_ofs_psn
			"Vxx_ct_thr_ofs_psn"
			UWORD
			F_0v09765625_p0_71
			2
			2
			0
			6399.902344
			ECU_ADDRESS 0xFFFF864C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ctr
			"Vxx_ctr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7970
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ctr_frm_csm
			"Vxx_ctr_frm_csm"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7334
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ctr_ti_sum
			"Vxx_ctr_ti_sum"
			UWORD
			F_20480_p0_357
			2
			2
			0
			1342156800
			ECU_ADDRESS 0xFFFF7396
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ctr_ti_sum_gas
			"Vxx_ctr_ti_sum_gas"
			UWORD
			F_20480_p0_357
			2
			2
			0
			1342156800
			ECU_ADDRESS 0xFFFF88B8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ctr_ti_sum_lpg
			"Vxx_ctr_ti_sum_lpg"
			UWORD
			F_20480_p0_357
			2
			2
			0
			1342156800
			ECU_ADDRESS 0xFFFF88BA
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ctr_vld_crk_fail1
			"Vxx_ctr_vld_crk_fail1"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7FA1
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cut_off_frq
			"Vxx_cut_off_frq"
			UBYTE
			F_0v125_p0_358
			2
			2
			0
			31.875
			ECU_ADDRESS 0xFFFF6D3E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cyl_ctr_last_val
			"Vxx_cyl_ctr_last_val"
			UWORD
			F_1_p0_53
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF86CC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cyl_id_sta_ofs
			"Vxx_cyl_id_sta_ofs"
			UBYTE
			F_1_p0_165
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6BCF
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cylr_ctl_phs
			"Vxx_cylr_ctl_phs"
			UBYTE
			Vxx_cylr_ctl_phs_conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF6BD0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cylr_iga_mem
			"Vxx_cylr_iga_mem"
			UBYTE
			F_0v375_m23v625_6
			2
			2
			-23.625
			72
			ECU_ADDRESS 0xFFFF6BD1
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cylr_is_run_test_ctr
			"Vxx_cylr_is_run_test_ctr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6BD2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cylr_ok_ctr
			"Vxx_cylr_ok_ctr"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF8676
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cylr_tdc_ctr
			"Vxx_cylr_tdc_ctr"
			UBYTE
			F_1_p0_53
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6BD3
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_cylr_test_ctr
			"Vxx_cylr_test_ctr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6BD4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_deb_dly
			"Vxx_deb_dly"
			UBYTE
			F_16_p0_10
			2
			2
			0
			4080
			ECU_ADDRESS 0xFFFF77C2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_dec_sta_ti
			"Vxx_dec_sta_ti"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7B56
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_decl_acel_jerk_iga
			"Vxx_decl_acel_jerk_iga"
			SBYTE
			F_0v375_p0_29
			2
			2
			-48
			47.625
			ECU_ADDRESS 0xFFFF6D90
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_decl_aj_tqe_l_thd
			"Vxx_decl_aj_tqe_l_thd"
			UWORD
			F_0v0078125_m100_35
			2
			2
			-100
			411.9921875
			ECU_ADDRESS 0xFFFF83B2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_decl_aj_tqe_up_thd
			"Vxx_decl_aj_tqe_up_thd"
			UWORD
			F_0v0078125_m100_35
			2
			2
			-100
			411.9921875
			ECU_ADDRESS 0xFFFF83B4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_decl_prs_lean_dsb_dly
			"Vxx_decl_prs_lean_dsb_dly"
			UWORD
			F_1v024_p0_119
			2
			2
			0
			67107.84
			ECU_ADDRESS 0xFFFF8030
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_dft_lght_on_ctr
			"Vxx_dft_lght_on_ctr"
			UBYTE
			F_1_p0_54
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7613
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_dft_lght_on_km
			"Vxx_dft_lght_on_km"
			ULONG
			F_0v2777778_p0_359
			2
			2
			0
			1193046566
			ECU_ADDRESS 0xFFFF75CC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_dft_lght_on_km_lsb
			"Vxx_dft_lght_on_km_lsb"
			UWORD
			F_0v2777778_p0_359
			2
			2
			0
			18204.16812
			ECU_ADDRESS 0xFFFF86A6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_dft_lght_on_km_msb
			"Vxx_dft_lght_on_km_msb"
			UWORD
			F_18204v445_p0_360
			2
			2
			0
			1193028303
			ECU_ADDRESS 0xFFFF86A4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_dgr_tco
			"Vxx_dgr_tco"
			UBYTE
			F_1_m40_40
			2
			2
			-40
			215
			ECU_ADDRESS 0xFFFF858B
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_diag_cata_cl_ti_fac
			"Vxx_diag_cata_cl_ti_fac"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A99
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_diag_fsys_dsb_dly
			"Vxx_diag_fsys_dsb_dly"
			UWORD
			F_512_p0_104
			2
			2
			0
			33553920
			ECU_ADDRESS 0xFFFF7DFE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_diag_knk_acq
			"Vxx_diag_knk_acq"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF74E6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_diag_mis_dsb_dly
			"Vxx_diag_mis_dsb_dly"
			UWORD
			F_512_p0_104
			2
			2
			0
			33553920
			ECU_ADDRESS 0xFFFF7E00
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_diag_tmp_is_n_cor
			"Vxx_diag_tmp_is_n_cor"
			SBYTE
			F_16_p0_83
			2
			2
			-2048
			2032
			ECU_ADDRESS 0xFFFF80E9
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_dly_driv_tqe_sp
			"Vxx_dly_driv_tqe_sp"
			UWORD
			F_0v0078125_m100_35
			2
			2
			-100
			411.9921875
			ECU_ADDRESS 0xFFFF7802
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_dly_inj_cut
			"Vxx_dly_inj_cut"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF84DA
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_dly_ocl_dly
			"Vxx_dly_ocl_dly"
			UBYTE
			F_512_p0_104
			2
			2
			0
			130560
			ECU_ADDRESS 0xFFFF7ACA
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_driv_eng_tq
			"Vxx_driv_eng_tq"
			UWORD
			F_0v0078125_m100_35
			2
			2
			-100
			411.9921875
			ECU_ADDRESS 0xFFFF83B6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_driv_fast_eng_tq
			"Vxx_driv_fast_eng_tq"
			UWORD
			F_0v0078125_m100_35
			2
			2
			-100
			411.9921875
			ECU_ADDRESS 0xFFFF83B8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_driv_fil_tqe_sp
			"Vxx_driv_fil_tqe_sp"
			UWORD
			F_0v0078125_m100_35
			2
			2
			-100
			411.9921875
			ECU_ADDRESS 0xFFFF7804
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_driv_fil_tqe_sp_old
			"Vxx_driv_fil_tqe_sp_old"
			UWORD
			F_0v0078125_m100_35
			2
			2
			-100
			411.9921875
			ECU_ADDRESS 0xFFFF7806
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_driv_is_thr_ar_sp
			"Vxx_driv_is_thr_ar_sp"
			UWORD
			F_0v06_p0_212
			2
			2
			0
			3932.1
			ECU_ADDRESS 0xFFFF8014
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_driv_slow_eng_tq
			"Vxx_driv_slow_eng_tq"
			UWORD
			F_0v0078125_m100_35
			2
			2
			-100
			411.9921875
			ECU_ADDRESS 0xFFFF83BA
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_driv_thr_ar_sp
			"Vxx_driv_thr_ar_sp"
			UWORD
			F_0v06_p0_212
			2
			2
			0
			3932.1
			ECU_ADDRESS 0xFFFF8016
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_driv_tqe_fac
			"Vxx_driv_tqe_fac"
			UBYTE
			F_0v3906_p0_133
			2
			2
			0
			99.603
			ECU_ADDRESS 0xFFFF832F
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_driv_tqe_sp
			"Vxx_driv_tqe_sp"
			UWORD
			F_0v0078125_m100_35
			2
			2
			-100
			411.9921875
			ECU_ADDRESS 0xFFFF83BC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_driv_tqe_sp_1
			"Vxx_driv_tqe_sp_1"
			UWORD
			F_0v0078125_m100_35
			2
			2
			-100
			411.9921875
			ECU_ADDRESS 0xFFFF7808
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_driv_tqe_sp_grd
			"Vxx_driv_tqe_sp_grd"
			UWORD
			F_0v02_m655v35_61
			2
			2
			-655.35
			655.35
			ECU_ADDRESS 0xFFFF780A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_driv_tqe_sp_grd_mem
			"Vxx_driv_tqe_sp_grd_mem"
			ULONG
			F_0v0000003052_p0_361
			2
			2
			0
			1310.738119
			ECU_ADDRESS 0xFFFF77F4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_dsb_dly_vs
			"Vxx_dsb_dly_vs"
			UBYTE
			F_1_p0_54
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF828F
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_dyn_forc
			"Vxx_dyn_forc"
			UBYTE
			F_25_p0_85
			2
			2
			0
			6375
			ECU_ADDRESS 0xFFFF81E6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_dyn_iga_efy_cor
			"Vxx_dyn_iga_efy_cor"
			UWORD
			F_0v24414_p0_263
			2
			2
			0
			15999.7149
			ECU_ADDRESS 0xFFFF7A38
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_dyn_iga_fil_fac
			"Vxx_dyn_iga_fil_fac"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6DB5
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_dyn_iga_mv_clc_dly
			"Vxx_dyn_iga_mv_clc_dly"
			UBYTE
			F_128_p0_125
			2
			2
			0
			32640
			ECU_ADDRESS 0xFFFF6DB6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_dyn_iga_mv_n
			"Vxx_dyn_iga_mv_n"
			UWORD
			F_0v125_p0_30
			2
			2
			0
			8191.875
			ECU_ADDRESS 0xFFFF6DD8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_dyn_iga_mv_tq
			"Vxx_dyn_iga_mv_tq"
			SWORD
			F_0v125_p0_30
			2
			2
			-4096
			4095.875
			ECU_ADDRESS 0xFFFF6DD4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_dyn_iga_n_dif
			"Vxx_dyn_iga_n_dif"
			UBYTE
			F_1_m128_105
			2
			2
			-128
			127
			ECU_ADDRESS 0xFFFF6DB7
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_dyn_iga_tq
			"Vxx_dyn_iga_tq"
			SWORD
			F_0v125_p0_30
			2
			2
			-4096
			4095.875
			ECU_ADDRESS 0xFFFF6DD6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_dyn_re_phs_ofs
			"Vxx_dyn_re_phs_ofs"
			UBYTE
			F_1_p0_165
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6BD5
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_dyn_thr_maf_cor
			"Vxx_dyn_thr_maf_cor"
			SWORD
			F_0v0152588_p0_362
			2
			2
			-500.0003584
			499.9850996
			ECU_ADDRESS 0xFFFF835A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_dyn_tq_iga_efy_degr
			"Vxx_dyn_tq_iga_efy_degr"
			UWORD
			F_0v0015258_p0_48
			2
			2
			0
			99.993303
			ECU_ADDRESS 0xFFFF83BE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_eai_ti_cl_ctr
			"Vxx_eai_ti_cl_ctr"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF6D70
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_eal
			"Vxx_eal"
			UWORD
			F_0v0061035156_p0_23
			2
			2
			0
			399.9938965
			ECU_ADDRESS 0xFFFF83C0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_eal_fac
			"Vxx_eal_fac"
			UWORD
			F_0v0044152_p0_86
			2
			2
			0
			289.350132
			ECU_ADDRESS 0xFFFF83C2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_eal_fl_ocl
			"Vxx_eal_fl_ocl"
			UWORD
			F_0v0061035156_p0_23
			2
			2
			0
			399.9938965
			ECU_ADDRESS 0xFFFF7B58
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_eal_ofs_agb_dri
			"Vxx_eal_ofs_agb_dri"
			UWORD
			F_0v0061035156_p0_23
			2
			2
			0
			399.9938965
			ECU_ADDRESS 0xFFFF7E02
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_eal_tdc_2
			"Vxx_eal_tdc_2"
			UWORD
			F_0v0061035156_p0_23
			2
			2
			0
			399.9938965
			ECU_ADDRESS 0xFFFF83C4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_eal_tdc_4
			"Vxx_eal_tdc_4"
			UWORD
			F_0v0061035156_p0_23
			2
			2
			0
			399.9938965
			ECU_ADDRESS 0xFFFF83C6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_edic_dly
			"Vxx_edic_dly"
			UBYTE
			F_128_p0_125
			2
			2
			0
			32640
			ECU_ADDRESS 0xFFFF7D9A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_efv_ti
			"Vxx_efv_ti"
			UWORD
			F_3v2_p0_152
			2
			2
			0
			209712
			ECU_ADDRESS 0xFFFF7B5A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_el_bk_wind_is_cor
			"Vxx_el_bk_wind_is_cor"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF79E4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_el_bk_wind_is_cor_dly
			"Vxx_el_bk_wind_is_cor_dly"
			UBYTE
			F_16_p0_10
			2
			2
			0
			4080
			ECU_ADDRESS 0xFFFF79C5
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_el_bk_wind_min_is_n
			"Vxx_el_bk_wind_min_is_n"
			UBYTE
			F_16_p0_83
			2
			2
			0
			4080
			ECU_ADDRESS 0xFFFF80F5
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_el_csm_clc_dly
			"Vxx_el_csm_clc_dly"
			UBYTE
			F_128_p0_125
			2
			2
			0
			32640
			ECU_ADDRESS 0xFFFF80F6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_el_csm_ctr
			"Vxx_el_csm_ctr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF86D8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_el_wind_is_cor
			"Vxx_el_wind_is_cor"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF79E6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_el_wind_is_cor_dly
			"Vxx_el_wind_is_cor_dly"
			UBYTE
			F_16_p0_10
			2
			2
			0
			4080
			ECU_ADDRESS 0xFFFF79C6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_el_wind_min_is_n
			"Vxx_el_wind_min_is_n"
			UBYTE
			F_16_p0_83
			2
			2
			0
			4080
			ECU_ADDRESS 0xFFFF80F7
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ena_off_obd_dly
			"Vxx_ena_off_obd_dly"
			UBYTE
			F_4_p0_163
			2
			2
			0
			1020
			ECU_ADDRESS 0xFFFF7877
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_eng_driv_tqe_sp
			"Vxx_eng_driv_tqe_sp"
			UWORD
			F_0v0078125_m100_35
			2
			2
			-100
			411.9921875
			ECU_ADDRESS 0xFFFF780C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_eng_driv_tqe_sp_old
			"Vxx_eng_driv_tqe_sp_old"
			UWORD
			F_0v0078125_m100_35
			2
			2
			-100
			411.9921875
			ECU_ADDRESS 0xFFFF780E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_eng_per
			"Vxx_eng_per"
			UWORD
			F_4_p0_149
			2
			2
			0
			262140
			ECU_ADDRESS 0xFFFF811C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_eng_per_32
			"Vxx_eng_per_32"
			UWORD
			F_3v2_p0_152
			2
			2
			0
			209712
			ECU_ADDRESS 0xFFFF7FAA
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_eng_per_sum
			"Vxx_eng_per_sum"
			UWORD
			F_6v4_p0_140
			2
			2
			0
			419424
			ECU_ADDRESS 0xFFFF829E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_eng_run_rst_nr
			"Vxx_eng_run_rst_nr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF86C0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_eng_vol_fill_efv_drv
			"Vxx_eng_vol_fill_efv_drv"
			SWORD
			F_0v0001220703_p0_363
			2
			2
			-3.99999959
			3.99987752
			ECU_ADDRESS 0xFFFF835C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_eng_vol_fill_efy
			"Vxx_eng_vol_fill_efy"
			UWORD
			F_0v00305175_p0_364
			2
			2
			0
			199.9964363
			ECU_ADDRESS 0xFFFF83C8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_eng_vol_fill_efy_precedent
			"Vxx_eng_vol_fill_efy_precedent"
			UWORD
			F_0v00305175_p0_365
			2
			2
			0
			199.9964363
			ECU_ADDRESS 0xFFFF83CA
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_equ_tco
			"Vxx_equ_tco"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF80DC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_err_ctr_mfld_pws_thr
			"Vxx_err_ctr_mfld_pws_thr"
			UBYTE
			F_1_p0_53
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8052
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_err_cylr_ctr
			"Vxx_err_cylr_ctr"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF867A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_err_cylr_is_run_ctr
			"Vxx_err_cylr_is_run_ctr"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF867C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_err_id_is_run_ctr
			"Vxx_err_id_is_run_ctr"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF8674
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_esti_driv_tq
			"Vxx_esti_driv_tq"
			UBYTE
			F_2_m100_36
			2
			2
			-100
			410
			ECU_ADDRESS 0xFFFF8330
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_esti_tqe
			"Vxx_esti_tqe"
			UBYTE
			F_2_m100_36
			2
			2
			-100
			410
			ECU_ADDRESS 0xFFFF8331
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_esti_tqe16
			"Vxx_esti_tqe16"
			UWORD
			F_0v0078125_m100_35
			2
			2
			-100
			411.9921875
			ECU_ADDRESS 0xFFFF83CC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ex_gaz_fil_fac
			"Vxx_ex_gaz_fil_fac"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7D9B
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ex_gaz_temp_fil_val
			"Vxx_ex_gaz_temp_fil_val"
			UWORD
			F_0v015625_m40_366
			2
			2
			-40
			983.984375
			ECU_ADDRESS 0xFFFF7E04
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ex_gaz_temp_ofs_vs
			"Vxx_ex_gaz_temp_ofs_vs"
			UBYTE
			F_4_p0_89
			2
			2
			0
			1020
			ECU_ADDRESS 0xFFFF7D9C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ex_gaz_temp_val
			"Vxx_ex_gaz_temp_val"
			UBYTE
			F_4_m40_88
			2
			2
			-40
			980
			ECU_ADDRESS 0xFFFF7D9D
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ex_prs
			"Vxx_ex_prs"
			UWORD
			F_3v7_p103_37
			2
			2
			103
			242582.5
			ECU_ADDRESS 0xFFFF84DC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ext_fail_ctr_vs
			"Vxx_ext_fail_ctr_vs"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8290
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fast_ad_cdn_dly
			"Vxx_fast_ad_cdn_dly"
			UWORD
			F_32_p0_122
			2
			2
			0
			2097120
			ECU_ADDRESS 0xFFFF79E8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fast_agb_tq_sp
			"Vxx_fast_agb_tq_sp"
			UBYTE
			F_2_m100_36
			2
			2
			-100
			410
			ECU_ADDRESS 0xFFFF7335
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fast_asr_tq_sp
			"Vxx_fast_asr_tq_sp"
			UBYTE
			F_2_m100_36
			2
			2
			-100
			410
			ECU_ADDRESS 0xFFFF7336
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fast_pdl_ad_ctr
			"Vxx_fast_pdl_ad_ctr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7FC1
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fast_slop_ctr
			"Vxx_fast_slop_ctr"
			UWORD
			F_1_p0_53
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7B5C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fast_tqr_cor
			"Vxx_fast_tqr_cor"
			UWORD
			F_0v0015258789_p0_115
			2
			2
			0
			99.99847412
			ECU_ADDRESS 0xFFFF83CE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fil1_thr_psn_sp
			"Vxx_fil1_thr_psn_sp"
			UWORD
			F_0v097656_p0_5
			2
			2
			0
			6399.88596
			ECU_ADDRESS 0xFFFF83E0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fil2_thr_psn_sp
			"Vxx_fil2_thr_psn_sp"
			UWORD
			F_0v097656_p0_5
			2
			2
			0
			6399.88596
			ECU_ADDRESS 0xFFFF83E2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fil_alt_pow
			"Vxx_fil_alt_pow"
			UWORD
			F_20_p0_63
			2
			2
			0
			1310700
			ECU_ADDRESS 0xFFFF83D0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fil_alt_pow_mem
			"Vxx_fil_alt_pow_mem"
			ULONG
			F_0v078125_p0_367
			2
			2
			0
			335544319.9
			ECU_ADDRESS 0xFFFF8318
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fil_alt_tq
			"Vxx_fil_alt_tq"
			UWORD
			F_0v0078125_p0_15
			2
			2
			0
			511.9921875
			ECU_ADDRESS 0xFFFF83D2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fil_alt_tq_mem
			"Vxx_fil_alt_tq_mem"
			ULONG
			F_0v0000305176_p0_368
			2
			2
			0
			131072
			ECU_ADDRESS 0xFFFF831C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fil_alti
			"Vxx_fil_alti"
			UWORD
			F_0v014453_p0_369
			2
			2
			0
			947.177355
			ECU_ADDRESS 0xFFFF8602
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fil_esti_tqe
			"Vxx_fil_esti_tqe"
			UBYTE
			F_2_m100_36
			2
			2
			-100
			410
			ECU_ADDRESS 0xFFFF8332
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fil_esti_tqe16
			"Vxx_fil_esti_tqe16"
			UWORD
			F_0v0078125_m100_35
			2
			2
			-100
			411.9921875
			ECU_ADDRESS 0xFFFF83D4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fil_fac_cor_thr_adj
			"Vxx_fil_fac_cor_thr_adj"
			UWORD
			F_3v05176_m100000_370
			2
			2
			-100000
			99997.0916
			ECU_ADDRESS 0xFFFF6CFE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fil_fac_cor_thr_adj_mem
			"Vxx_fil_fac_cor_thr_adj_mem"
			ULONG
			F_0v0000465_m100000_371
			2
			2
			-100000
			99715.97922
			ECU_ADDRESS 0xFFFF6C18
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fil_inj_clos_angl_ctr
			"Vxx_fil_inj_clos_angl_ctr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7ACB
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fil_is_i_ad
			"Vxx_fil_is_i_ad"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF79EA
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fil_lbdw_v
			"Vxx_fil_lbdw_v"
			UWORD
			F_0v038125_p0_237
			2
			2
			0
			2498.521875
			ECU_ADDRESS 0xFFFF7B5E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fil_map_spg_dif1
			"Vxx_fil_map_spg_dif1"
			SWORD
			F_0v0009033203_p0_372
			2
			2
			-29.59999959
			29.59909627
			ECU_ADDRESS 0xFFFF7F00
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fil_map_spg_dif2
			"Vxx_fil_map_spg_dif2"
			SWORD
			F_0v057813_p0_373
			2
			2
			-1894.416384
			1894.358571
			ECU_ADDRESS 0xFFFF8600
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fil_map_thr_adj
			"Vxx_fil_map_thr_adj"
			UWORD
			F_3v7_p103_37
			2
			2
			103
			242582.5
			ECU_ADDRESS 0xFFFF6D00
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fil_map_thr_adj_mem
			"Vxx_fil_map_thr_adj_mem"
			ULONG
			F_0v00005646_p103_374
			2
			2
			103
			242596.8535
			ECU_ADDRESS 0xFFFF6C1C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fil_max_tqi
			"Vxx_fil_max_tqi"
			UWORD
			F_0v0078125_m100_35
			2
			2
			-100
			411.9921875
			ECU_ADDRESS 0xFFFF83D6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fil_mdl_map_thr_adj
			"Vxx_fil_mdl_map_thr_adj"
			UWORD
			F_3v7_p103_37
			2
			2
			103
			242582.5
			ECU_ADDRESS 0xFFFF6D02
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fil_mdl_map_thr_adj_mem
			"Vxx_fil_mdl_map_thr_adj_mem"
			ULONG
			F_0v00005646_p103_374
			2
			2
			103
			242596.8535
			ECU_ADDRESS 0xFFFF6C20
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fil_mux_slow_tq_sp
			"Vxx_fil_mux_slow_tq_sp"
			UWORD
			F_0v0078125_m100_35
			2
			2
			-100
			411.9921875
			ECU_ADDRESS 0xFFFF6DDA
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fil_mux_slow_tq_sp_mem
			"Vxx_fil_mux_slow_tq_sp_mem"
			ULONG
			Id_0x00
			2
			2
			0
			4294967295
			ECU_ADDRESS 0xFFFF6D88
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fil_n_drv
			"Vxx_fil_n_drv"
			SBYTE
			F_19_p0_221
			2
			2
			-2432
			2413
			ECU_ADDRESS 0xFFFF8322
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fil_n_thr_adj
			"Vxx_fil_n_thr_adj"
			UWORD
			F_1_p0_14
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF6D04
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fil_n_thr_adj_mem
			"Vxx_fil_n_thr_adj_mem"
			ULONG
			F_0v000015259_p0_375
			2
			2
			0
			65536.90595
			ECU_ADDRESS 0xFFFF6C24
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fil_pred_prs
			"Vxx_fil_pred_prs"
			UWORD
			F_3v7_p103_37
			2
			2
			103
			242582.5
			ECU_ADDRESS 0xFFFF83D8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fil_stab_max_tqi
			"Vxx_fil_stab_max_tqi"
			UWORD
			F_0v0078125_p0_15
			2
			2
			0
			511.9921875
			ECU_ADDRESS 0xFFFF83DA
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fil_t_toth_0_lsb
			"Vxx_fil_t_toth_0_lsb"
			UWORD
			F_0v1_p0_275
			2
			2
			0
			6553.5
			ECU_ADDRESS 0xFFFF7F6E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fil_t_toth_0_msb
			"Vxx_fil_t_toth_0_msb"
			UWORD
			F_6v5536_p0_274
			2
			2
			0
			429490.176
			ECU_ADDRESS 0xFFFF7F6C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fil_t_toth_1_lsb
			"Vxx_fil_t_toth_1_lsb"
			UWORD
			F_0v1_p0_275
			2
			2
			0
			6553.5
			ECU_ADDRESS 0xFFFF7F72
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fil_t_toth_1_msb
			"Vxx_fil_t_toth_1_msb"
			UWORD
			F_6v5536_p0_274
			2
			2
			0
			429490.176
			ECU_ADDRESS 0xFFFF7F70
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fil_t_toth_2_lsb
			"Vxx_fil_t_toth_2_lsb"
			UWORD
			F_0v1_p0_275
			2
			2
			0
			6553.5
			ECU_ADDRESS 0xFFFF7F76
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fil_t_toth_2_msb
			"Vxx_fil_t_toth_2_msb"
			UWORD
			F_6v5536_p0_274
			2
			2
			0
			429490.176
			ECU_ADDRESS 0xFFFF7F74
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fil_t_toth_3_lsb
			"Vxx_fil_t_toth_3_lsb"
			UWORD
			F_0v1_p0_275
			2
			2
			0
			6553.5
			ECU_ADDRESS 0xFFFF7F7A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fil_t_toth_3_msb
			"Vxx_fil_t_toth_3_msb"
			UWORD
			F_6v5536_p0_274
			2
			2
			0
			429490.176
			ECU_ADDRESS 0xFFFF7F78
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fil_t_toth_4_lsb
			"Vxx_fil_t_toth_4_lsb"
			UWORD
			F_0v1_p0_275
			2
			2
			0
			6553.5
			ECU_ADDRESS 0xFFFF7F7E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fil_t_toth_4_msb
			"Vxx_fil_t_toth_4_msb"
			UWORD
			F_6v5536_p0_274
			2
			2
			0
			429490.176
			ECU_ADDRESS 0xFFFF7F7C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fil_t_toth_5_lsb
			"Vxx_fil_t_toth_5_lsb"
			UWORD
			F_0v1_p0_275
			2
			2
			0
			6553.5
			ECU_ADDRESS 0xFFFF7F82
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fil_t_toth_5_msb
			"Vxx_fil_t_toth_5_msb"
			UWORD
			F_6v5536_p0_274
			2
			2
			0
			429490.176
			ECU_ADDRESS 0xFFFF7F80
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fil_thr_pos_thr_adj
			"Vxx_fil_thr_pos_thr_adj"
			UWORD
			F_0v097656_p0_5
			2
			2
			0
			6399.88596
			ECU_ADDRESS 0xFFFF6D06
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fil_thr_pos_thr_adj_mem
			"Vxx_fil_thr_pos_thr_adj_mem"
			ULONG
			F_0v00000149_p0_376
			2
			2
			0
			6399.50127
			ECU_ADDRESS 0xFFFF6C28
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fil_thr_psn_dif
			"Vxx_fil_thr_psn_dif"
			UWORD
			F_0v0015625_p0_377
			2
			2
			0
			102.3984375
			ECU_ADDRESS 0xFFFF7F06
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fil_thr_psn_sp
			"Vxx_fil_thr_psn_sp"
			UWORD
			F_0v097656_p0_5
			2
			2
			0
			6399.88596
			ECU_ADDRESS 0xFFFF83DC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fil_thr_psn_sp_memory
			"Vxx_fil_thr_psn_sp_memory"
			UWORD
			F_0v097656_p0_5
			2
			2
			0
			6399.88596
			ECU_ADDRESS 0xFFFF7756
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fil_thr_psn_sp_prec_1
			"Vxx_fil_thr_psn_sp_prec_1"
			UWORD
			F_0v097656_p0_5
			2
			2
			0
			6399.88596
			ECU_ADDRESS 0xFFFF7758
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fil_tkof_tq_cor
			"Vxx_fil_tkof_tq_cor"
			SWORD
			F_0v0078125_p0_15
			2
			2
			-256
			255.9921875
			ECU_ADDRESS 0xFFFF835E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fil_tq_ovn_cor
			"Vxx_fil_tq_ovn_cor"
			UWORD
			F_0v0078125_p0_15
			2
			2
			0
			511.9921875
			ECU_ADDRESS 0xFFFF83DE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fil_tq_rat_ovn
			"Vxx_fil_tq_rat_ovn"
			UBYTE
			F_0v390625_p0_4
			2
			2
			0
			99.609375
			ECU_ADDRESS 0xFFFF8333
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fil_tq_rat_sp
			"Vxx_fil_tq_rat_sp"
			UBYTE
			F_0v390625_p0_4
			2
			2
			0
			99.609375
			ECU_ADDRESS 0xFFFF8334
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fil_trt_sp_lim
			"Vxx_fil_trt_sp_lim"
			UWORD
			F_0v09765625_p0_71
			2
			2
			0
			6399.902344
			ECU_ADDRESS 0xFFFF775A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fil_vb
			"Vxx_fil_vb"
			UWORD
			F_0v000125_p8_7
			2
			2
			8
			16.191875
			ECU_ADDRESS 0xFFFF6DEC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fil_vs_n_rat
			"Vxx_fil_vs_n_rat"
			UWORD
			F_0v0015259_p0_78
			2
			2
			0
			99.9998565
			ECU_ADDRESS 0xFFFF811E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fil_vs_n_rat_prec
			"Vxx_fil_vs_n_rat_prec"
			UWORD
			F_0v0015259_p0_78
			2
			2
			0
			99.9998565
			ECU_ADDRESS 0xFFFF8120
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fil_vs_n_rat_prec2
			"Vxx_fil_vs_n_rat_prec2"
			UWORD
			F_0v0015259_p0_78
			2
			2
			0
			99.9998565
			ECU_ADDRESS 0xFFFF8122
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fill_efv_cor_ol
			"Vxx_fill_efv_cor_ol"
			SWORD
			F_1_p0_9
			2
			2
			-32768
			32767
			ECU_ADDRESS 0xFFFF7B04
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fill_efy_n_mpl
			"Vxx_fill_efy_n_mpl"
			UWORD
			F_0v25_p0_378
			2
			2
			0
			16383.75
			ECU_ADDRESS 0xFFFF8032
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fl_dsb_dly
			"Vxx_fl_dsb_dly"
			UWORD
			F_4v096_p0_12
			2
			2
			0
			268431.36
			ECU_ADDRESS 0xFFFF7B60
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fl_rich_fac
			"Vxx_fl_rich_fac"
			UWORD
			F_0v00260417_p0v667_32
			2
			2
			0.667
			171.331281
			ECU_ADDRESS 0xFFFF7B62
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fmt_pdl_psn_rat
			"Vxx_fmt_pdl_psn_rat"
			UWORD
			F_0v001526_p0_42
			2
			2
			0
			100.00641
			ECU_ADDRESS 0xFFFF8018
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fmt_tq_air_dly_t
			"Vxx_fmt_tq_air_dly_t"
			UWORD
			F_3v2_p0_152
			2
			2
			0
			209712
			ECU_ADDRESS 0xFFFF7A3A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_frm_dft_lght_on_km
			"Vxx_frm_dft_lght_on_km"
			UWORD
			F_71v111114_p0_379
			2
			2
			0
			4660266.856
			ECU_ADDRESS 0xFFFF7644
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_frn_tq_loss
			"Vxx_frn_tq_loss"
			UWORD
			F_0v0078125_p0_15
			2
			2
			0
			511.9921875
			ECU_ADDRESS 0xFFFF83E4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fsys_cor_ti_fac
			"Vxx_fsys_cor_ti_fac"
			UWORD
			F_1_p0_9
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7E06
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fsys_cor_ti_fac_max
			"Vxx_fsys_cor_ti_fac_max"
			UWORD
			F_1_p0_9
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7E08
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fsys_cor_ti_fac_min
			"Vxx_fsys_cor_ti_fac_min"
			UWORD
			F_1_p0_9
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7E0A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fsys_dft_dly
			"Vxx_fsys_dft_dly"
			UBYTE
			F_1024_p0_189
			2
			2
			0
			261120
			ECU_ADDRESS 0xFFFF7D9E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fsys_dly
			"Vxx_fsys_dly"
			UBYTE
			F_1024_p0_189
			2
			2
			0
			261120
			ECU_ADDRESS 0xFFFF7D9F
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fsys_thd_2_dly
			"Vxx_fsys_thd_2_dly"
			UWORD
			F_1024_p0_189
			2
			2
			0
			67107840
			ECU_ADDRESS 0xFFFF7E0C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_fzy_tkof
			"Vxx_fzy_tkof"
			UBYTE
			F_0v00390625_p0_90
			2
			2
			0
			0.99609375
			ECU_ADDRESS 0xFFFF77FA
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_gas_inj_avl_nr
			"Vxx_gas_inj_avl_nr"
			UBYTE
			F_1_p0_9
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7ACC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_gas_inj_cut_nr
			"Vxx_gas_inj_cut_nr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7ACD
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_gas_lpg_trs_cor_dec
			"Vxx_gas_lpg_trs_cor_dec"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7971
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_gas_lpg_trs_cor_inc
			"Vxx_gas_lpg_trs_cor_inc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7972
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_gas_lpg_trs_cor_ini
			"Vxx_gas_lpg_trs_cor_ini"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7973
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_gas_pump_dly
			"Vxx_gas_pump_dly"
			UBYTE
			F_0v128_p0_75
			2
			2
			0
			32.64
			ECU_ADDRESS 0xFFFF8155
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_gas_trs_cor_min
			"Vxx_gas_trs_cor_min"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7974
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_gas_trs_cor_stop
			"Vxx_gas_trs_cor_stop"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7975
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_gear
			"Vxx_gear"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF80CE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_gear_1
			"Vxx_gear_1"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF80CF
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_gear_cge_dec_dly
			"Vxx_gear_cge_dec_dly"
			UWORD
			F_0v008_p0_172
			2
			2
			0
			524.28
			ECU_ADDRESS 0xFFFF78C6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_gear_cge_dly
			"Vxx_gear_cge_dly"
			UWORD
			F_16_p0_10
			2
			2
			0
			1048560
			ECU_ADDRESS 0xFFFF78C8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_gear_cge_eal_dly
			"Vxx_gear_cge_eal_dly"
			UWORD
			F_16_p0_10
			2
			2
			0
			1048560
			ECU_ADDRESS 0xFFFF78CA
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_gear_cge_fast_lim_dly
			"Vxx_gear_cge_fast_lim_dly"
			UWORD
			F_0v008_p0_172
			2
			2
			0
			524.28
			ECU_ADDRESS 0xFFFF78CC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_gear_cge_fmt
			"Vxx_gear_cge_fmt"
			UBYTE
			F_0v00390625_p0_90
			2
			2
			0
			0.99609375
			ECU_ADDRESS 0xFFFF78C3
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_gear_cge_l_tq
			"Vxx_gear_cge_l_tq"
			UWORD
			F_0v0078125_m100_35
			2
			2
			-100
			411.9921875
			ECU_ADDRESS 0xFFFF83E6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_gear_cge_l_tq_dly
			"Vxx_gear_cge_l_tq_dly"
			UWORD
			F_0v008_p0_172
			2
			2
			0
			524.28
			ECU_ADDRESS 0xFFFF78CE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_gear_cge_vs_dly
			"Vxx_gear_cge_vs_dly"
			UWORD
			F_16_p0_10
			2
			2
			0
			1048560
			ECU_ADDRESS 0xFFFF78D0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_gear_ctr
			"Vxx_gear_ctr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF78C4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_gear_fil_val_clc
			"Vxx_gear_fil_val_clc"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF80D6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_gear_mem
			"Vxx_gear_mem"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF80D0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_gear_mux_val_clc
			"Vxx_gear_mux_val_clc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF80D1
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_gear_prec
			"Vxx_gear_prec"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF78C5
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_gear_red_rat
			"Vxx_gear_red_rat"
			UBYTE
			F_0v00390625_p0_90
			2
			2
			0
			0.99609375
			ECU_ADDRESS 0xFFFF81E7
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_gear_red_rat_ini
			"Vxx_gear_red_rat_ini"
			UBYTE
			F_0v00390625_p0_90
			2
			2
			0
			0.99609375
			ECU_ADDRESS 0xFFFF81E8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_gear_val_clc
			"Vxx_gear_val_clc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF80D2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_h_cge_n_dly
			"Vxx_h_cge_n_dly"
			UWORD
			F_0v008_p0_172
			2
			2
			0
			524.28
			ECU_ADDRESS 0xFFFF78D2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_h_dyn_efy_cor
			"Vxx_h_dyn_efy_cor"
			UWORD
			F_0v24414_p0_263
			2
			2
			0
			15999.7149
			ECU_ADDRESS 0xFFFF7A3C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_h_maf_sp
			"Vxx_h_maf_sp"
			UWORD
			F_0v0000152588_p0_27
			2
			2
			0
			0.9999847412
			ECU_ADDRESS 0xFFFF83E8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_h_prs_ac_dsb_dly
			"Vxx_h_prs_ac_dsb_dly"
			UBYTE
			F_1v024_p0_119
			2
			2
			0
			261.12
			ECU_ADDRESS 0xFFFF745F
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_h_ti_p_cor
			"Vxx_h_ti_p_cor"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7B64
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_hot_rst_ctr
			"Vxx_hot_rst_ctr"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF86B0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_id_fail_trg
			"Vxx_id_fail_trg"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7E0E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_iga
			"Vxx_iga"
			UBYTE
			F_0v375_m23v625_6
			2
			2
			-23.625
			72
			ECU_ADDRESS 0xFFFF6DB8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_iga_appl
			"Vxx_iga_appl"
			UBYTE
			F_0v375_m23v625_6
			2
			2
			-23.625
			72
			ECU_ADDRESS 0xFFFF7A22
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_iga_appl_aftr
			"Vxx_iga_appl_aftr"
			UBYTE
			F_0v375_m23v625_6
			2
			2
			-23.625
			72
			ECU_ADDRESS 0xFFFF7A23
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_iga_bas_efy_degr
			"Vxx_iga_bas_efy_degr"
			UWORD
			F_0v0015258_p0_48
			2
			2
			0
			99.993303
			ECU_ADDRESS 0xFFFF7A3E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_iga_bas_lim
			"Vxx_iga_bas_lim"
			UBYTE
			F_0v375_m23v625_6
			2
			2
			-23.625
			72
			ECU_ADDRESS 0xFFFF7A24
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_iga_fl_cor
			"Vxx_iga_fl_cor"
			UBYTE
			F_0v375_p0_33
			2
			2
			0
			95.625
			ECU_ADDRESS 0xFFFF6DB9
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_iga_is_deci_in_dly
			"Vxx_iga_is_deci_in_dly"
			UWORD
			F_32_p0_122
			2
			2
			0
			2097120
			ECU_ADDRESS 0xFFFF6DDC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_iga_min_efy
			"Vxx_iga_min_efy"
			UWORD
			F_0v0015258_p0_48
			2
			2
			0
			99.993303
			ECU_ADDRESS 0xFFFF7A40
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_iga_min_ref
			"Vxx_iga_min_ref"
			UBYTE
			F_0v375_m23v625_6
			2
			2
			-23.625
			72
			ECU_ADDRESS 0xFFFF7A25
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_iga_ofs
			"Vxx_iga_ofs"
			UBYTE
			F_0v375_m23v625_6
			2
			2
			-23.625
			72
			ECU_ADDRESS 0xFFFF7A26
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_iga_ofs_aftr
			"Vxx_iga_ofs_aftr"
			UBYTE
			F_0v375_m23v625_6
			2
			2
			-23.625
			72
			ECU_ADDRESS 0xFFFF7A27
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_iga_wup_cor
			"Vxx_iga_wup_cor"
			UBYTE
			F_0v375_m48_41
			2
			2
			-48
			47.625
			ECU_ADDRESS 0xFFFF6DBA
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_imd_ti_ad_fac
			"Vxx_imd_ti_ad_fac"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7ACE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_imd_ti_ad_ofs
			"Vxx_imd_ti_ad_ofs"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7ACF
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_in_vol_rat
			"Vxx_in_vol_rat"
			UWORD
			F_0v00076_p0_380
			2
			2
			0
			49.8066
			ECU_ADDRESS 0xFFFF83EA
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_in_vvtc_angl
			"Vxx_in_vvtc_angl"
			UBYTE
			F_0v375_p0_29
			2
			2
			0
			95.625
			ECU_ADDRESS 0xFFFF8530
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_in_vvtc_angl_fil
			"Vxx_in_vvtc_angl_fil"
			UBYTE
			F_0v375_p0_29
			2
			2
			0
			95.625
			ECU_ADDRESS 0xFFFF8531
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_in_vvtc_angl_fil_mem
			"Vxx_in_vvtc_angl_fil_mem"
			ULONG
			F_0v0014648438_p0_381
			2
			2
			0
			6291455.999
			ECU_ADDRESS 0xFFFF8520
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_in_vvtc_angl_max
			"Vxx_in_vvtc_angl_max"
			UBYTE
			F_0v375_p0_29
			2
			2
			0
			95.625
			ECU_ADDRESS 0xFFFF7DA0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_in_vvtc_angl_min
			"Vxx_in_vvtc_angl_min"
			UBYTE
			F_0v375_p0_29
			2
			2
			0
			95.625
			ECU_ADDRESS 0xFFFF7DA1
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_in_vvtc_fil_fac
			"Vxx_in_vvtc_fil_fac"
			UBYTE
			F_0v390625_p0_4
			2
			2
			0
			99.609375
			ECU_ADDRESS 0xFFFF77AA
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_in_vvtc_mov_vs
			"Vxx_in_vvtc_mov_vs"
			UWORD
			F_0v375_m200_382
			2
			2
			-200
			24375.625
			ECU_ADDRESS 0xFFFF7E10
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_in_vvtc_mov_vs_max
			"Vxx_in_vvtc_mov_vs_max"
			UWORD
			F_0v375_m200_382
			2
			2
			-200
			24375.625
			ECU_ADDRESS 0xFFFF7E12
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ini_dly
			"Vxx_ini_dly"
			UBYTE
			F_128_p0_125
			2
			2
			0
			32640
			ECU_ADDRESS 0xFFFF7614
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_inj1_appl_ti1
			"Vxx_inj1_appl_ti1"
			UWORD
			F_3v2_p0_152
			2
			2
			0
			209712
			ECU_ADDRESS 0xFFFF7B22
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_inj1_appl_ti2
			"Vxx_inj1_appl_ti2"
			UWORD
			F_3v2_p0_152
			2
			2
			0
			209712
			ECU_ADDRESS 0xFFFF7B2A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_inj1_efv_ti1
			"Vxx_inj1_efv_ti1"
			UWORD
			F_3v2_p0_152
			2
			2
			0
			209712
			ECU_ADDRESS 0xFFFF7B32
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_inj1_efv_ti2
			"Vxx_inj1_efv_ti2"
			UWORD
			F_3v2_p0_152
			2
			2
			0
			209712
			ECU_ADDRESS 0xFFFF7B3A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_inj1_open_angl1
			"Vxx_inj1_open_angl1"
			UBYTE
			F_3_p0_111
			2
			2
			0
			765
			ECU_ADDRESS 0xFFFF7AAF
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_inj1_open_angl2
			"Vxx_inj1_open_angl2"
			UBYTE
			F_3_p0_111
			2
			2
			0
			765
			ECU_ADDRESS 0xFFFF7AB3
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_inj2_appl_ti1
			"Vxx_inj2_appl_ti1"
			UWORD
			F_3v2_p0_152
			2
			2
			0
			209712
			ECU_ADDRESS 0xFFFF7B28
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_inj2_appl_ti2
			"Vxx_inj2_appl_ti2"
			UWORD
			F_3v2_p0_152
			2
			2
			0
			209712
			ECU_ADDRESS 0xFFFF7B30
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_inj2_efv_ti1
			"Vxx_inj2_efv_ti1"
			UWORD
			F_3v2_p0_152
			2
			2
			0
			209712
			ECU_ADDRESS 0xFFFF7B38
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_inj2_efv_ti2
			"Vxx_inj2_efv_ti2"
			UWORD
			F_3v2_p0_152
			2
			2
			0
			209712
			ECU_ADDRESS 0xFFFF7B40
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_inj2_open_angl1
			"Vxx_inj2_open_angl1"
			UBYTE
			F_3_p0_111
			2
			2
			0
			765
			ECU_ADDRESS 0xFFFF7AB2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_inj2_open_angl2
			"Vxx_inj2_open_angl2"
			UBYTE
			F_3_p0_111
			2
			2
			0
			765
			ECU_ADDRESS 0xFFFF7AB6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_inj3_appl_ti1
			"Vxx_inj3_appl_ti1"
			UWORD
			F_3v2_p0_152
			2
			2
			0
			209712
			ECU_ADDRESS 0xFFFF7B24
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_inj3_appl_ti2
			"Vxx_inj3_appl_ti2"
			UWORD
			F_3v2_p0_152
			2
			2
			0
			209712
			ECU_ADDRESS 0xFFFF7B2C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_inj3_efv_ti1
			"Vxx_inj3_efv_ti1"
			UWORD
			F_3v2_p0_152
			2
			2
			0
			209712
			ECU_ADDRESS 0xFFFF7B34
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_inj3_efv_ti2
			"Vxx_inj3_efv_ti2"
			UWORD
			F_3v2_p0_152
			2
			2
			0
			209712
			ECU_ADDRESS 0xFFFF7B3C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_inj3_open_angl1
			"Vxx_inj3_open_angl1"
			UBYTE
			F_3_p0_111
			2
			2
			0
			765
			ECU_ADDRESS 0xFFFF7AB0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_inj3_open_angl2
			"Vxx_inj3_open_angl2"
			UBYTE
			F_3_p0_111
			2
			2
			0
			765
			ECU_ADDRESS 0xFFFF7AB4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_inj4_appl_ti1
			"Vxx_inj4_appl_ti1"
			UWORD
			F_3v2_p0_152
			2
			2
			0
			209712
			ECU_ADDRESS 0xFFFF7B26
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_inj4_appl_ti2
			"Vxx_inj4_appl_ti2"
			UWORD
			F_3v2_p0_152
			2
			2
			0
			209712
			ECU_ADDRESS 0xFFFF7B2E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_inj4_efv_ti1
			"Vxx_inj4_efv_ti1"
			UWORD
			F_3v2_p0_152
			2
			2
			0
			209712
			ECU_ADDRESS 0xFFFF7B36
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_inj4_efv_ti2
			"Vxx_inj4_efv_ti2"
			UWORD
			F_3v2_p0_152
			2
			2
			0
			209712
			ECU_ADDRESS 0xFFFF7B3E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_inj4_open_angl1
			"Vxx_inj4_open_angl1"
			UBYTE
			F_3_p0_111
			2
			2
			0
			765
			ECU_ADDRESS 0xFFFF7AB1
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_inj4_open_angl2
			"Vxx_inj4_open_angl2"
			UBYTE
			F_3_p0_111
			2
			2
			0
			765
			ECU_ADDRESS 0xFFFF7AB5
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_inj_avl_nr
			"Vxx_inj_avl_nr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7AD0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_inj_clos_angl
			"Vxx_inj_clos_angl"
			UBYTE
			F_3_p0_111
			2
			2
			0
			765
			ECU_ADDRESS 0xFFFF7AD1
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_inj_cut_dly
			"Vxx_inj_cut_dly"
			UBYTE
			F_8_p0_56
			2
			2
			0
			2040
			ECU_ADDRESS 0xFFFF7AD2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_inj_cut_nr
			"Vxx_inj_cut_nr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7AD3
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_inj_dly
			"Vxx_inj_dly"
			UWORD
			F_4_p0_149
			2
			2
			0
			262140
			ECU_ADDRESS 0xFFFF7B66
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_inj_mov_ofs
			"Vxx_inj_mov_ofs"
			UBYTE
			F_1_p0_165
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6BD6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_inj_sta_dly
			"Vxx_inj_sta_dly"
			UBYTE
			F_128_p0_125
			2
			2
			0
			32640
			ECU_ADDRESS 0xFFFF7AD4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_inj_stop_n
			"Vxx_inj_stop_n"
			UWORD
			F_1_p0_14
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF8124
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_int_agb_tq
			"Vxx_int_agb_tq"
			UWORD
			F_2_p0_198
			2
			2
			0
			131070
			ECU_ADDRESS 0xFFFF7398
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_inv_dyn_cor_fac
			"Vxx_inv_dyn_cor_fac"
			UBYTE
			F_0v0000305176_p0_383
			2
			2
			0
			0.007781982422
			ECU_ADDRESS 0xFFFF8335
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_inv_dyn_cor_vvt
			"Vxx_inv_dyn_cor_vvt"
			SWORD
			F_0v0152587891_p0_384
			2
			2
			-500
			499.9847412
			ECU_ADDRESS 0xFFFF8360
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_inv_mfld_in_fil_fac
			"Vxx_inv_mfld_in_fil_fac"
			UWORD
			F_0v0976563_p0_385
			2
			2
			0
			6399.90562
			ECU_ADDRESS 0xFFFF83EC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_inv_mfld_out_fil_fac
			"Vxx_inv_mfld_out_fil_fac"
			UWORD
			F_0v00152588_p0_107
			2
			2
			0
			99.9985458
			ECU_ADDRESS 0xFFFF83EE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ip_abst_ctr
			"Vxx_ip_abst_ctr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7337
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ip_abst_mem
			"Vxx_ip_abst_mem"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF88C4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ip_ecu_stt
			"Vxx_ip_ecu_stt"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7338
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_is_ac_cor
			"Vxx_is_ac_cor"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF79EC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_is_ad_cor_dsb_dly
			"Vxx_is_ad_cor_dsb_dly"
			UBYTE
			F_1v024_p0_119
			2
			2
			0
			261.12
			ECU_ADDRESS 0xFFFF79C7
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_is_agb_cor
			"Vxx_is_agb_cor"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF79EE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_is_air_pump_cor
			"Vxx_is_air_pump_cor"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF79F0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_is_alt_pow_cor
			"Vxx_is_alt_pow_cor"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF79F2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_is_cdn_h_n_dly
			"Vxx_is_cdn_h_n_dly"
			UBYTE
			F_32_p0_122
			2
			2
			0
			8160
			ECU_ADDRESS 0xFFFF79C8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_is_cor
			"Vxx_is_cor"
			UWORD
			F_0v0015259_p0_92
			2
			2
			0
			99.9998565
			ECU_ADDRESS 0xFFFF79F4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_is_cp_cor
			"Vxx_is_cp_cor"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF79F6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_is_cylr_ok_ctr
			"Vxx_is_cylr_ok_ctr"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF8678
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_is_d_aj_fac
			"Vxx_is_d_aj_fac"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF79C9
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_is_d_cor
			"Vxx_is_d_cor"
			SWORD
			F_0v0015259_p0_92
			2
			2
			-50.0006912
			49.9991653
			ECU_ADDRESS 0xFFFF79D8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_is_deci_in_dly
			"Vxx_is_deci_in_dly"
			UWORD
			F_32_p0_122
			2
			2
			0
			2097120
			ECU_ADDRESS 0xFFFF79F8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_is_dyn_iga
			"Vxx_is_dyn_iga"
			SBYTE
			F_0v375_p0_29
			2
			2
			-48
			47.625
			ECU_ADDRESS 0xFFFF6D91
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_is_dyn_iga_dly
			"Vxx_is_dyn_iga_dly"
			UBYTE
			F_16_p0_10
			2
			2
			0
			4080
			ECU_ADDRESS 0xFFFF6DBB
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_is_el_cor
			"Vxx_is_el_cor"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF79FA
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_is_hot_ti_cl_dly
			"Vxx_is_hot_ti_cl_dly"
			UBYTE
			F_4v096_p0_12
			2
			2
			0
			1044.48
			ECU_ADDRESS 0xFFFF7AD5
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_is_i
			"Vxx_is_i"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF79FC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_is_i_zon_out_dly
			"Vxx_is_i_zon_out_dly"
			UWORD
			F_32_p0_122
			2
			2
			0
			2097120
			ECU_ADDRESS 0xFFFF79FE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_is_iga
			"Vxx_is_iga"
			UBYTE
			F_0v375_m23v625_6
			2
			2
			-23.625
			72
			ECU_ADDRESS 0xFFFF6DBC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_is_iga_fil_ctr
			"Vxx_is_iga_fil_ctr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6DBD
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_is_in_dly
			"Vxx_is_in_dly"
			UBYTE
			F_32_p0_122
			2
			2
			0
			8160
			ECU_ADDRESS 0xFFFF79CA
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_is_mdf_cor
			"Vxx_is_mdf_cor"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7A00
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_is_min_ad_pwm
			"Vxx_is_min_ad_pwm"
			SWORD
			Id_0x00
			2
			2
			-32768
			32767
			ECU_ADDRESS 0xFFFF86C2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_is_n02
			"Vxx_is_n02"
			UBYTE
			F_2_p600_102
			2
			2
			600
			1110
			ECU_ADDRESS 0xFFFF79CC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_is_n_sp01
			"Vxx_is_n_sp01"
			UWORD
			F_1_p0_14
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF8126
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_is_n_sp16
			"Vxx_is_n_sp16"
			UBYTE
			F_16_p0_83
			2
			2
			0
			4080
			ECU_ADDRESS 0xFFFF80F8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_is_n_sp32
			"Vxx_is_n_sp32"
			UBYTE
			F_32_p0_46
			2
			2
			0
			8160
			ECU_ADDRESS 0xFFFF80F9
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_is_n_stab_fac
			"Vxx_is_n_stab_fac"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF79CB
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_is_p_cor
			"Vxx_is_p_cor"
			SWORD
			F_0v0015259_p0_92
			2
			2
			-50.0006912
			49.9991653
			ECU_ADDRESS 0xFFFF79DA
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_is_ptc_cor
			"Vxx_is_ptc_cor"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7A02
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_is_pwm
			"Vxx_is_pwm"
			UWORD
			F_0v0015259_p0_92
			2
			2
			0
			99.9998565
			ECU_ADDRESS 0xFFFF7A04
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_is_thr_ar_sp
			"Vxx_is_thr_ar_sp"
			UWORD
			F_0v06_p0_212
			2
			2
			0
			3932.1
			ECU_ADDRESS 0xFFFF7A06
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_is_tia_cor
			"Vxx_is_tia_cor"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7A08
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_is_tqe
			"Vxx_is_tqe"
			UBYTE
			F_2_m100_36
			2
			2
			-100
			410
			ECU_ADDRESS 0xFFFF81E9
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_is_wup_cor
			"Vxx_is_wup_cor"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7A0A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_kd_rich_fac
			"Vxx_kd_rich_fac"
			UWORD
			F_0v00260417_p0v667_32
			2
			2
			0.667
			171.331281
			ECU_ADDRESS 0xFFFF7B68
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_knk_acq_fac
			"Vxx_knk_acq_fac"
			UBYTE
			F_0v0039_p0_171
			2
			2
			0
			0.9945
			ECU_ADDRESS 0xFFFF748E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_knk_acq_frq
			"Vxx_knk_acq_frq"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF748F
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_knk_acq_int
			"Vxx_knk_acq_int"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7490
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_knk_fail_ctr
			"Vxx_knk_fail_ctr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7491
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_knk_fil_fac
			"Vxx_knk_fil_fac"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF74E8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_knk_iga_cor_fil_mv
			"Vxx_knk_iga_cor_fil_mv"
			UBYTE
			F_0v375_p0_29
			2
			2
			0
			95.625
			ECU_ADDRESS 0xFFFF8336
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_knk_iga_cor_mv
			"Vxx_knk_iga_cor_mv"
			UBYTE
			F_0v375_p0_29
			2
			2
			0
			95.625
			ECU_ADDRESS 0xFFFF8337
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_knk_iga_fast_cor_inc
			"Vxx_knk_iga_fast_cor_inc"
			UBYTE
			F_0v375_p0_29
			2
			2
			0
			95.625
			ECU_ADDRESS 0xFFFF6DBE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_knk_iga_mv_efy
			"Vxx_knk_iga_mv_efy"
			UWORD
			F_0v1525879_p0_205
			2
			2
			0
			9999.848026
			ECU_ADDRESS 0xFFFF83F0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_knk_iga_slow_cor_mv
			"Vxx_knk_iga_slow_cor_mv"
			UBYTE
			F_0v375_p0_29
			2
			2
			0
			95.625
			ECU_ADDRESS 0xFFFF8338
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_knk_rel_tq_appl_cor
			"Vxx_knk_rel_tq_appl_cor"
			UBYTE
			F_0v390625_p0_4
			2
			2
			0
			99.609375
			ECU_ADDRESS 0xFFFF8339
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_knk_rel_tq_cor
			"Vxx_knk_rel_tq_cor"
			UBYTE
			F_0v390625_p0_4
			2
			2
			0
			99.609375
			ECU_ADDRESS 0xFFFF833A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_knk_rel_tq_cor_dec
			"Vxx_knk_rel_tq_cor_dec"
			UBYTE
			F_0v390625_p0_4
			2
			2
			0
			99.609375
			ECU_ADDRESS 0xFFFF833B
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_knk_rel_tq_cor_inc
			"Vxx_knk_rel_tq_cor_inc"
			UBYTE
			F_0v390625_p0_4
			2
			2
			0
			99.609375
			ECU_ADDRESS 0xFFFF833C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_knk_rel_tq_cor_max
			"Vxx_knk_rel_tq_cor_max"
			UBYTE
			F_0v390625_p0_4
			2
			2
			0
			99.609375
			ECU_ADDRESS 0xFFFF833D
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_knk_rel_tq_cor_stt
			"Vxx_knk_rel_tq_cor_stt"
			UBYTE
			Vxx_knk_rel_tq_cor_stt_conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF833E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_knk_slow_cor_dec_ctr
			"Vxx_knk_slow_cor_dec_ctr"
			UBYTE
			F_1_p0_54
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6DBF
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_knk_slow_cor_max_iga
			"Vxx_knk_slow_cor_max_iga"
			UBYTE
			F_0v375_p0_33
			2
			2
			0
			95.625
			ECU_ADDRESS 0xFFFF86D5
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_knk_tq_cor_dec_ctr
			"Vxx_knk_tq_cor_dec_ctr"
			UBYTE
			F_0v128_p0_75
			2
			2
			0
			32.64
			ECU_ADDRESS 0xFFFF833F
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_knk_tq_cor_inc_ctr
			"Vxx_knk_tq_cor_inc_ctr"
			UBYTE
			F_0v128_p0_75
			2
			2
			0
			32.64
			ECU_ADDRESS 0xFFFF8340
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_knk_win_frst
			"Vxx_knk_win_frst"
			UBYTE
			F_0v375_p0_29
			2
			2
			0
			95.625
			ECU_ADDRESS 0xFFFF7492
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_knk_win_long
			"Vxx_knk_win_long"
			UBYTE
			F_0v375_p0_29
			2
			2
			0
			95.625
			ECU_ADDRESS 0xFFFF7493
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_l_dyn_efy_cor
			"Vxx_l_dyn_efy_cor"
			UWORD
			F_0v24414_p0_263
			2
			2
			0
			15999.7149
			ECU_ADDRESS 0xFFFF7A42
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_l_min_iga_ctr
			"Vxx_l_min_iga_ctr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7A28
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lamb_swi_ctr
			"Vxx_lamb_swi_ctr"
			UBYTE
			F_1_p0_148
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7AD6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_last_iga
			"Vxx_last_iga"
			UBYTE
			F_0v375_m23v625_6
			2
			2
			-23.625
			72
			ECU_ADDRESS 0xFFFF7A29
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_last_iga_efy
			"Vxx_last_iga_efy"
			UWORD
			F_0v015258_p0_93
			2
			2
			0
			999.93303
			ECU_ADDRESS 0xFFFF7A44
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_last_p_cor
			"Vxx_last_p_cor"
			SWORD
			Id_0x00
			2
			2
			-32768
			32767
			ECU_ADDRESS 0xFFFF7B06
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_last_ti_p_cor
			"Vxx_last_ti_p_cor"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7AD7
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lbdw_cata_fil_val
			"Vxx_lbdw_cata_fil_val"
			UWORD
			F_0v038125_p0_386
			2
			2
			0
			2498.521875
			ECU_ADDRESS 0xFFFF7E14
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lbdw_h_lvl_fil_val
			"Vxx_lbdw_h_lvl_fil_val"
			UWORD
			F_0v038125_p0_237
			2
			2
			0
			2498.521875
			ECU_ADDRESS 0xFFFF7E16
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lbdw_hot_cmd_dly
			"Vxx_lbdw_hot_cmd_dly"
			UWORD
			F_4_p0_128
			2
			2
			0
			262140
			ECU_ADDRESS 0xFFFF7EE6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lbdw_hot_dly_ctr
			"Vxx_lbdw_hot_dly_ctr"
			UWORD
			F_1_p0_53
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7EE8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lbdw_hot_stt_t
			"Vxx_lbdw_hot_stt_t"
			UBYTE
			F_0v512_p0_121
			2
			2
			0
			130.56
			ECU_ADDRESS 0xFFFF7EBD
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lbdw_hot_t
			"Vxx_lbdw_hot_t"
			UBYTE
			F_4_p0_163
			2
			2
			0
			1020
			ECU_ADDRESS 0xFFFF7EBE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lbdw_no_oc_det_ctr
			"Vxx_lbdw_no_oc_det_ctr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7EBF
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lbdw_no_scg_det_t
			"Vxx_lbdw_no_scg_det_t"
			UBYTE
			F_64_p0_145
			2
			2
			0
			16320
			ECU_ADDRESS 0xFFFF7EC0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lbdw_pump_crt_dly
			"Vxx_lbdw_pump_crt_dly"
			UBYTE
			F_0v512_p0_121
			2
			2
			0
			130.56
			ECU_ADDRESS 0xFFFF7EC1
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lbdw_pump_crt_t
			"Vxx_lbdw_pump_crt_t"
			UBYTE
			F_0v512_p0_121
			2
			2
			0
			130.56
			ECU_ADDRESS 0xFFFF7EC2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lbdw_scg_det_t
			"Vxx_lbdw_scg_det_t"
			UBYTE
			F_64_p0_145
			2
			2
			0
			16320
			ECU_ADDRESS 0xFFFF7EC3
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lbdw_v
			"Vxx_lbdw_v"
			UBYTE
			F_9v76_p0_45
			2
			2
			0
			2488.8
			ECU_ADDRESS 0xFFFF7EC4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lbdw_v_sp
			"Vxx_lbdw_v_sp"
			UBYTE
			F_9v76_p0_45
			2
			2
			0
			2488.8
			ECU_ADDRESS 0xFFFF7AD8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lbup_acq_ofs_diag
			"Vxx_lbup_acq_ofs_diag"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D6F
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lbup_appl_pwm
			"Vxx_lbup_appl_pwm"
			UBYTE
			F_8v333333_p0_387
			2
			2
			0
			2124.999915
			ECU_ADDRESS 0xFFFF7EC5
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lbup_asd_diag_ctr
			"Vxx_lbup_asd_diag_ctr"
			UBYTE
			F_1_p0_9
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7DA2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lbup_asd_sf
			"Vxx_lbup_asd_sf"
			UBYTE
			F_1_p0_9
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7DA3
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lbup_asd_sf_ctr
			"Vxx_lbup_asd_sf_ctr"
			UBYTE
			F_1_p0_9
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7DA4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lbup_clc_pwm
			"Vxx_lbup_clc_pwm"
			UBYTE
			F_0v390625_p0_4
			2
			2
			0
			99.609375
			ECU_ADDRESS 0xFFFF7EC6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lbup_hot_cmd_dly
			"Vxx_lbup_hot_cmd_dly"
			UWORD
			F_4_p0_128
			2
			2
			0
