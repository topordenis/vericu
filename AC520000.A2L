				Cxx_dtc_ac_rcpt
				Cxx_dtc_acr
				Cxx_dtc_actr_rly
				Cxx_dtc_inj2
				Cxx_dtc_knk
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_Appli
			""
			/begin DEF_CHARACTERISTIC
				Cbx_df_in_fil_ena
				Cbx_thr_sge_ena
				Cbx_ti_cl2_conf
				Cbx_cylr_is_run_gex_appl
				Cbx_cylr_run_ol
				Cbx_thr_mcut_ena
				Ctb_tq_stat_ref
				Cmp_alt_n_lim
				Ctb_psi_fac_cor
				Cbx_alt_tco_cor_vld
				Ctb_t_lbup_hot_rest
				Ctb_t_lbup_hot_sta
				Cbx_alt_typ_tco_cor
				Ctb_tco_mdl
				Cbx_cylr_ena_re_phs
				Cbx_alt_rat_mux_dsb
				Cbx_air_pump_conf
				Cbx_agb_csm_tq_conf
				Autorisation_test_power_latch_
				Autorise_clq_num
				Cbx_agb_conf
				Ctb_tco_dif_max
				Cbx_ac_vld_conf
				Cbx_up_thr_prs_sens
				Cbx_vs_mux
				Cbx_wpmp_conf
				Cmp_alt_n_fac1
				Cmp_alt_n_fac2
				Ctb_pred_map_prs_rat
				Cfgphaac
				Cbx_tsta_conf
				Cbx_ac_mux
				Cfgpsobd
				Cbx_ac_mdf1_cmd
				Ctb_alt_n
				Cbx_ac_l_vc_eng_conf
				Cbx_agb_clck_test_ena
				Cbx_l_pwl_conf
				Cbx_clos_typ_prs_cnt
				Cbx_mux_pwst_prs_dsb
				Cbx_cold_loop_ac
				Cbx_igc_1_4_diag_dsb
				Cbx_igc_2_3_diag_dsb
				Cbx_lbup_typ
				Cbx_alt_v_fil_ena
				Cbx_lbdw
				Cbx_mvac_pump_conf
				Cbx_lbdw_osp_typ
				Cbx_ptc_max_cut_ena_lim
				Cbx_cylr_dyn_iga_off
				Cbx_lbup_conf
				Cbx_crsh_typ_phs_1
				Cbx_thpl_conf
				Cbx_sys_wf_conf
				Cbx_swlk_dsb
				Cbx_lbup_osp_typ
				Cbx_lbdw_typ
				Cbx_cylr_bas_conf
				Cbx_brk_pdl_conf
				Cbx_lbup_dwpt_per_ena
				Cbx_can_emt_flow
				Cbx_rgb_conf
				Cbx_clu_cnt_inv
				Cbx_lbup_hot_cho
				Cxx_n_min_mmv
				Cxx_nr_cyl_dsb_n_thd
				Cxx_mux_pdl_h_thd
				Cxx_n_min_out_cart_iga
				Cxx_n_max_clc_dsb
				Cxx_n_l_alt_crt
				Cxx_n_h_alt_crt
				Cxx_n_alt_rat
				Cxx_mux_pdl_psn_ofs
				Cxx_pfdec_agb_gear
				Cxx_n_mux_emt_max
				Cxx_off_syn_max_toth_nr
				Cxx_pfdec_acr_oc
				Cxx_pfdec_ac_rcpt
				Cxx_pfdec_ac_prs
				Cxx_pdl_ufld_psn_thd
				Cxx_pdl_slow_ad_trs_nr
				Cxx_pdl_max_psn_thd
				Cxx_pfdec_agb_conv_stt
				Cxx_ok_ini_dly
				Cxx_pfdec_acr_scg
				Cxx_off_crk_dly
				Cxx_nr_vld_crk_fail1
				Cxx_nr_tdc_dif_prs_fail
				Cxx_pfdec_acr_vb_sc
				Cxx_mux_pdl_frm_thd2
				Cxx_pfdec_actr_rly
				Cxx_pdl_fast_ad_trs_nr
				Cxx_mfnrsta_vta_intake_pmh
				Cxx_mux_pdl_psn_fac
				Cxx_mfnrsta_vvt_intake_dyn
				Cxx_mfnrsta_vvt_intake_bound
				Cxx_mfnrsta_vvt_intake_blk
				Cxx_mfnrsta_vvt_int_old_off
				Cxx_mfnrsta_vvt_int_ev_vb_sc
				Cxx_mfnrsta_vvt_int_ev_scg
				Cxx_mfnrsta_vvtc_toth_3
				Cxx_mfnrsta_vta_intake_shift
				Cxx_mfnrsta_wat_temp_high
				Cxx_mfnrsta_vs_parasite
				Cxx_mfnrsta_vs_mux
				Cxx_mfnrsta_vs_eal
				Cxx_mfnrsta_vb_low
				Cxx_mfnrsta_vb_high
				Cxx_mfnrsta_tlz_ad_b
				Cxx_pfdec_mastervac_oc
				Cxx_mfnrsta_vvt_int_ev_oc
				Cxx_min_alt_pwm
				Cxx_mux_pdl_frm_thd1
				Cxx_mux_min_n
				Cxx_min_t_toth
				Cxx_min_pwl_dly
				Cxx_min_n_test_acq
				Cxx_min_mes_prs_fail_sens
				Cxx_min_l_alt_pwm_per
				Cxx_mfnrsta_vvt_intake_int
				Cxx_min_amp
				Cxx_pfdec_alt_mux
				Cxx_mfnrsta_wpmp_vb_sc
				Cxx_mfnrsta_wpmp_scg
				Cxx_mfnrsta_wpmp_oc
				Cxx_mfnrsta_wgc_vb_sc
				Cxx_mfnrsta_wgc_scg
				Cxx_mfnrsta_wgc_oc
				Cxx_mfnrsta_wat_temp_low
				Cxx_min_h_alt_pwm_per
				Cxx_pfdec_inj3_scg
				Cxx_pfdec_lbdw_hot_oc
				Cxx_pfdec_knk
				Cxx_pfdec_ip_inj_cnt
				Cxx_pfdec_inj4_vb_sc
				Cxx_pfdec_inj4_scg
				Cxx_pfdec_inj1_oc
				Cxx_pfdec_inj3_vb_sc
				Cxx_pfdec_lbdw_oc
				Cxx_pfdec_inj3_oc
				Cxx_pfdec_inj2_vb_sc
				Cxx_pfdec_inj2_scg
				Cxx_pfdec_inj2_oc
				Cxx_pfdec_inj1_vb_sc
				Cxx_pfdec_alt_ecu
				Cxx_pfdec_inj4_oc
				Cxx_pfdec_lbup_hot_vb_sc
				Cxx_mfnrsta_inj1_scg
				Cxx_pfdec_map_chr
				Cxx_pfdec_map
				Cxx_pfdec_lpg_rcpt
				Cxx_pfdec_lbup_vb_sc
				Cxx_pfdec_lbup_scg
				Cxx_pfdec_lbdw_hot_scg
				Cxx_pfdec_lbup_oc
				Cxx_pfdec_lbdw_hot_vb_sc
				Cxx_pfdec_lbup_hot_scg
				Cxx_pfdec_lbup_hot_oc
				Cxx_pfdec_lbdw_vb_sc
				Cxx_pfdec_lbdw_scg
				Cxx_pfdec_lbdw_pump_crt
				Cxx_pfdec_inj_ecu
				Cxx_pfdec_lbup_pump_crt
				Cxx_pfdec_clu
				Cxx_pfdec_eng_temp_oc
				Cxx_pfdec_el_wind_rcpt
				Cxx_pfdec_crk_nr
				Cxx_pfdec_crk
				Cxx_pfdec_cp_vb_sc
				Cxx_pfdec_inj1_scg
				Cxx_pfdec_cp_oc
				Cxx_pfdec_eng_whl
				Cxx_pfdec_checksum
				Cxx_mfnrsta_tia_high
				Cxx_pfdec_alt_load_in
				Cxx_mfnrsta_tia_low
				Cxx_pfdec_air
				Cxx_pfdec_agb_tq_nok
				Cxx_pfdec_cp_scg
				Cxx_pfdec_igc
				Cxx_pfdec_igc_4_vb_sc
				Cxx_pfdec_igc_4_oc
				Cxx_pfdec_igc_3_vb_sc
				Cxx_pfdec_igc_3_oc
				Cxx_pfdec_igc_2_vb_sc
				Cxx_pfdec_igc_2_oc
				Cxx_pfdec_eng_temp_scg
				Cxx_pfdec_igc_1_oc
				Cxx_pfdec_eng_temp_vb_sc
				Cxx_pfdec_gas_pump_vb_sc
				Cxx_pfdec_gas_pump_scg
				Cxx_pfdec_gas_pump_oc
				Cxx_pfdec_fsys_lpg
				Cxx_pfdec_fsys
				Cxx_pfdec_agb_rcpt
				Cxx_pfdec_igc_1_vb_sc
				Cxx_mfnrsta_mdf2_vb_sc
				Cxx_mfnrsta_mis_cata_3
				Cxx_mfnrsta_mis_cata_2_lpg
				Cxx_mfnrsta_mis_cata_2
				Cxx_mfnrsta_mis_cata_1_lpg
				Cxx_mfnrsta_mis_cata_1
				Cxx_mfnrsta_mis_cata
				Cxx_mfnrsta_mis_polu_gas
				Cxx_mfnrsta_min_gas_lvl
				Cxx_mfnrsta_mis_cata_4_lpg
				Periode_wastegate_turbo
				Cxx_mfnrsta_mdf2_scg
				Cxx_mfnrsta_mdf2_oc
				Cxx_mfnrsta_mdf1_vb_sc
				Cxx_mfnrsta_mdf1_scg
				Cxx_mfnrsta_mdf1_oc
				Cxx_mfnrsta_min_lpg_lvl
				Cxx_mfnrsta_mis_polu
				Cxx_mfnrsta_tjy_ctl
				Cxx_mfnrsta_mis_polu_4
				Cxx_mfnrsta_mis_polu_3_lpg
				Cxx_mfnrsta_mis_polu_3
				Cxx_mfnrsta_mis_polu_2_lpg
				Cxx_mfnrsta_mis_polu_2
				Cxx_mfnrsta_mis_cata_3_lpg
				Cxx_mfnrsta_mis_polu_1
				Cxx_mfnrsta_mis_cata_4
				Cxx_mfnrsta_mis_lih
				Cxx_mfnrsta_mis_fast
				Fcallcyc
				Fcinjcyc
				Cxx_mfnrsta_mis_cata_lpg
				Cxx_mfnrsta_mis_cata_gas
				Cxx_mfnrsta_mastervac_cc
				Cxx_mfnrsta_mis_polu_1_lpg
				Cxx_mfnrsta_inj4_oc
				Cxx_mfnrsta_mcut_sens1
				Seuil_maxi_vbatt_activ_vvt_adm
				Seuil_maxi_vbatt_activ_wastegate
				Cxx_mfnrsta_ip_inj_cnt
				Cxx_mfnrsta_inj4_vb_sc
				Seuil_mini_vbatt_activ_vvt_adm
				Cxx_mfnrsta_lbdw_hot_oc
				Cxx_mfnrsta_inj4_scg
				Cxx_mfnrsta_lbdw_hot_scg
				Cxx_mfnrsta_inj3_vb_sc
				Cxx_mfnrsta_inj3_scg
				Cxx_mfnrsta_inj3_oc
				Cxx_mfnrsta_inj2_vb_sc
				Cxx_mfnrsta_inj2_scg
				Cxx_mfnrsta_inj2_oc
				Cxx_mfnrsta_inj1_vb_sc
				Seuil_mini_vbatt_activ_wastegate
				Cxx_mfnrsta_lbup_hot_vb_sc
				Cxx_mfnrsta_mis_polu_lpg
				Cxx_mfnrsta_map_chr
				Cxx_mfnrsta_map
				Cxx_mfnrsta_lpg_rcpt
				Cxx_mfnrsta_lbup_vb_sc
				Cxx_mfnrsta_lbup_scg
				Cxx_mfnrsta_knk
				Cxx_mfnrsta_lbup_oc
				Cxx_mfnrsta_mastervac_oc
				Cxx_mfnrsta_lbup_hot_scg
				Cxx_mfnrsta_lbup_hot_oc
				Cxx_mfnrsta_lbdw_vb_sc
				Cxx_mfnrsta_lbdw_scg
				Cxx_mfnrsta_lbdw_pump_crt
				Cxx_mfnrsta_lbdw_oc
				Cxx_mfnrsta_lbdw_hot_vb_sc
				Cxx_mfnrsta_lbup_pump_crt
				Cxx_mfnrsta_sa_ev_oc
				Cxx_mfnrsta_svkl_chk_springs
				Cxx_mfnrsta_spg_sys
				Cxx_mfnrsta_spg
				Cxx_mfnrsta_sa_vb_sc
				Cxx_mfnrsta_sa_scg
				Cxx_mfnrsta_sa_oc
				Cxx_mfnrsta_mis_polu_4_lpg
				Cxx_mfnrsta_sa_ev_scg
				Cxx_mfnrsta_svkl_psn
				Cxx_mfnrsta_rmc_timeoutpp
				Cxx_mfnrsta_rmc_pedmpp
				Cxx_mfnrsta_rmc_papmpp
				Cxx_mfnrsta_rmc_monitpp
				Cxx_mfnrsta_rmc_inhwp
				Cxx_mfnrsta_rmc_comspipp
				Cxx_mfnrsta_sa_ev_vb_sc
				Cxx_mfnrsta_thpl_scg
				Cxx_mfnrsta_thr_sens2_vb_sc
				Cxx_mfnrsta_thr_sens2_scg
				Cxx_mfnrsta_thr_sens1_vb_sc
				Cxx_mfnrsta_thr_sens1_oc
				Cxx_mfnrsta_thr_sens_chr
				Cxx_mfnrsta_thr_cmd_vb_sc
				Cxx_mfnrsta_svkl_lih
				Cxx_mfnrsta_thpl_vb_sc
				Cxx_mfnrsta_svkl_oc
				Cxx_mfnrsta_thpl_oc
				Cxx_mfnrsta_tco_chr
				Cxx_mfnrsta_tco_acq
				Cxx_mfnrsta_swlk_mem
				Cxx_mfnrsta_svkl_trt_srch
				Cxx_mfnrsta_svkl_sge
				Cxx_mfnrsta_reserve_3_vb_sc
				Cxx_mfnrsta_thr_cmd_cpt
				Cxx_mfnrsta_oil_cc
				Cxx_mfnrsta_rmc_clockpp
				Cxx_mfnrsta_pmh_cc
				Cxx_mfnrsta_pdl_sens2_vb_sc
				Cxx_mfnrsta_pdl_sens2_oc
				Cxx_mfnrsta_pdl_sens1_vb_sc
				Cxx_mfnrsta_pdl_sens1_oc
				Cxx_mfnrsta_pow_lbdw
				Cxx_mfnrsta_oil_co
				Cxx_mfnrsta_pow_lbup
				Cxx_mfnrsta_obd_sa
				Cxx_mfnrsta_obd_lamb
				Cxx_mfnrsta_obd_cata
				Cxx_mfnrsta_mvac_sys
				Cxx_mfnrsta_mvac_pump_vb_sc
				Cxx_mfnrsta_mvac_pump_scg
				Cxx_mfnrsta_mvac_pump_oc
				Cxx_mfnrsta_pdl_sens_chr
				Cxx_mfnrsta_pws_thr_pdl1
				Cxx_pfdec_mdf1_oc
				Cxx_mfnrsta_reserve_3_scg
				Icd_boost_delay
				Icd_boost_load_thresh_low
				Cxx_mfnrsta_rams_tq_req
				Cxx_mfnrsta_rams_tq_ctl
				Cxx_mfnrsta_pmh_co
				Cxx_mfnrsta_rams_map_tq
				Cxx_mfnrsta_rmc_algopp
				Cxx_mfnrsta_pws_pdl2
				Cxx_mfnrsta_pws_2
				Cxx_mfnrsta_pws_1
				Cxx_mfnrsta_ptc_rov_vb_sc
				Cxx_mfnrsta_ptc_rov_scg
				Cxx_mfnrsta_ptc_rov_oc
				Cxx_mfnrsta_ptc
				Cxx_mfnrsta_rams_pdl
				Cxx_pfinc_mis_polu_1_lpg
				Cxx_pfinc_mis_polu_lpg
				Cxx_pfinc_mis_polu_gas
				Cxx_pfinc_mis_polu_4_lpg
				Cxx_pfinc_mis_polu_4
				Cxx_pfinc_mis_polu_3_lpg
				Cxx_pfinc_mis_polu_3
				Cxx_pfinc_sa_ev_vb_sc
				Cxx_pfinc_mis_polu_2
				Cxx_pfinc_mvac_pump_vb_sc
				Cxx_pfinc_mis_polu_1
				Cxx_pfinc_mis_polu
				Cxx_pfinc_mis_lih
				Cxx_pfinc_mis_fast
				Cxx_pfinc_mis_cata_lpg
				Cxx_pfinc_mis_cata_gas
				Cxx_pfinc_mis_polu_2_lpg
				Cxx_pfinc_ptc
				Cxx_pfinc_knk
				Cxx_pfinc_sa_ev_oc
				Cxx_pfinc_reserve_3_vb_sc
				Cxx_pfinc_reserve_3_scg
				Cxx_pfinc_reserve_3_oc
				Cxx_pfinc_ptc_rov_vb_sc
				Cxx_pfinc_mvac_pump_oc
				Cxx_pfinc_ptc_rov_oc
				Cxx_pfinc_mvac_pump_scg
				Cxx_pfinc_pow_lbup
				Cxx_pfinc_pow_lbdw
				Cxx_pfinc_obd_sa
				Cxx_pfinc_obd_lamb
				Cxx_pfinc_obd_cata
				Cxx_pfinc_mvac_sys
				Cxx_pfinc_mis_cata_3_lpg
				Cxx_pfinc_ptc_rov_scg
				Cxx_pfinc_lbup_hot_oc
				Cxx_pfinc_mis_cata_4_lpg
				Cxx_pfinc_lpg_rcpt
				Cxx_pfinc_lbup_vb_sc
				Cxx_pfinc_lbup_scg
				Cxx_pfinc_lbup_pump_crt
				Cxx_pfinc_lbup_oc
				Cxx_pfinc_map_chr
				Cxx_pfinc_lbup_hot_scg
				Cxx_pfinc_mastervac_cc
				Cxx_pfinc_lbdw_vb_sc
				Cxx_pfinc_lbdw_scg
				Cxx_pfinc_lbdw_pump_crt
				Cxx_pfinc_lbdw_oc
				Cxx_pfinc_lbdw_hot_vb_sc
				Cxx_pfinc_lbdw_hot_scg
				Cxx_pfdec_mastervac_cc
				Cxx_pfinc_lbup_hot_vb_sc
				Cxx_pfinc_min_gas_lvl
				Cxx_pfinc_sa_oc
				Cxx_pfinc_mis_cata_3
				Cxx_pfinc_mis_cata_2_lpg
				Cxx_pfinc_mis_cata_2
				Cxx_pfinc_mis_cata_1_lpg
				Cxx_pfinc_mis_cata_1
				Cxx_pfinc_map
				Cxx_pfinc_min_lpg_lvl
				Cxx_pfinc_mis_cata_4
				Cxx_pfinc_mdf2_vb_sc
				Cxx_pfinc_mdf2_scg
				Cxx_pfinc_mdf2_oc
				Cxx_pfinc_mdf1_vb_sc
				Cxx_pfinc_mdf1_scg
				Cxx_pfinc_mdf1_oc
				Cxx_pfinc_mastervac_oc
				Cxx_pfinc_mis_cata
				Cxx_rel_thd_thr_prs_h_err
				Cxx_stop_eng_dly
				Cxx_stal_det_thd
				Cxx_stal_det_swlk_dly
				Cxx_stab_spg_dif_thd
				Cxx_sta_gas_pump_n_thd
				Cxx_spg_fail_ctr
				Cxx_pfinc_sa_ev_scg
				Cxx_set_stal_dly
				Cxx_supl_nr3
				Cxx_rams_pdl_max_psn_thd
				Cxx_pwl_dly
				Cxx_ptc_mem_inc
				Cxx_ptc_mem_dly
				Cxx_ptc_lih_pow
				Cxx_trs_thd
				Cxx_toil_tco_cnt
				Cxx_thd_syn_fail_per
				Cxx_thr_psn_fil_fac
				Cxx_thpl_vb_aftr_sta_dly
				Cxx_thpl_pos_el_csm_thd
				Cxx_thpl_pos_el_csm_fac
				Cxx_thpl_neg_el_csm_thd
				Cxx_thpl_neg_el_csm_fac
				Cxx_supl_nr1
				Cxx_thd_vb_fail
				Cxx_supl_nr2
				Cxx_thd_n_diag
				Cxx_tco_mon_dly
				Cxx_tco_mdl_max
				Cxx_tco_cor_vld_alt_typ
				Cxx_tco_chr_fil_dly
				Cxx_sys_c_nr
				Cxx_prog_nr2
				Cxx_thpl_fil_vb_fac
				Cxx_pfinc_thpl_scg
				Cxx_trs_thd_lpg
				Cxx_pfinc_vs_mux
				Cxx_pfinc_vs_eal
				Cxx_pfinc_vb_high
				Cxx_pfinc_tlz_ad_b
				Cxx_pfinc_tia_low
				Cxx_pfinc_vta_intake_pmh
				Cxx_pfinc_thpl_vb_sc
				Cxx_pfinc_vta_intake_shift
				Cxx_pfinc_thpl_oc
				Cxx_pfinc_tco_chr
				Cxx_pfinc_tco_acq
				Cxx_pfinc_swlk_mem
				Cxx_pfinc_svkl_chk_springs
				Cxx_pfinc_sa_vb_sc
				Cxx_pfinc_sa_scg
				Cxx_pfinc_tia_high
				Cxx_pfinc_wpmp_oc
				Cxx_pfinc_ip_inj_cnt
				Cxx_prog_nr1
				Cxx_phs_mem_toth_nr
				Cxx_vb_dft_val
				Cxx_vers_nr1
				Cxx_vers_nr2
				Cxx_pfinc_vs_parasite
				Cxx_pfinc_wpmp_scg
				Cxx_ptc_lbup_conf
				Cxx_pfinc_wat_temp_low
				Cxx_pfinc_wat_temp_high
				Cxx_pfinc_vvtc_toth_3
				Cxx_pfinc_vvt_int_old_off
				Cxx_pfinc_vvt_int_ev_vb_sc
				Cxx_pfinc_vvt_int_ev_scg
				Cxx_pfinc_vvt_int_ev_oc
				Cxx_pfinc_wpmp_vb_sc
				Cxx_pfdec_ptc_rov_scg
				Cxx_pfdec_sa_oc
				Cxx_pfdec_sa_ev_vb_sc
				Cxx_pfdec_sa_ev_scg
				Cxx_pfdec_sa_ev_oc
				Cxx_pfdec_reserve_3_vb_sc
				Cxx_pfdec_reserve_3_scg
				Cxx_pfdec_vvt_int_ev_oc
				Cxx_pfdec_ptc_rov_vb_sc
				Cxx_pfdec_svkl_chk_springs
				Cxx_pfdec_ptc_rov_oc
				Cxx_pfdec_ptc
				Cxx_pfdec_pow_lbup
				Cxx_pfdec_pow_lbdw
				Cxx_pfdec_obd_sa
				Cxx_pfdec_obd_lamb
				Cxx_pfdec_reserve_3_oc
				Cxx_pfdec_tia_high
				Cxx_pfinc_lbdw_hot_oc
				Cxx_pfdec_vta_intake_pmh
				Cxx_pfdec_vs_parasite
				Cxx_pfdec_vs_mux
				Cxx_pfdec_vs_eal
				Cxx_pfdec_vb_high
				Cxx_pfdec_sa_scg
				Cxx_pfdec_tia_low
				Cxx_pfdec_sa_vb_sc
				Cxx_pfdec_thpl_vb_sc
				Cxx_pfdec_thpl_scg
				Cxx_pfdec_thpl_oc
				Cxx_pfdec_tco_chr
				Cxx_pfdec_tco_acq
				Cxx_pfdec_swlk_mem
				Cxx_pfdec_mvac_pump_vb_sc
				Cxx_pfdec_tlz_ad_b
				Cxx_pfdec_mis_cata
				Cxx_pfdec_obd_cata
				Cxx_pfdec_mis_cata_4
				Cxx_pfdec_mis_cata_3_lpg
				Cxx_pfdec_mis_cata_3
				Cxx_pfdec_mis_cata_2_lpg
				Cxx_pfdec_mis_cata_2
				Cxx_pfdec_mis_cata_gas
				Cxx_pfdec_mis_cata_1
				Cxx_pfdec_mis_cata_lpg
				Cxx_pfdec_min_lpg_lvl
				Cxx_pfdec_min_gas_lvl
				Cxx_pfdec_mdf2_vb_sc
				Cxx_pfdec_mdf2_scg
				Cxx_pfdec_mdf2_oc
				Cxx_pfdec_mdf1_vb_sc
				Cxx_pfdec_mdf1_scg
				Cxx_pfdec_mis_cata_1_lpg
				Cxx_pfdec_mis_polu_3
				Cxx_pfdec_vvt_int_ev_scg
				Cxx_pfdec_mvac_pump_scg
				Cxx_pfdec_mvac_pump_oc
				Cxx_pfdec_mis_polu_lpg
				Cxx_pfdec_mis_polu_gas
				Cxx_pfdec_mis_polu_4_lpg
				Cxx_pfdec_mis_cata_4_lpg
				Cxx_pfdec_mis_polu_3_lpg
				Cxx_pfdec_mvac_sys
				Cxx_pfdec_mis_polu_2_lpg
				Cxx_pfdec_mis_polu_2
				Cxx_pfdec_mis_polu_1_lpg
				Cxx_pfdec_mis_polu_1
				Cxx_pfdec_mis_polu
				Cxx_pfdec_mis_lih
				Cxx_pfdec_mis_fast
				Cxx_pfdec_mis_polu_4
				Cxx_pfinc_fsys
				Cxx_pfinc_igc_2_oc
				Cxx_pfinc_igc_1_vb_sc
				Cxx_pfinc_igc_1_oc
				Cxx_pfinc_igc
				Cxx_pfinc_gas_pump_vb_sc
				Cxx_pfinc_gas_pump_scg
				Cxx_pfdec_vta_intake_shift
				Cxx_pfinc_fsys_lpg
				Cxx_pfinc_igc_3_vb_sc
				Cxx_vs_fail_dsb
				Cxx_pfinc_eng_whl
				Cxx_pfinc_eng_temp_vb_sc
				Cxx_pfinc_eng_temp_scg
				Cxx_vs_sum_cor_fac
				Cxx_vs_t_sens_fail_det
				Cxx_pfinc_gas_pump_oc
				Cxx_pfinc_inj2_oc
				Cxx_pfinc_inj4_vb_sc
				Cxx_pfinc_inj4_scg
				Cxx_pfinc_inj4_oc
				Cxx_pfinc_inj3_vb_sc
				Cxx_pfinc_inj3_scg
				Cxx_pfinc_inj3_oc
				Cxx_pfinc_igc_2_vb_sc
				Cxx_pfinc_inj2_scg
				Cxx_pfinc_igc_3_oc
				Cxx_pfinc_inj1_vb_sc
				Cxx_pfinc_inj1_scg
				Cxx_pfinc_inj1_oc
				Cxx_pfinc_inj_ecu
				Cxx_pfinc_igc_4_vb_sc
				Cxx_pfinc_igc_4_oc
				Cxx_pfinc_eng_temp_oc
				Cxx_pfinc_inj2_vb_sc
				Cxx_pfdec_wpmp_vb_sc
				Cxx_vs_thd_sens_fail_det
				Cxx_pfinc_agb_conv_stt
				Cxx_pfinc_actr_rly
				Cxx_pfinc_acr_vb_sc
				Cxx_pfinc_acr_scg
				Cxx_pfinc_acr_oc
				Cxx_pfinc_agb_rcpt
				Cxx_pfinc_ac_prs
				Cxx_pfinc_agb_tq_nok
				Cxx_pfdec_wpmp_scg
				Cxx_pfdec_wpmp_oc
				Cxx_pfdec_wat_temp_low
				Cxx_pfdec_wat_temp_high
				Cxx_pfdec_vvtc_toth_3
				Cxx_pfdec_vvt_int_old_off
				Cxx_pfdec_vvt_int_ev_vb_sc
				Cxx_pfinc_ac_rcpt
				Cxx_pfinc_cp_oc
				Icd_boost_load_thresh_high
				Cxx_vvt_cmd_min_vb
				Cxx_vvt_conf
				Cxx_pfinc_el_wind_rcpt
				Cxx_pfinc_crk_nr
				Cxx_pfinc_crk
				Cxx_pfinc_agb_gear
				Cxx_pfinc_cp_scg
				Cxx_vs_thd_vs_sens_vld
				Cxx_pfinc_clu
				Cxx_vvtc_in_sp_fil_fac
				Cxx_pfinc_checksum
				Cxx_pfinc_alt_mux
				Cxx_pfinc_alt_load_in
				Cxx_pfinc_alt_ecu
				Cxx_pfinc_air
				Cxx_pfinc_cp_vb_sc
				Cxx_cp_flr_min_1
				Cxx_kd_rel_pdl_hys
				Cxx_h_thd_dif_prs_dsb_sp
				Cxx_h_thd_n_vs_test
				Cxx_h_thd_prs_h_fail
				Cxx_cl_off_n_thd
				Cxx_clc_ct_pdl_psn_hys
				Cxx_clc_ct_pdl_psn_thd
				Cxx_clc_pdl_max_psn_thd
				Cxx_ac_acel_is_h_prs_thd
				Cxx_h_prs_ac_dsb_prs_thd
				Cxx_clu_fail_vs_thd
				Cxx_h_prs_ac_dsb_prs_hys
				Cxx_h_vvtc_fil_fac
				Cxx_cp_flr_min_2
				Cxx_hw_nr1
				Cxx_hw_nr2
				Cxx_hw_nr3
				Cxx_hw_nr4
				Cxx_hw_nr5
				Cxx_igk_stal_eng_n_thd
				Cxx_lbup_dft_pwm
				Cxx_h_thd_prs_sp_fail
				Cxx_cert_nr3
				Cxx_gear_val_fil_fac2
				Cxx_gear_val_fil_fac3
				Cxx_gear_val_mux_fac
				Cxx_h_alt_crt_nok
				Cxx_h_alt_ind
				Cxx_h_alt_r_mv
				Cxx_h_alt_temp_fac
				Cxx_h_alt_temp_max_grd
				Cxx_cert_nr2
				Cxx_ac_acel_is_l_prs_thd
				Cxx_h_alt_temp_mv
				Cxx_kd_thr_hys
				Cxx_h_alt_temp_ref
				Cxx_h_alt_v_ref
				Cxx_h_alt_v_temp_fac
				Cxx_cert_nr4
				Cxx_h_alt_vb_ofs
				Cxx_h_dif_prs_dsb_sp
				Cxx_h_pdl_psn_ofs
				Cxx_cert_nr5
				Cxx_h_prs_ac_dsb_dly
				Cxx_h_alt_temp_min_v
				Cxx_lbdw_osp_oc_det_l_v
				Cxx_ip_abst_nr_fail
				Cxx_lbdw_hot_cmd_dly1
				Cxx_lbdw_hot_cmd_dly2
				Cxx_lbdw_hot_pwm_dly_inc
				Cxx_lbdw_hot_pwm_per1
				Cxx_lbdw_hot_pwm_per2
				Cxx_lbdw_hot_pwm1_dly1
				Cxx_lbdw_hot_pwm1_dly2
				Cxx_lbdw_no_oc_det_ctr
				Cxx_cp_frq_2
				Cxx_lbdw_osp_oc_det_h_v
				Cxx_l_thd_prs_l_fail
				Cxx_lbdw_osp_sc_vb_v
				Cxx_lbdw_osp_scg_v
				Cxx_cp_pwm_cor_max
				Cxx_lbdw_pump_crt_t
				Cxx_lbdw_pump_crt_v_thd
				Cxx_lbdw_sc_vb_v
				Cxx_lbdw_scg_t
				Cxx_lbdw_scg_v
				Cxx_lbup_cold_sta_rat
				Cxx_lbdw_oc_h_v
				Cxx_l_alt_v_temp_fac
				Cxx_knk_fail_nr
				Cxx_knk_fil_fac
				Cxx_l_alt_crt_nok
				Cxx_l_alt_ind
				Cxx_l_alt_r_mv
				Cxx_l_alt_temp_fac
				Cxx_l_alt_temp_max_grd
				Cxx_l_alt_temp_min_v
				Cxx_l_alt_temp_mv
				Cxx_l_vvtc_fil_fac
				Cxx_l_alt_v_ref
				Cxx_gear_val_fac
				Cxx_l_alt_vb_ofs
				Cxx_l_pdl_psn_ofs
				Cxx_l_prs_ac_dsb_prs_hys
				Cxx_l_prs_ac_dsb_prs_thd
				Tpac_thrusts_air_temp_mini_
				Tpac_thrusts_air_temp_maxi_
				Tpac_thrust_search_cleoff_delay
				Cxx_l_thd_dif_prs_dsb_sp
				Ctp_tco_dif_max
				Cxx_l_alt_temp_ref
				Cxx_ac_pow_min
				Cxx_cert_nr1
				Ctp_thpl_el_csm_vb
				Cxx_acc_neut
				Cxx_acc_bk
				Cxx_ac_prs_v_min
				Cxx_ac_prs_v_max
				Cxx_ac_prs_ofs
				Cxx_ac_prs_fac
				Cxx_ac_pow_prs_n_fac
				Cxx_acel_pdl_kd_out_thd
				Cxx_ac_pow_n_fac
				Cxx_acr_eng_fac
				Cxx_abs_abst_nr_fail
				Cxx_ac_pow_max
				Cxx_ac_mdf_vs_thd4
				Cxx_ac_mdf_vs_thd3
				Cxx_ac_mdf_vs_thd2
				Cxx_ac_mdf_vs_thd1
				Cxx_ac_max_mdf_dly
				Cxx_alt_temp_tco_ofs
				Ctp_n_map_fil_fac
				Cxx_ac_pow_prs_fac
				Cxx_alt_crt_h_n
				Ctp_tco_alt_cor
				Ctd_slop_psi_fac
				Ctd_ofs_psi_fac
				Cxx_alt_efy
				Cxx_alt_load_nok
				Cxx_alt_pwm_edg_max_dly
				Ctd_t_rat_lbup_rest
				Ctd_t_rat_lbup_sta
				Ctp_tco_mdl_tdc_nr
				Cxx_acel_pdl_kd_in_thd
				Cxx_alt_crt_l_n
				Cxx_alti_map_fil_fac
				Cxx_alt_crt_fmt_fac
				Cxx_alt_crt_esti_dly
				Ctp_is_d_clc_aj_fac
				Cxx_agb_conv_trs_dly
				Cxx_alt_pwm_fil_fac
				Cxx_alt_rat_fail_dly
				Ctp_max_dif_clc_vs
				Cxx_agb_abst_nr_fail
				Cxx_aftr_inj_n_thd
				Cxx_alt_crt_ofs
				Cxx_fil_fac_vb
				Cxx_ecu_nr1
				Cxx_ecu_nr2
				Cxx_ecu_nr3
				Cxx_ecu_nr4
				Cxx_ecu_nr5
				Cxx_eng_alt_fac
				Cxx_fac_n_grd
				Cxx_fac_n_mmv
				Cxx_fail_ctr_vs_thd
				Cxx_alt_v_fil_fac
				Cxx_fil_fac_thr_adj
				Cxx_c_id9
				Cxx_fil_fac_vvtc_dif
				Cxx_fil_map_thr_adj
				Cxx_fil_mdl_map_thr_adj
				Cxx_fil_n_thr_adj
				Cxx_c_nr2
				Vta_intake_min_reg_inh
				Cxx_gas_pump_sta_dly
				Cxx_gear_ctr
				Cxx_cp_frq_1
				Cxx_fil_fac_cor_thr_adj
				Cxx_c_id14
				Cxx_gear_val_fil_fac1
				Cxx_alti_prs_dft_val
				Cxx_amp_prs_dif_thd
				Cxx_aut_eng_n_thd
				Cxx_c_id1
				Cxx_c_id10
				Cxx_c_id11
				Cxx_mfnrsta_inj1_oc
				Cxx_c_id12
				Cxx_dyn_iga_dsb_n_thd
				Cxx_c_id13
				Cxx_c_nr1
				Cxx_c_id15
				Cxx_c_id16
				Cxx_c_id2
				Cxx_c_id3
				Cxx_c_id4
				Cxx_c_id5
				Cxx_c_id6
				Cxx_c_id7
				Cxx_c_id8
				Ctp_pred_map_prs_rat
				Cxx_mfnrsta_reserve_3_oc
				Cxx_cylr_cold_is_stab_t
				Cxx_mdf_ac_prs_hys
				Cxx_mdf_ac_prs_thd1
				Cxx_mdf_ac_prs_thd2
				Cxx_mdf_ac_prs_thd3
				Cxx_cylr_is_neg_clu_stal
				Cxx_mfnrsta_ac_prs
				Cxx_mfnrsta_ac_rcpt
				Cxx_mfnrsta_air
				Cxx_mfnrsta_acr_scg
				Cxx_cylr_max_n_lpg
				Cxx_mfnrsta_acr_vb_sc
				Cxx_mfnrsta_actr_rly
				Cxx_ctr_frm_csm_gas
				Cxx_mfnrsta_agb_conv_stt
				Cxx_mfnrsta_agb_gear
				Cxx_mfnrsta_agb_rcpt
				Cxx_dif_mes_esti_prs_err
				Cxx_mfnrsta_acr_oc
				Cxx_l_thd_n_vs_test
				Cxx_diag_nr
				Cxx_dft_lght_on_inc
				Cxx_dft_lght_on_dec
				Cxx_ct_pdl_psn_thd
				Cxx_lpg_abst_nr_fail
				Cxx_dft_lght_km_rst_wup
				Cxx_cylr_trz_stab_dif
				Cxx_max_val_dif_prs_acq
				Cxx_max_alt_pwm
				Cxx_cylr_max_n
				Cxx_max_amp
				Cxx_max_dif_mfld_mv_prs
				Cxx_cylr_stab_t
				Cxx_max_h_alt_pwm_per
				Cxx_max_l_alt_pwm_per
				Cxx_max_mes_prs_fail_sens
				Cxx_max_t_toth
				Cxx_mfnrsta_alt_ecu
				Cxx_lbup_hot_cmd_dly1
				Cxx_mfnrsta_igc_1_vb_sc
				Cxx_mfnrsta_eng_temp_scg
				Cxx_mfnrsta_eng_temp_vb_sc
				Cxx_mfnrsta_eng_whl
				Cxx_mfnrsta_fsys
				Cxx_mfnrsta_fsys_lpg
				Cxx_mfnrsta_gas_pump_oc
				Cxx_mfnrsta_gas_pump_scg
				Cxx_mfnrsta_agb_tq_nok
				Cxx_mfnrsta_igc_1_oc
				Cxx_mfnrsta_el_wind_rcpt
				Cxx_mfnrsta_igc_2_oc
				Cxx_mfnrsta_igc_2_vb_sc
				Cxx_mfnrsta_igc_3_oc
				Cxx_mfnrsta_igc_3_vb_sc
				Cxx_mfnrsta_igc_4_oc
				Cxx_mfnrsta_igc_4_vb_sc
				Cxx_mfnrsta_inj_ecu
				Cxx_mfnrsta_gas_pump_vb_sc
				Cxx_mfnrsta_crk
				Cxx_mfnrsta_alt_load_in
				Cxx_mfnrsta_alt_mux
				Cxx_ac_abst_nr_fail
				Cxx_mfnrsta_checksum
				Cxx_mfnrsta_clu
				Temps_apres_test_actionneur_
				Cxx_mfnrsta_cp_oc
				Table_nb_cycle_test_actionneur_
				Cxx_mfnrsta_cp_vb_sc
				Cxx_mfnrsta_eng_temp_oc
				Cxx_mfnrsta_crk_nr
				Cxx_mfnrsta_cru_brk_cnt1
				Cxx_mfnrsta_cru_brk_cnt2
				Cxx_ctr_frm_csm_lpg
				Table_temps_test_actionneur
				Cxx_mfnrsta_cru_on_off_chr
				Cxx_mfnrsta_cru_whl_cmd
				Cxx_map_thd_vs_test
				Cxx_mfnrsta_cp_scg
				Cxx_csm_fil_fac
				Cxx_lbup_osp_sc_vb_det_v
				Cxx_lbup_osp_scg_det_v
				Cxx_lbup_pump_crt_t
				Cxx_lbup_pump_crt_v_thd
				Cxx_lbup_sc_vb_det_v
				Cxx_lbup_hot_pwm_per2
				Cxx_lbup_scg_t
				Cxx_lbup_v_thd
				Cxx_lbup_hot_pwm_dly_inc
				Cxx_lbup_osp_oc_det_l_v
				Cxx_crk1_bas_toth_nr
				Cxx_lbup_rms_v
				Cxx_lbup_hot_pwm_per1
				Cxx_lbup_max_vb_thd
				Cxx_lbup_hot_pwm1_dly2
				Cxx_ct_pdl_ofs
				Cxx_ct_pdl_mem_ofs
				Cxx_ct_dsb_pdl_psn_thd
				Cxx_ct_dsb_pdl_psn_dif
				Cxx_ct_pdl_psn_hys
				Cxx_lbup_hot_pwm1_dly1
				Cxx_cp_pwm_min_1
				Cxx_cp_pwm_min_2
				Cxx_lbup_oc_det_h_v
				Cxx_lbup_oc_t
				Cxx_lbup_no_oc_det_ctr
				Cxx_lbup_min_vb_thd
				Cxx_lbup_oc_det_l_v
				Cxx_crk_toth_nr
				Cxx_lbup_hot_cmd_dly2
				Cxx_lbup_scg_det_v
				Cxx_lbup_osp_oc_det_h_v
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION Structure_Couple_MAP
			""
			/begin DEF_CHARACTERISTIC
				Ctp_n_pred_val_fil_fac
				Ctp_tia_max_tqi_cor
				Ctp_thr_ar_pos
				Ctp_spg_prs_rat_sp
				Ctp_spg_prs_dif_thd_trs
				Ctp_spg_max_grd
				Ctp_spg_cl_spg_prs_thd
				Ctp_rich_otl_iga_mv_tqi
				Ctp_pwm_cp_efv_ar2
				Ctp_pwm_cp_efv_ar1
				Ctp_prs_tq_trs_fac
				Ctp_prs_tmp_flr_val
				Ctp_iga_efv
				Cxx_dft_cp_load
				Ctx_fac_cor_thr_ar_min
				Ctp_n_mfld_inv_fil_fac
				Ctp_n_h_thr_tq
				Cbx_knk_out_tq_cor
				Ctp_min_map
				Ctp_max_pump_maf
				Ctp_max_map_sp
				Cbx_inv_dyn_cor_vvt_dsb
				Cbx_iga_ofs_dsb
				Ctb_spg_ol_map_sp
				Ctp_knk_rel_tq_cor_max
				Cbx_prs_sp_dsb
				Ctp_prs_rat_fil_fac
				Cxx_knk_tq_cor_dec_fac
				Cbx_mdl_thr_conf
				Cxx_ar_flr_tmp_dsb
				Cxx_alti_upd_t_rst
				Cxx_bch_mod_nr
				Cxx_bch_mod_tq
				Cxx_l_min_iga_inc
				Cxx_l_min_iga_ctr_thd
				Cxx_l_min_iga_ctr_inc
				Cxx_l_min_iga_ctr_dec
				Cxx_knk_tq_cor_inc_ofs
				Cxx_knk_tq_cor_inc_fac
				Ctp_tq_rat_fil_fac
				Cxx_knk_tq_cor_dec_ofs
				Ctx_fac_cor_thr_ar_max
				Cxx_knk_tq_cor_dec_dly
				Cxx_knk_slow_iga_efy_hys
				Cxx_knk_slow_iga_efy
				Cxx_knk_slow_fil_mv_iga
				Cxx_knk_slow_fil_mv_hys
				Cxx_knk_iga_cor_fil_fac
				Cxx_air_tq_t_dly
				Cxx_air_tq_angl_dly
				Cxx_adj_fac_thr_adj
				Cxx_ad_tq_fil_fac
				Cxx_l_tq_req
				Ctp_inv_prs_rat
				Cxx_knk_tq_cor_inc_dly
				Cbx_ad_tq_agb_conf
				Cbx_iga_bch_mod
				Cxx_fac_cor_thr_adj
				Cmp_iga_tq_min
				Cbx_actr_spg_dsb
				Cmp_iga_tco_cor
				Cmp_ex_prs_dif_fac
				Cmp_eal_n_vvtc_otl_iga
				Cmp_eal_n_vvtc_on_otl_iga
				Cmp_eal_n_vvtc_off_otl_iga
				Cmp_eal_n_min_iga_cor
				Cxx_fl_max_thr_ar
				Cmp_alti_n_max_tqi_cor
				Cmp_min_iga
				Cxx_flr_clc_dsb_prs_thd
				Cmp_n_eal_otl_tqi_fac
				Cxx_h_tq_req
				Cxx_iga_bch_mod
				Cxx_iga_ofs_cyl
				Cxx_iga_ofs_cyl1
				Cxx_iga_ofs_cyl2
				Cxx_iga_ofs_cyl3
				Cxx_iga_ofs_cyl4
				Cbx_tot_dyn_iga_cor_dsb
				Cbx_thr_ar_l_lim_dsb
				Cbx_thr_ar_h_lim_dsb
				Cbx_thr_ar_cor_dsb
				Cbx_spg_tq_off_mod
				Cxx_fl_tq_ofs
				Ctb_eal2
				Ctp_bch_mod_cyc_nr
				Ctb_thr_psn
				Cbx_mdl_cp_load_dsb
				Ctb_spg_tq_rat
				Ctp_bch_mod_dyn_ofs
				Ctb_spg_ar_maf_fac
				Ctb_rich_sp9
				Cxx_eng_air_wht_ref
				Ctp_bch_mod_stat_inc
				Ctp_iga_dif
				Ctp_bch_mod_dyn_inc
				Ctb_eng_alti
				Ctb_pump_maf
				Ctb_eal1
				Cxx_dz_iga_efv
				Ctp_bch_mod_stat_ofs
				Ctp_cp_load_fac_cor
				Cmp_spg_ol_pwm_thr_n
				Cmp_spg_ol_pwm
				Cmp_otl_iga_tco_cor
				Cmp_n_map_bch_appl_iga
				Ctp_eal_fac
				Ctb_prs_rat
				Cxx_spg_i_pwm_min_cor
				Cxx_map_min_thr_adj
				Cxx_map_rat_max_thr_adj
				Cxx_mfld_mdl_fac
				Cxx_mfld_vol_rat
				Cxx_mfld_dly_fac
				Cxx_thd_map_in_thr_adj
				Cxx_tia_min_thr_adj
				Cxx_spg_min_pwm
				Cxx_spg_ol_spg_sp_thd
				Cxx_spg_prop_dz
				Cxx_spg_prop_pwm_fac
				Cxx_spg_pwm_bch_mod_val
				Cxx_spg_pwm_dif_trt_ad
				Cxx_spg_up_ad_dz
				Cxx_spg_max_pwm
				Cxx_tdc_per_fac
				Cxx_spg_max_prs_dif
				Cxx_thd_map_out_thr_adj
				Cxx_thd_n_in_thr_adj
				Cxx_thd_n_out_thr_adj
				Cxx_thpl_pow
				Cxx_thr_mdl_fil_fac
				Cxx_thr_pos_max_thr_adj
				Cxx_thr_pos_min_thr_adj
				Cxx_thr_pos_sc_bch
				Cxx_tia_max_thr_adj
				Cxx_tbn_prs_dif_cut_fac
				Cxx_spg_alti_ofs_fac
				Cxx_spg_i_pwm_fac
				Cxx_spg_ad_alti_thd
				Cxx_spg_ad_down_vb_thd
				Cxx_spg_ad_n_thd
				Cxx_spg_ad_pwm_fac
				Cxx_spg_ad_pwm_max_cor
				Cxx_spg_ad_pwm_min_cor
				Cxx_spg_ad_spg_thd
				Cxx_spg_min_err_drv
				Cxx_spg_ad_up_vb_thd
				Cxx_spg_err_drv_fil_fac
				Cxx_spg_alti_ofs_ofs
				Cxx_spg_alti_ol_pwm_fac
				Cxx_spg_cl_tco_thd
				Cxx_spg_down_ad_dz
				Cxx_spg_err_down_thd_drv
				Cxx_spg_err_up_thd_drv
				Cxx_spg_i_pwm_max_cor
				Cxx_spg_i_pwm_sp
				Cxx_spg_max_err_drv
				Cxx_spg_ad_stab_prs_thd
				Cxx_min_ar_grd_thr_adj
				Cxx_ovt_inc_lim
				Cxx_ovt_gear_thd
				Cxx_n_min_thr_adj
				Cxx_n_max_thr_adj
				Cxx_mux_mfld_inv_fil_fac
				Cxx_min_tqe_fac
				Cxx_min_thr_ar
				Cxx_min_iga_dsb_t
				Cxx_spg_drv_pwm_fac
				Cxx_min_otl_iga_mv_tqi
				Cbx_bch_mod_tq
				Cbx_ctl_mux_dyn_iga_conf
				Cbx_bch_dsb_thr_adj_val
				Cbx_bch_mod_stat_tq
				Cbx_driv_tq_req_dsb
				Cbx_agb_dyn_iga_conf
				Cbx_agb_min_tqe_dsb
				Cbx_ena_appl_thr_adj
				Cbx_bch_rst_thr_adj
				Cbx_cart_iga_bch_mod
				Cbx_bch_cp_thr_adj
				Cbx_bch_mod_dyn_tq
				Cbx_eng_tq_loss_ad_dsb
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION R�glage_de_Base_MAP
			""
			/begin DEF_CHARACTERISTIC
				Ctp_tco_toil_ofs
				Ctp_tia_inj_cor
				Ctp_polu_inj_clos_angl
				Ctp_perf_inj_clos_angl
				Ctp_tco_lbup_hot_dly
				Ctp_n_tia_fac
				Ctp_prs_tia_fac
				Cxx_cyl_nr
				Ctp_toil_fil
				Cmp_n_eal_vvtc_off_iga
				Cxx_alti_inj_cor
				Cmp_n_map_ol_rich_sp
				Cmp_n_map_fl_rich_sp
				Cmp_n_map_fill_efv_vvt
				Ctb_tco_dif
				Cmp_n_map_fill_efv
				Cxx_lbup_hot_cmd_vs_hys
				Cmp_n_eal_vvtc_on_iga
				Cmp_n_toil
				Cmp_n_eal_vvtc_iga
				Cmp_n_eal_tia_fil_fac
				Cxx_cold_loop_kd_rich_fac
				Cmp_n_eal_fl_thd
				Cmp_n_eal_fl_rich_sp
				Cxx_fil_inj_clos_dec
				Cxx_fil_inj_clos_inc
				Cxx_lbdw_hot_cmd_map_hys
				Ctb_tia_17
				Ctb_n4
				Ctb_eal3
				Cmp_vvt_fill_efv_cor_fac2
				Cmp_vvt_fill_efv_cor_fac1
				Cmp_tia_iga_cor
				Ctb_map_fl
				Ctb_map_ol
				Cmp_n_prs_fl_thd
				Cxx_fl_n_thd
				Ctb_n6
				Ctb_prs_dif
				Cxx_air_wht_mpl_fac
				Cmp_prs_dif_ti_cor
				Cxx_lbup_hot_cmd_map_hys
				Ctb_n_ol
				Ctp_vb_inj_dly_cor
				Ctp_map_fl_ocl_ofs
				Ctp_map_tia_iga_cor
				Ctp_max_map_inj_cut
				Ctp_n_dly_ofs_dly
				Cxx_dly_ocl_up_n_thd
				Ctp_n_kd_iga_cor
				Cxx_lbdw_hot_dsb_vs
				Ctp_n_kd_rich_fac
				Ctp_n_lbdw_hot_dsb_map
				Ctp_n_lbup_hot_dsb_map
				Ctp_vvtc_angl_iga_fac2
				Ctp_vvtc_angl_iga_fac1
				Ctb_eal_fl
				Cbx_min_ti
				Cxx_dly_ocl_tco_thd
				Cbx_kd_rich_cor_prs_conf
				Cbx_toil_bch_mod
				Cxx_fl_n_thd_hys
				Cxx_lbup_hot_dsb_vs
				Cxx_inj_clos_angl_bch
				Cxx_inj_csm
				Cxx_inj_dly
				Ctp_eal_fl_ocl_ofs
				Cxx_lbdw_hot_cmd_vs_hys
				Cxx_dly_ocl_knk_thd
				Cxx_adac_ti_ofs
				Cxx_adac_ti_csm_fac
				Cxx_adac_csm_mux
				Ctp_iga_prs_fl_thd
				Cbx_spg_i_ini_req
				Cbx_tot_dft_ini_req
				Cxx_tco_toil_fil
				Cxx_nr_tdc_inj_cut
				Fftibm
				Cxx_tco_kd_rich_cor_fac
				Cxx_map_slop_inj_cut
				Cxx_perf_inj_tco_thd
				Cxx_prs_thd_inj_cut
				Cxx_min_ti
				Cxx_rich_cor_ena_n_thd
				Cxx_min_gas_dly
				Cxx_lbup_tco_rest_thd
				Cxx_tia_iga_cor_prs
				Cxx_no_min_gas_dly
				Cxx_tco_toil_thd
				Cxx_tia_fac
				Cxx_stop_toil_fil
				Cxx_vvtc_min_iga_cor
				Cxx_toil_bch_mod
				Cxx_vvt_fill_efv_cam_ofs
				Cxx_vvtc_h_trt
				Cbx_bch_inj1_cut_req
				Cbx_bch_inj2_cut_req
				Cbx_bch_inj4_cut_req
				Cbx_fail_dft_ini_req
				Cbx_bch_inj3_cut_req
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION Anti-K_MAP
			""
			/begin DEF_CHARACTERISTIC
				Cxx_knk_fast_cor_dec_ctr
				Ctp_n_knk_fil_fac_2_3
				Ctp_n_knk_fil_fac_1_4
				Ctp_n_knk_fast_inc_iga
				Ctp_n_knk_fac_cyl4
				Ctp_n_knk_fac_cyl3
				Ctp_n_knk_fac_cyl2
				Ctp_n_knk_fac_cyl1
				Ctp_n_knk_fac
				Ctp_n_knk_acq_int
				Ctp_n_knk_acq_frq
				Cbx_knk_ad_dsb
				Cxx_decl_knk_fil_fac
				Ctp_n_knk_ofs_cyl2
				Cxx_knk_fast_cor_iga_max
				Cxx_knk_fast_cor_iga_thd
				Cxx_knk_fil_inc
				Cmp_n_prs_knk_cyl14_fac
				Cxx_knk_fmt_fil_fac
				Cxx_knk_fmt_fil_max
				Cmp_n_prs_knk_cyl23_fac
				Cxx_knk_fmt_fil_min
				Cxx_knk_slow_cor_iga_inc
				Cxx_knk_slow_cor_dec_ctr
				Cxx_knk_noi_lvl
				Ctp_n_diag_knk_acq
				Cbx_knk_dft_ini_req
				Cxx_diag_knk_win_frst
				Cxx_knk_det_n_thd
				Cxx_diag_knk_tco
				Cxx_diag_knk_n
				Cxx_knk_det_prs_thd
				Cxx_knk_slow_cor_prs_dif
				Cxx_diag_knk_bpf_frq
				Cxx_knk_zon_tco_thd
				Cxx_diag_knk_acq_int
				Cxx_knk_2cyl_slow_dif_max
				Cxx_knk_1cyl_slow_cor_max
				Ctp_n_knk_ofs
				Cxx_diag_knk_acq_fac
				Ctp_n_knk_ofs_cyl1
				Cxx_knk_iga_cor
				Cxx_knk_det_tco_thd
				Cxx_diag_knk_win_long
				Cxx_knk_slow_cor_iga_max
				Ctp_prs_knk_win_frst
				Ctp_n_knk_zon
				Ctp_n_knk_win_long
				Ctp_n_knk_win_frst
				Ctp_n_knk_ofs_cyl4
				Ctp_n_knk_ofs_cyl3
				Cxx_diag_knk_tdc_nr
				Cxx_diag_knk_acq_frq
				Cxx_inc_knk_fil_fac
				Ctb_n_knk
				Ctd_n_iga_prs_thd
				Ctd_n_iga_pred_prs_thd
				Ctd_n_prs_trs_cor_iga
				Table_dec_clq_num_pression
				Table_deb_clq_num_regime
				Table_facteur_form_clq_num_cyl1
				Table_facteur_form_clq_num_cyl2
				Table_facteur_form_clq_num_cyl3
				Table_facteur_form_clq_num_cyl4
				Cxx_n_iga_tco_thd
				Cxx_prs_pred_prs_dif_thd
				Seuil_max_reg_detect_cliq
				Table_freq_centrale_clq
				Table_long_clq_num_regime
				Seuil_min_reg_detect_cliq
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION VVT_MAP
			""
			/begin DEF_CHARACTERISTIC
				Cxx_hot_vb_thd
				Cmp_n_tq_vvtc_hot_in_angl
				Cxx_inj_vvt_req_on_tdc
				Cxx_cmd_vvt_req_off_tdc
				Cxx_iga_vvt_req_off_tdc
				Cxx_cmd_vvt_req_on_tdc
				Ctp_vvtc_act_temp_h_thd
				Cxx_bch_in_angl
				Cmp_n_prs_vvt
				Cxx_iga_vvt_req_on_tdc
				Cxx_inj_vvt_req_off_tdc
				Ctb_tq
				Ctb_vvt_n
				Ctb_vvt_n1
				Ctb_vvt_n2
				Cxx_vvtc_act_ena_n_thd
				Cxx_vvt_cmd_min_tco
				Cxx_vvt_off_thd
				Cxx_vvt_on_thd
				Cxx_vvt_req_off_tdc
				Cxx_vvtc_act_temp_h_hys
				Cxx_vvtc_act_ena_n_hys
				Cxx_vvtc_dsb_ena_fil_inc
				Cxx_vvt_req_on_tdc
				Cbx_bch_in_angl
				Cbx_bch_tco_toil
				Cbx_bch_tco_toil_2
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION R�glage_de_Base_GPL_MAP
			""
			/begin DEF_CHARACTERISTIC
				Cmp_n_eal_fl_thd_lpg
				Ctb_lpg_typ
				Ctp_n_kd_rich_fac_lpg
				Cmp_n_eal_lpg_cor_iga
				Cxx_adac_csm_mux_lpg
				Cmp_n_map_ol_rich_sp_lpg
				Cxx_adac_ti_ofs_lpg
				Ctp_n_dly_ofs_dly_lpg
				Cmp_n_eal_fl_rich_sp_lpg
				Cmp_n_map_fill_efv_lpg
				Ctp_lpg_typ_adac_fmt_fac
				Cxx_typ_lpg_thd2
				Cxx_typ_lpg_thd1
				Cxx_lpg_flow_fmt_fac
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION SDF_SC_MAP
			""
			/begin DEF_CHARACTERISTIC
				Cxx_acel_esti_tqe_fil_fac
				Ctp_rams_driv_tq_fil_acel
				Cxx_air_pump_pow1
				Ctp_rams_driv_tq_fil_decl
				Ctp_rams_h_vs_pdl_fac
				Cbx_h_thr_conf
				Ctp_rams_n_max_tqi
				Cxx_air_pump_pow2
				Cxx_el_wind_pow
				Ctp_rams_n_ovt_tqi_ofs
				Ctp_rams_n_tqi_dyn_lim
				Ctb_rams_tq_req
				Cxx_ac_load_dft
				Cbx_ac_load_dft_ena
				Cbx_rams_tq_loss_ad_dsb
				Ctp_rams_rvr_pdl_fac
				Cbx_rams_ovt_act
				Cbx_rams_lpg_lpg_mod_ena
				Cmp_rams_frn_tq_loss
				Cmp_rams_lpg_esti_tqe
				Cmp_rams_map_n_esti_tqe
				Cmp_rams_pdl_n_abv_tqe
				Ctp_ptc_pow_cor
				Cmp_rams_pump_tq_loss
				Ctp_rams_l_vs_pdl_fac
				Ctb_ptc_pow
				Ctd_n_ovt_tqi_ofs
				Ctp_frn_tq_loss_tco_fac
				Cxx_decl_esti_tqe_fil_fac
				Ctp_frn_tq_loss
				Ctp_n_tqi_dyn_lim
				Cxx_fl_tq_hys
				Ctd_n_max_tqi_lih
				Ctd_n_max_tqi
				Cxx_rams_pwst_tq_loss
				Cxx_ovt_dly
				Cxx_mdf1_pow
				Cxx_rams_fl_tqr_thd1
				Cxx_rams_fl_tqr_thd2
				Cxx_pwst_tq_loss
				Cxx_rams_tkof_tqe_cor
				Cxx_rams_fmt_pdl_vs_thd
				Cxx_mdf2_pow
				Cxx_rams_max_tq_dec
				Cxx_rams_ovt_dly
				Nxx_rams_pow_tq_trs_ac
				Cxx_rams_tq_dec_mask_t
				Cxx_rams_tkof_n_thd
				Cbx_alt_tq_conf
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION SDF_R�glage_de_Base_MAP
			""
			/begin DEF_CHARACTERISTIC
				Ctb_map
				Ctb_n
				Ctb_n1
				Ctb_n3
				Ctb_spg_n
				Cxx_amp_spg_dif_fac
				Ctb_n2
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION SDF_Sural_MAP
			""
			/begin DEF_CHARACTERISTIC
				Ctp_spg_up_hys
				Cmp_spg_alti_cor
				Ctp_spg_tia_cor
				Cmp_tq_n_spg_fail_thd
				Ctp_spg_l_hys
				Ctb_alti
				Cxx_spg_dly
				Cxx_tq_stab_thd
				Cxx_spg_sys_diag_dly
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION Structure_Couple_GPL_MAP
			""
			/begin DEF_CHARACTERISTIC
				Ctp_rich_lpg_otl_iga_tqi
				Cmp_n_eal_otl_tqi_fac_lpg
				Cmp_iga_tq_min_lpg
				Ctp_iga_efv_lpg
				Cmp_eal_n_min_iga_cor_lpg
				Cmp_eal_n_lpg_cor_otl_iga
				Cmp_iga_tco_cor_lpg
				Cxx_min_otl_iga_tqi_lpg
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION Double_boucle_MAP
			""
			/begin DEF_CHARACTERISTIC
				Cxx_dyn_prs_fil_ofs2
				Cxx_cl2_act_ctr
				Cxx_cl2_asd_map_thd
				Cxx_cl2_n_thd
				Cxx_lbdw_fil_fac
				Cmp_prs_n_lamb_v
				Cxx_cl2_map_thd
				Cxx_fil_ti_ofs2_fac
				Ctp_tco_cl2_ena_ctr
				Cxx_max_n_fil_ofs2
				Cxx_max_prs_fil_ofs2
				Cxx_min_is_ti_ofs2
				Cxx_max_ti_ofs1
				Cxx_max_tco_fil_ofs2
				Cxx_min_n_fil_ofs2
				Cxx_ti_p2_cor_fac
				Cxx_min_tco_fil_ofs2
				Cxx_max_is_ti_ofs2
				Cxx_min_ti_ofs2
				Cxx_min_prs_fil_ofs2
				Cxx_ti_i2_cor_fac
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION Chauffage_sonde_MAP
			""
			/begin DEF_CHARACTERISTIC
				Ctp_tco_lbdw_hot_dly
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION Purge_Canister_MAP
			""
			/begin DEF_CHARACTERISTIC
				Cxx_cp_is_tco_min_thd
				Cxx_cp_max_prs_thd
				Cxx_cp_max_dly
				Cxx_cp_max_ad_dly
				Cxx_cp_max_ad
				Cxx_cp_fac_rel
				Cxx_cp_lamb_fac_mv_thd_2
				Cxx_cp_fac_pwm
				Cxx_cp_fil_cl_ti_fac
				Cxx_cp_grd_fac
				Cxx_cp_is_tia_min_thd
				Cxx_cp_n_frq
				Cxx_cp_rtn_dly_dec
				Cxx_cp_ad_thd
				Cxx_cp_inc_ad
				Cxx_cp_hys_n_frq
				Cxx_cp_ad_tco_min_thd
				Cxx_cp_lamb_fac_mv_thd_1
				Cxx_cp_rel_step_lamb_fac
				Cxx_cp_pwm_step_1
				Cxx_cp_step_lamb_fac
				Cxx_cp_trs_l_thd
				Cxx_cp_pwm_step_3
				Cxx_cp_pwm_step_4
				Cxx_cp_min_ad_dly
				Cxx_cp_trs_h_thd
				Cxx_cp_pwm_sp4
				Cxx_cp_t_on
				Cxx_cp_tia_min_thd
				Cxx_cp_stab_dly
				Cxx_cp_tco_min_thd
				Pgcban
				Ctb_cp_ad_fil
				Cxx_cp_pwm_step_5
				Cmp_prs_n_pwm_cp
				Cxx_cp_min_dly
				Cxx_cp_n_thd
				Cxx_cp_t_off
				Cxx_cp_ol_tco_min_thd
				Cxx_cp_pwm_step_2
				Cxx_cp_pwm_max_2
				Cxx_cp_pwm_sp3
				Cxx_cp_pwm_max_3
				Cxx_cp_pwm_max_4
				Cxx_cp_pwm_sp1
				Cxx_cp_pwm_sp2
				Cxx_cp_pwm_max_1
				Cxx_min_cp_ti
				Pcrcoban
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION Double_boucle_GPL_MAP
			""
			/begin DEF_CHARACTERISTIC
				Ctp_tco_cl2_ena_ctr_lpg
				Cmp_prs_n_lamb_v_lpg
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION R�gulation_Rich_MAP
			""
			/begin DEF_CHARACTERISTIC
				Cbx_mv_ofs_ini_req
				Cxx_is_ti_p_cor_lean1
				Cxx_is_dstb_ti_ofs_cor
				Cxx_is_ti_p_cor_lean2
				Cxx_ct_pdl_tco_thd
				Ctp_prs_l_ti_i_cor
				Ctp_prs_l_ti_i_cor_lean
				Ctp_prs_ti_ofs1
				Cbx_max_ti_b0_ini_req
				Cbx_lsb_ini_req
				Cxx_is_ocl_tco_thd
				Cbx_mv_fac_ini_req
				Cxx_fl_ena_n_thd
				Lmbavaba
				Ctp_tco_cl_off_dly
				Cbx_lsm_dft_ini_req
				Cbx_lsm_ctr_ini_req
				Ctb_tco_cl_off
				Cxx_fl_bfr_cl_ctr
				Ctp_prs_ti_ofs2
				Ctp_n_l_ti_i_cor_lean
				Cxx_l_ti_slop_thd
				Cbx_ad1_zon3_ini_req
				Cbx_ad1_zon4_ini_req
				Cbx_ad1_zon2_ini_req
				Cbx_ad1_zon1_ini_req
				Cbx_ad1_zon0_ini_req
				Ctp_fast_slop_out
				Ctp_fast_slop_in
				Ctp_decl_n_ti_p_cor
				Ctp_cl_lean_stop
				Ctp_cl_lean_sta
				Cxx_h_dly_ocl_tco_thd
				Cxx_dly_ocl_alti_thd
				Ctp_n_l_ti_i_cor
				Cxx_decl_fast_slop
				Cbx_ad_ini_req
				Cxx_dstb_ti_p_cor
				Cxx_dstb_ti_ofs_cor
				Cxx_dly_ocl_l_n_thd
				Ctp_acel_n_ti_p_cor
				Cbx_max_ti_b1_ini_req
				Cbx_ad_dft_ini_req
				Ctp_n_ti_p_cor
				Ctp_n_ti_p_cor_lean1
				Ctp_n_ti_p_cor_lean2
				Cxx_appl_ti_ofs_ctr
				Cxx_decl_fast_slop_lean
				Cxx_bfr_cl_ctr
				Cxx_cl_run_prs_thd
				Lmbavama
				Cxx_is_ti_p_cor
				Cbx_min_ti_b4_ini_req
				Cbx_min_ti_b3_ini_req
				Cbx_min_ti_b2_ini_req
				Cbx_min_ti_b1_ini_req
				Cbx_min_ti_b0_ini_req
				Cxx_lamb_swi_ctr_ini
				Cxx_l_v_lamb_thd
				Cbx_max_ti_b3_ini_req
				Cxx_cl_lean_ctr
				Cbx_max_ti_b2_ini_req
				Cxx_cl_stop_prs_thd
				Cxx_cl_t_fac
				Cxx_fast_slop_l_thd
				Cxx_is_ti_i_cor_lean
				Cxx_is_ti_i_cor
				Cxx_l_ti_slop_thd_lean2
				Cxx_fast_slop_h_thd
				Cxx_acel_fast_slop
				Cxx_acel_fast_slop_lean
				Cxx_l_ti_slop_thd_lean1
				Cxx_fil_cl_ti_fac
				Cbx_max_ti_b4_ini_req
				Cxx_mv_ti_ad_fac_ini
				Cxx_min_cl_ti_fac
				Cxx_min_b4_ini
				Cxx_min_b3_ini
				Cxx_max_is_ocl_t
				Cxx_sta_fl_off_dly
				Cxx_min_b0_ini
				Cxx_up_v_lamb_thd
				Ofsthman
				Ofsthban
				Ofdbmyma
				Ofdbmyba
				Cxx_ti_p_prs_thd
				Cxx_ti_ofs_vs_thd
				Cxx_ti_i_cor_fac
				Cxx_ti_ad1_zon4_ini
				Cxx_ti_ad1_zon3_ini
				Cxx_ti_ad1_zon2_ini
				Cxx_max_b0_ini
				Cxx_ti_ad1_zon0_ini
				Cxx_min_b2_ini
				Cxx_mv_ad_lsm_ctr_ini
				Cxx_mv_ad_dly
				Cxx_slop_fil_map_fac
				Cxx_max_b1_ini
				Cxx_max_b2_ini
				Cxx_min_b1_ini
				Cxx_max_b3_ini
				Cxx_max_b4_ini
				Cxx_max_cl_ti_fac
				Cxx_max_fast_slop_ctr
				Cxx_max_ti_p_cor
				Cxx_ti_ad1_zon1_ini
				Cxx_rich_ol_ti_thd
				Cxx_mv_ti_ad_ofs_ini
				Cxx_rich_cl_tco_thd
				Cxx_rich_cl_alti_fac
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION R�gulation_Rich_GPL_MAP
			""
			/begin DEF_CHARACTERISTIC
				Cxx_bfr_cl_ctr_lpg
				Cxx_dstb_ti_ofs_cor_lpg
				Ctp_prs_ti_ofs1_lpg
				Cxx_dstb_ti_p_cor_lpg
				Cxx_fil_cl_ti_fac_lpg
				Ctp_prs_l_ti_i_cor_lpg
				Ctp_n_ti_p_cor_lpg
				Cxx_is_dstb_ti_ofs_cor1
				Cxx_is_ti_i_cor_lpg
				Ctp_n_l_ti_i_cor_lpg
				Ctp_prs_ti_ofs2_lpg
				Cxx_lamb_swi_ctr_ini_lpg
				Cxx_is_ti_p_cor_lpg
				Cxx_l_ti_slop_thd_lpg
				Cxx_appl_ti_ofs_ctr_lpg
				Cxx_max_ti_p_cor_lpg
				Cxx_ti_p_prs_thd_lpg
				Cxx_ti_ofs_vs_thd_lpg
				Cxx_sta_fl_off_dly_lpg
				Cxx_ti_i_cor_fac_lpg
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION Purge_Canister_GPL_MAP
			""
			/begin DEF_CHARACTERISTIC
				Cxx_cp_trs_l_thd_lpg
				Cxx_cp_trs_h_thd_lpg
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION Automate_MEA_GPL_MAP
			""
			/begin DEF_CHARACTERISTIC
				Cxx_cyl3_ti_dstb_iga_lpg
				Ctp_cata_neut_hot_is_cor1
				Ctp_cata_neut_sta_is_cor1
				Cxx_cyl1_ti_dstb_iga_lpg
				Ctp_cata_wup_cold_lpg
				Cxx_dstb_inj2_ti_fac_lpg
				Ctp_cold_neut_sta_is_cor1
				Cmp_n_tq_lpg_wup_iga_cor1
				Ctp_cata_wup_lean_lpg
				Cxx_dstb_inj1_ti_fac_lpg
				Ctp_cold_neut_hot_is_cor1
				Cxx_dstb_inj3_ti_fac_lpg
				Cxx_cyl2_ti_dstb_iga_lpg
				Ctp_cata_wup_dstb_lpg
				Ctp_neut_cata_is_iga_cor1
				Ctp_cold_neut_is_iga_cor1
				Cxx_dstb_inj4_ti_fac_lpg
				Cmp_n_tq_lpg_wup_iga_cor
				Ctp_cata_wup_eng_lpg
				Cxx_cyl4_ti_dstb_iga_lpg
				Cxx_wup_dstb_h_map_lpg
				Cxx_wup_dstb_l_map_lpg
				Cxx_wup_dstb_h_n_lpg
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION Automate_MEA_MAP
			""
			/begin DEF_CHARACTERISTIC
				Cxx_in_hot_temp_thd
				Cxx_in_hot_temp_hys
				Cxx_cyl3_ti_dstb_iga
				Cxx_cyl3_ti_dstb_iga_is
				Cxx_cyl2_ti_dstb_iga_is
				Ctp_air_pump_sta_tdc_thd
				Ctp_air_pump_stop_tdc_thd
				Cxx_cyl1_ti_dstb_iga_is
				Ctb_rel_tq_wup
				Cxx_cyl1_ti_dstb_iga
				Cxx_is_iga_cor_fil_step
				Ctp_cata_drag_red_sta_is_cor
				Cxx_air_pump_cor
				Cxx_air_pump_eal_dsb
				Cxx_air_pump_eal_dsb_hys
				Cxx_cyl2_ti_dstb_iga
				Cxx_dstb_inj1_ti_fac_is
				Ctp_ti_cor_eai_fil_ctr
				Cxx_dstb_inj4_ti_fac_is
				Cxx_dstb_inj4_ti_fac
				Ctp_tdc_pn_tco_is_n_ofs
				Ctp_tdc_drag_red_tco_is_n_ofs
				Ctp_tdc_agb_tco_is_n_ofs
				Cxx_dstb_inj3_ti_fac_is
				Cxx_dstb_inj3_ti_fac
				Ctb_n_wup
				Cxx_dstb_inj2_ti_fac
				Cxx_cyl4_ti_dstb_iga
				Cxx_dstb_inj1_ti_fac
				Ctb_eal_eai
				Ctp_tco_lean_ti_fac_cor
				Ctp_tco_eai_ti_fac_cor
				Ctp_cata_dri_hot_is_cor
				Ctp_cata_wup_dstb
				Ctb_n_eai
				Ctp_neut_cata_is_iga_cor
				Cxx_cyl4_ti_dstb_iga_is
				Cxx_dstb_inj2_ti_fac_is
				Cbx_rich_dstb_iga_cor
				Ctp_cold_drag_red_is_iga_cor
				Ctp_dri_cata_is_iga_cor
				Ctp_cold_dri_hot_is_cor
				Ctp_cold_neut_sta_is_cor
				Ctp_cold_dri_sta_is_cor
				Cxx_cold_sta_tco
				Ctp_eai_rich_cl_ctr
				Ctp_cold_neut_hot_is_cor
				Ctp_cold_neut_is_iga_cor
				Cxx_cata_wup_dstb_prs_max
				Cxx_cata_wup_dstb_ofs
				Ctp_cold_drag_red_hot_is_cor
				Cxx_air_pump_is_cor1
				Ctp_cold_drag_red_sta_is_cor
				Ctp_cata_drag_red_hot_is_cor
				Ctb_iga_cata_wup_ctr
				Ctp_drag_red_cata_is_iga_cor
				Cxx_cold_pn
				Ctp_cata_wup_cold
				Ctb_is_cata_wup_ctr
				Cxx_cold_drag_red
				Ctp_cold_tdc_pn_is_n_ofs
				Ctp_cold_tdc_drag_red_is_n_ofs
				Cxx_cold_agb
				Ctp_cold_tdc_agb_is_n_ofs
				Cxx_cata_wup_dstb_n_max
				Ctp_h_l_iga_cata_wup
				Cxx_air_pump_is_cor2
				Cxx_air_pump_n_dsb
				Cxx_air_pump_n_dsb_hys
				Ctp_cata_wup_eai
				Cxx_air_pump_sta_dly
				Ctp_cata_wup_eng
				Cxx_air_pump_stop_dly
				Ctp_cata_wup_lean
				Cxx_air_pump_thr_ar_sp
				Ctp_cata_dri_sta_is_cor
				Ctp_cold_dri_is_iga_cor
				Cmp_n_prs_eai_ti_cor
				Cxx_cor_fil_cata_hot_dec
				Cxx_air_pump_thr_ar_sp_hys
				Cmp_n_tq_cart_h_iga_cor
				Cxx_cor_fil_cata_hot_inc
				Cxx_cart_iga_fil_inc
				Cmp_n_tq_cart_l_iga_cor
				Cmp_n_tq_cart_iga_cor1
				Cxx_cart_iga_fil_dec
				Ctp_cata_neut_hot_is_cor
				Cxx_cata_wup_dstb_prs_min
				Cxx_cart_iga_fil_cold_inc
				Cmp_n_prs_lean_ti_cor
				Ctp_cata_neut_sta_is_cor
				Cxx_sa_alt_dly_is_cor
				Cxx_rest_mod_dsb_max_dly
				Cxx_rest_mod_dsb_tco_thd
				Cxx_tco_ti_fil_nr2
				Cxx_sa_dly_is_cor
				Cxx_tco_ti_fil_nr
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION Adaptatif_Rich_GPL_MAP
			""
			/begin DEF_CHARACTERISTIC
				Ctb_lpg_ad_zon_prs
				Ctb_lpg_ad_fac
				Ctd_lpg_typ_id
				Cxx_lpg_ad_lpg_max_temp
				Cxx_lpg_ad_min_tco
				Cxx_lpg_zon_3_ad_prs_min
				Cxx_lpg_zon_2_ad_prs_min
				Cxx_lpg_ena_ad_prs_min_thd
				Cxx_lpg_ad_l_thd
				Cxx_lpg_ad_h_thd
				Cxx_lpg_zon_5_ad_prs_min
				Cxx_lpg_ad_cl_ti_fac_thd
				Cxx_lpg_ad_fac_fac
				Cxx_lpg_ad_lpg_min_temp
				Cxx_lpg_ena_ad_prs_max_thd
				Cxx_lpg_ad_min_n
				Cxx_lpg_ad_max_prs
				Cxx_lpg_ad_min_prs
				Cxx_lpg_ad_max_n
				Cxx_lpg_zon_4_ad_prs_min
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION Adaptatif_Rich_MAP
			""
			/begin DEF_CHARACTERISTIC
				Cxx_is_hot_ti_cl_dly
				Ctd_ti_b_cor
				Ctd_ti_ad_ofs_cor
				Ctd_ti_ad_fac_cor
				Cxx_ad_lamb_swi_ctr
				Ctp_max_mv_cld_ad
				Ctp_min_mv_cld_ad
				Cxx_cld_ad_nr
				Cxx_is_hot_tco_thd
				Cxx_ad_off_ti_ad_fac
				Cxx_ad_off_ti_ad_ofs
				Cxx_max_cld_fac_thd
				Cxx_max_cld_ofs_thd
				Cxx_min_ad_fac_thd
				Cxx_min_mv_ti_ad_ofs
				Cxx_min_ad_ofs_thd
				Cxx_min_mv_ti_ad_fac
				Cxx_min_cld_fac_thd
				Cxx_min_cld_ofs_thd
				Cxx_prs_zon0
				Cadzerom
				Cxx_min_dif_ti_b
				Cxx_max_mv_ti_ad_ofs
				Cxx_prs_zon
				Cadgainm
				Cxx_zon_dif_min_hys
				Cxx_max_mv_ti_ad_fac
				Cxx_ti_ad_max_n
				Cxx_ti_ad_prs_l_thd
				Cxx_ti_ad_prs_trs_thd
				Cxx_ti_ad_prs_up_thd
				Cxx_ti_ad_tco_thd
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION SDF_R�gul_Ralenti_MAP
			""
			/begin DEF_CHARACTERISTIC
				Ctp_n_agb_tq_pwm
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION Mouillage_MAP
			""
			/begin DEF_CHARACTERISTIC
				Cmp_wet_eal_vol_fac_tco60
				Ctp_wet_vol_dif_thd_sta
				Ctp_wet_vol_dif_thd_sta_t
				Cmp_wet_eal_vol_fac_tco20
				Cmp_wet_eal_fil_fac_tco00
				Cxx_decl_lean_dsb_n_thd
				Cmp_wet_prs_vol_fac_tco60
				Cmp_wet_eal_fil_fac_tco40
				Ctp_wet_vol_dif_thd_decl
				Cmp_wet_eal_fil_fac_tco20
				Cmp_wet_eal_vol_fac_tco40
				Cmp_wet_prs_vol_fac_tco80
				Cxx_decl_prs_lean_dsb_dly
				Ctb_wet_cor_map
				Cbx_wet_tb_cor_bch_mod
				Ctb_wet_tdc_rat_ctr
				Ctp_wet_ini_acel_cor_ofs
				Ctb_wet_n
				Ctp_wet_decl_fil_fac
				Cbx_wet_stat_cor_bch_mod
				Ctp_wet_vol_dif_thd_ini
				Ctp_wet_acel_cor_fac
				Cbx_wet_ti_cut_bch_mod
				Cbx_wet_prs_eal_swi_mod
				Cbx_wet_bch_mod
				Ctp_wet_tb_acel_vol_fac
				Ctp_wet_tb_decl_vol_fac
				Cmp_wet_prs_vol_fac_tco40
				Ctp_wet_vol_dif_thd_acel
				Ctp_wet_decl_cor_fac
				Cmp_wet_eal_fil_fac_tco80
				Cmp_wet_prs_vol_fac_tco00
				Cmp_wet_prs_vol_fac_tco20
				Cmp_wet_prs_fil_fac_tco40
				Cmp_wet_prs_fil_fac_tco20
				Cmp_wet_eal_vol_fac_tco00
				Cxx_decl_lean_dsb_n_ofs
				Cmp_wet_prs_fil_fac_tco80
				Cmp_wet_prs_fil_fac_tco60
				Cmp_wet_prs_fil_fac_tco00
				Cmp_wet_eal_vol_fac_tco80
				Cmp_wet_eal_fil_fac_tco60
				Cxx_wet_tb_cor_fac
				Cxx_wet_tdc_ctr_rat
				Cxx_wet_ti_cut_tdc_nr
				Cxx_wet_ti_cut_nr
				Cxx_wet_ini_acel_ofs_t
				Cxx_wet_decl_bch_cor_fac
				Cxx_wet_decl_bch_fil_fac
				Cxx_wet_acel_bch_fil_fac
				Cxx_wet_ini_acel_sta_t
				Cxx_wet_acel_bch_cor_fac
				Cxx_wet_bch_vol_fac
				Cxx_wet_min_air_stab_thd
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION SDF_MAP
			""
			/begin DEF_CHARACTERISTIC
				Ctd_gear_pdl_psn
				Ctp_n_rams_max_thr_ar
				Ctp_lih_iga_prmt_cor
				Ctd_gear_inj_stop_n
				Cmx_n_iga_tq_min_lih
				Ctd_gear_inj_stop_n_dec
				Cxx_lih_efy_inj_2_3_thd
				Cxx_lih_iga_max_cor_rtn_t
				Cxx_lih_efy_inj_3_4_thd
				Cxx_rams_acel_fil_thr
				Cxx_thr_acel_thd
				Cxx_lih_efy_inj_4_3_thd
				Cxx_lih_iga_cor_dec_t
				Cxx_lih_iga_max_cor
				Cxx_lih_efy_inj_3_2_thd
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION R�gul_Ralenti_MAP
			""
			/begin DEF_CHARACTERISTIC
				Cxx_is_aj_n_drv_h_hys
				Cxx_cold_agb_tco_is_n_ofs
				Cxx_cold_drag_red_tco_is_n_ofs
				Cxx_cold_pn_tco_is_n_ofs
				Cxx_fast_ad_cdn_dly
				Cxx_h_ad_is_alt_pow
				Cxx_iga_is_deci_in_dly
				Cxx_iga_is_deci_in_n_thd
				Cxx_is_aj_clc_step
				Cxx_is_aj_n_drv_l_hys
				Cxx_is_cdn_h_sta_n_dly
				Cxx_is_d_cor_min
				Cxx_is_d_dsb_n_drv_thd
				Cxx_is_dclu_acc
				Cxx_is_aj_clc_n_drv_fac
				Cxx_is_stab_n_drv_thd
				Cxx_el_csm_clc_dly
				Cxx_el_csm_clc_neg_fac
				Cxx_clu_acc
				Cxx_l_ad_is_alt_pow
				Cxx_is_deci_in_dly
				Cxx_is_p_min
				Cxx_el_csm_clc_pos_fac
				Cxx_is_p_max
				Cxx_is_i_fac3
				Cxx_l_is_pwm
				Cxx_is_p_clc_fac3
				Cxx_is_min_ad_pwm_ini
				Cxx_is_n_sp_max
				Cxx_is_n_stab_clc_fac
				Cxx_is_out_n_ofs
				Cxx_is_out_n_ofs_sta
				Cxx_is_out_n_ofs2
				Cxx_is_out_pump_thd
				Cxx_is_i_fac1
				Cxx_is_p_clc_fac2
				Cbx_is_min_ad_pwm_set
				Cxx_is_p_clc_fac4
				Cxx_is_p_dsb_n_hys
				Cxx_dri_sp_is_cor
				Cxx_dri_agb_ad_is_fil
				Cxx_fil_is_i_sp
				Cxx_is_p_clc_fac1
				Cxx_is_iga_sp_max_ofs
				Cxx_drag_red_tco_is_n_ofs
				Cxx_is_i_fac2
				Cxx_is_i_fil_fac1
				Cxx_cp_is_cor
				Cxx_is_i_fil_fac2
				Cxx_is_i_n_drv_thd
				Cxx_is_i_sp_fil_fac
				Cxx_is_in_pump_thd
				Cxx_is_iga_prop_sp_fac
				Cxx_is_in_dly
				Cxx_is_in_cdn_ofs
				Cxx_is_in_cdn_ofs2
				Cbx_is_ad_mdf_conf
				Cbx_is_alt_conf
				Cbx_is_dft_ini_req
				Cbx_is_ini_req
				Cbx_is_min_ad_pwm_req
				Cxx_is_deci_in_n_thd
				Cxx_is_i_zon_out_dly
				Ctp_pwst_iga_cor_max_lim
				Cxx_agb_min_is_n_step_dly
				Ctp_tia_is_cor
				Ctp_tco_neut_is_cor
				Ctp_tco_is_bas_iga
				Ctp_tco_ini_fil_is_i_ad
				Ctp_tq_agb_is_iga
				Ctp_tco_dri_agb_is_iga
				Cxx_ac_is_i_n_drv_thd
				Ctp_prs_is_i_set
				Ctp_pn_tco_min_is_n
				Ctp_n_ptc_is_cor
				Ctp_n_neut_dyn_iga_fac5
				Ctp_n_neut_dyn_iga_fac4
				Ctp_n_neut_dyn_iga_fac3
				Ctp_n_neut_dyn_iga_fac2
				Ctp_tco_dri_is_cor_ofs
				Cxx_ac_mdf2_is_cor
				Cxx_agb_min_is_n_step
				Cxx_agb_min_is_n
				Cxx_agb_ac_min_is_n
				Cxx_ad_ptc_pow_thd
				Cxx_ad_cor_dsb_dly
				Cxx_acel_is_req_dclu_acc
				Cxx_ac_min_is_n_step_dly
				Ctp_toil_is_n_ofs
				Cxx_ac_mdf2_is_cor1
				Ctp_n_dri_dyn_iga_fac5
				Cxx_ac_mdf1_is_cor1
				Cxx_ac_mdf1_is_cor
				Cxx_ac_is_out_n_ofs2
				Cxx_ac_is_out_n_ofs
				Cxx_ac_is_in_dly
				Cxx_ac_is_in_cdn_ofs2
				Cxx_ac_is_in_cdn_ofs
				Cxx_ac_min_is_n_step
				Ctb_is_cor_alt_pow
				Ctp_ac_neut_is_cor
				Ctp_ac_is_cor_appl_dly
				Ctp_ac_dri_tmp_is_cor
				Ctp_ac_dri_is_cor
				Ctd_n_ptc_is_cor
				Ctb_toil
				Cxx_alti_is_dec
				Ctp_n_neut_dyn_iga_fac1
				Ctb_is_cor_n
				Ctp_ac_pow_is_iga
				Ctb_csm_agb_tq
				Cbx_thr_dft_ini_req
				Cbx_on_ac_cor_dsb
				Cbx_on_mdf_cor_dsb
				Cbx_on_ptc_cor_dsb
				Cbx_on_pwst_cor_dsb
				Cbx_on_tia_fail_cor_dsb
				Ctb_n5
				Ctp_is_d_clc_n_drv_fac
				Ctp_n_alt_is_cor
				Ctp_n_dri_dyn_iga_fac4
				Ctp_n_dri_dyn_iga_fac3
				Ctp_n_dri_dyn_iga_fac2
				Ctp_n_dri_dyn_iga_fac1
				Ctp_n_dri_dyn_iga_fac
				Ctp_n_ac_is_cor
				Ctp_ac_neut_tmp_is_cor
				Ctp_is_d_clc_tco_fac
				Ctp_ac_pow_dri_is_iga
				Ctp_is_aj_clc_n_cor
				Ctp_el_csm_n_sp_ofs
				Ctp_drag_tco_min_is_n
				Ctp_alti_sta_cor
				Ctp_alt_neut_is_cor
				Ctp_alt_dri_is_cor
				Ctp_agb_tco_min_is_n
				Ctp_n_neut_dyn_iga_fac
				Ctp_is_pwm_thr_ar_sp
				Cxx_agb_ptc_min_is_n
				Cxx_agb_pwst_min_is_n
				Cxx_agb_tco_is_n_ofs
				Cxx_alt_pow_fil_fac
				Cxx_agb_min_tqe_fac
				Cxx_agb_vh_min_is_n
				Cxx_alt_tq_fil_fac
				Cxx_alti_is_cor
				Cxx_max_stop_dyn_iga1
				Cxx_ptc_is_cor_appl_dly1
				Cxx_ptc_cor
				Cxx_ptc_min_is_n_step
				Cxx_ptc_is_cor_appl_dly
				Cxx_ptc_pow
				Cxx_max_stop_dyn_iga
				Cxx_pwst_iga_cor_cge_t
				Cxx_pwst_min_is_n_dec
				Cxx_pwst_min_is_n_rtn_dly
				Cxx_pwst_off_is_cor_dly
				Cxx_pwst_on_is_cor_dly
				Cxx_pwst_prs_tco_thd
				Cxx_max_stop_dyn_iga4
				Cxx_min_tco_ad_cor
				Cxx_neut_ad_is_fil
				Cxx_run_ac_dyn_iga_fac
				Cxx_run_dyn_iga_ofs
				Cxx_pwst_min_is_n_dec_dly
				Cxx_n_ofs_cart_iga_stop2
				Cxx_mdf2_is_cor1
				Rcoban
				Cxx_mdf2_is_cor_appl_dly1
				Cxx_neut_sp_is_cor
				Cxx_mdf2_is_cor_appl_dly
				Cxx_mdf2_is_cor
				Cxx_mdf1_is_cor1
				Cxx_mdf1_is_cor_appl_dly1
				Cxx_mdf1_is_cor_appl_dly
				Cxx_mv_vb_fil_fac
				Rrcobanc
				Cxx_mdf_cor
				Cxx_prs_dft_min_is_n
				Cxx_run_vh_min_is_n
				Cxx_pn_ac_min_is_n
				Cxx_pn_ptc_min_is_n
				Cxx_pn_pwst_min_is_n
				Cxx_pn_tco_is_n_ofs
				Cxx_pn_vh_min_is_n
				Cxx_ptc_min_is_n_step_dly
				Cxx_max_stop_dyn_iga5
				Cxx_max_stop_dyn_iga3
				Cxx_max_stop_dyn_iga2
				Cxx_mdf1_is_cor
				Cxx_max_run_dyn_iga
				Cxx_max_run_ac_dyn_iga
				Cxx_min_is_min_ad_pwm
				Cxx_min_is_i_ofs
				Cxx_min_is_i_2
				Cxx_max_n_ad_sp_dif
				Cxx_max_run_dyn_iga1
				Cxx_max_run_dyn_iga_fac
				Cxx_min_is_i
				Cxx_max_is_min_ad_pwm
				Cxx_max_is_i_ofs
				Cxx_sta_stt_is_in_dly
				Cxx_stop_ac_dyn_iga_fac
				Cxx_tco_is_n_ofs_rat_lim
				Cxx_stop_dyn_iga_ofs
				Cxx_vh_stop_pwst_is_cor3
				Cxx_max_stop_ac_dyn_iga
				Cxx_vh_run_ini_is_i_ofs
				Cxx_vh_run_max_is_i_ofs
				Cxx_vh_run_min_is_i_ofs
				Cxx_vh_run_pwst_is_cor2
				Cxx_vh_run_pwst_is_cor3
				Cxx_vh_run_tmp_pwst_cor
				Cxx_vh_stop_pwst_is_cor2
				Cxx_max_run_dyn_iga2
				Cxx_vh_stop_tmp_pwst_cor
				Cxx_toil_is_n_ofs
				Cxx_max_run_dyn_iga4
				Cxx_tmp_mdf1_is_cor
				Cxx_tmp_ac_is_cor_dec
				Cxx_tmp_ac_cor_dec_dly
				Cxx_max_run_dyn_iga5
				Cxx_max_run_dyn_iga3
				Cxx_tmp_mdf2_is_cor
				Cxx_vh_stop_ini_is_i_ofs
				Cbx_agb_is_n_req
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION Chaud_MAP
			""
			/begin DEF_CHARACTERISTIC
				Cxx_cmd_mdf_dly
				Cxx_dft_lght_on_tco_thd
				Cxx_ac_ena_tco_thd
				Cxx_dft_lght_off_tco_thd
				Cxx_ac_dsb_tco_thd
				Cxx_tco_fail_cmd_mdf_dly
				Cxx_wpmp_max_t
				Cxx_mdf_1_cmd_ena_thd_tco
				Cxx_mon_stop_tco_thd
				Cxx_wpmp_max_tco_t
				Cxx_wpmp_tco_hys
				Cxx_wpmp_tco_thd
				Cxx_mdf1_clu_dly
				Cxx_mem_tia_fail_max_tia
				Cxx_mdf2_on_tco_thd
				Cxx_tco_mdf_dly
				Cxx_mdf1_clu_off_dly
				Cxx_mdf1_off_tco_thd
				Cxx_mdf1_on_tco_thd
				Cxx_mdf1_on_tco_thd_hys
				Cxx_mdf2_off_tco_thd
				Cxx_run_mdf1_off_tco_thd
				Cbx_agb_mdf2_conf
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION SDF_LIS_MAP
			""
			/begin DEF_CHARACTERISTIC
				Cxx_i_agb_driv_tq_thd
				Cxx_dft_agb_tq_sp_lim
				Cxx_min_agb_tq_sp
				Cxx_max_fast_agb_tq
				Cxx_max_gear_cge_dly
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION SDF_D�part_MAP
			""
			/begin DEF_CHARACTERISTIC
				Ctb_tco
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION SDF_GPL_MAP
			""
			/begin DEF_CHARACTERISTIC
				Cmx_n_iga_tq_min_lih_lpg
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION SDF_Agr�ment_MAP
			""
			/begin DEF_CHARACTERISTIC
				Cxx_fail_decl_cut_n_ofs
				Ctp_h_vs_pdl_fac
				Cxx_fail_decl_inj_cut
				Ctp_is_decl_clc_cut_n_fac
				Cmp_pdl_n_driv_abv_tqe
				Ctp_l_vs_pdl_fac
				Cxx_agb_tq_max_ofs
				Cxx_fail_decl_inj_cut_lpg
				Cxx_degr_cut_gear_thd
				Cxx_fmt_pdl_h_vs_thd
				Ctp_is_decl_clc_tco_fac
				Ctb_rel_pdl_psn
				Ctp_vs_l_tq_pdl_thd
				Cxx_dz_pdl
				Cbx_tq_abst_agb_aj_dsb
				Ctp_rvr_pdl_fac
				Cxx_fmt_pdl_l_vs_thd
				Cxx_tkof_n_thd
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION D�part_GPL_MAP
			""
			/begin DEF_CHARACTERISTIC
				Cbx_lpg_min_lvl_lih_ena
				Cbx_lpg_aper_pump_run_ena
				Cxx_gas_pump_dly
				Ctp_lpg_sta_tia_thd
				Ctp_lpg_sta_tco_thd
				Cbx_lpg_gas_pump_cut_ena
				Cbx_lpg_sta_ena
				Ctp_lpg_tia_thd
				Cxx_lpg_tco_ti_cor_fac
				Cxx_lpg_aper_n_thd
				Cxx_lpg_pump_run_cdn_dly
				Cxx_lpg_aper_pump_run_dly
				Cxx_lpg_aper_dly
				Cxx_lpg_max_nr_lpg_stal
				Cxx_lpg_gas_pump_cut_dly
				Cxx_rest_tco_l_ofs_lpg
				Cxx_rest_tco_up_ofs_lpg
				Cxx_lpg_gas_pump_wup_dly
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION R�servoir_vide_GPL_MAP
			""
			/begin DEF_CHARACTERISTIC
				Cbx_min_lvl_pump_cut_ena
				Cbx_lpg_min_lvl_diag_ena
				Cbx_lpg_prs_diag_ena
				Cxx_lpg_diag_ti_fac_thd
				Cxx_lpg_cl_lean_diag_dly
				Cxx_prs_dif_lpg_cdn_thd
				Cxx_lpg_stall_dly
				Cxx_lpg_fl_lean_diag_dly
				Cxx_min_lpg_fl_prs_thd
				Cxx_min_lpg_cl_n_thd
				Cxx_lpg_prs_diag_dly
				Cxx_lpg_max_nr_lpg_stall
				Cxx_min_lpg_cl_prs_thd
				Cxx_lpg_prs_fil_fac
				Cxx_min_lpg_fl_n_thd
				Cxx_lpg_prs_dif_stab_thd
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION Transition_gaz_GPL_MAP
			""
			/begin DEF_CHARACTERISTIC
				Cxx_gas_lpg_trs_cyc_nr
				Ctb_lpg_temp_09
				Ctp_gas_lpg_trs_cor_ini
				Ctp_gas_lpg_trs_cor_inc
				Ctp_lpg_gas_trs_cor_ini
				Ctp_gas_trs_cor_stop
				Ctp_lpg_trs_cor_stop
				Ctp_prs_lpg_trs_cor_min
				Ctp_prs_gas_trs_cor_min
				Ctp_gas_lpg_trs_cor_dec
				Ctp_lpg_temp_wup_cor_fac
				Ctp_lpg_gas_trs_cor_inc
				Ctp_lpg_gas_trs_cor_dec
				Ctp_lpg_aftr_sta_ini_dly
				Ctp_lpg_temp_wup_cyc_nr
				Cxx_lpg_gas_max_n
				Cxx_lpg_gas_dly
				Cxx_lpg_rich_cl_tco_thd
				Cxx_tdc_nr_bfr_lpg_gas
				Cxx_tdc_nr_bfr_gas_lpg
				Cxx_lpg_prs_dif_trs_thd
				Cxx_lpg_gas_lpg_min_n
				Cxx_lpg_wup_cor_dec
				Cxx_lpg_gas_lpg_dly
				Cxx_lpg_gas_trs_cyc_nr
				Cxx_lpg_gas_min_prs
				Cxx_lpg_wup_cor_inc
				Cxx_lpg_gas_min_n
				Cxx_lpg_gas_max_prs
				Cxx_lpg_gas_lpg_min_prs
				Cxx_lpg_gas_lpg_max_n
				Cxx_lpg_gas_lpg_max_prs
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION Reco_Cylindre_GPL_MAP
			""
			/begin DEF_CHARACTERISTIC
				Cxx_cylr_clc_ctr_lpg
				Cxx_cylr_is_clc_ctr_lpg
				Cxx_cylr_is_min_tq_dec1
				Cxx_cylr_min_n_lpg
				Cxx_cylr_max_tq_dec_lpg
				Cxx_cylr_min_tq_dec_lpg
				Cxx_cylr_stab_ctr_lpg
				Cxx_cylr_is_max_tq_dec1
				Cxx_cylr_max_prs_lpg
				Cxx_cylr_min_prs_lpg
				Cxx_cylr_stab_is_ctr_lpg
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION Reco_Cylindre_MAP
			""
			/begin DEF_CHARACTERISTIC
				Cxx_cylr_n_stab_dif
				Cxx_cylr_min_prs
				Cxx_cylr_is_max_test_nr
				Cxx_asd_lean_cylr
				Ctp_ol_is_lean_cylr
				Cxx_asd_rich_cylr
				Cxx_cylr_is_clc_ctr
				Cxx_cylr_gear
				Cxx_cylr_eol_mod
				Cxx_cylr_l_prs_re_phs
				Cxx_cylr_min_tco
				Cxx_cylr_clc_ctr
				Ctp_ol_is_rich_cylr
				Cxx_cylr_stab_ctr
				Cxx_cylr_tco_thd
				Cxx_cylr_cp_ti_fac
				Cxx_cylr_alti_prs_max_fac
				Ctp_tco_rich_cylr
				Cmp_prs_n_rich_cylr
				Cxx_cylr_stab_inj_dif
				Ctp_tco_lean_cylr
				Cxx_cylr_stab_is_ctr
				Cxx_cylr_alti_prs_min_fac
				Cmp_prs_n_lean_cylr
				Cxx_alti_prs2_fac
				Cxx_cylr_l_n_re_phs
				Cxx_cylr_is_run_n_fac
				Cxx_cylr_max_prs
				Cbx_trz_ad_b1_fil_req
				Cbx_trz_ad_b1_val_req
				Cbx_trz_ad_b2_fil_req
				Cxx_cylr_is_max_tq_dec
				Cxx_cylr_is_run_min_tco
				Cxx_cylr_min_tq_dec
				Cbx_trz_ad_b2_val_req
				Ctp_cl_is_rich_cylr
				Ctp_cl_is_lean_cylr
				Cxx_cylr_max_mv_lamb_fac
				Cxx_cylr_max_dif_iga
				Cxx_in_run_stal_step
				Cxx_cylr_l_prs_dif_fac
				Ctp_cylr_prs_stab_dif
				Cxx_cylr_is_ti_fac_min
				Cxx_cylr_max_test_nr
				Cxx_cylr_min_mv_lamb_fac
				Cxx_cylr_is_min_tq_dec
				Cxx_cylr_is_run_max_tco
				Cxx_cylr_min_n
				Cxx_cylr_max_tq_dec
				Cxx_cylr_max_tco
				Cxx_stal_step
				Cbx_cylr_bch_mod
				Cbx_bch_cylr
				Cbx_cam_dft_ini_req
				Cbx_cylr_loop
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION R�gul_Ralenti_GPL_MAP
			""
			/begin DEF_CHARACTERISTIC
				Ctp_tco_is_bas_iga_lpg
				Ctp_tco_dri_is_iga_lpg
				Ctp_tq_agb_is_iga_lpg
				Ctp_n_neut_dyn_iga_fac6
				Ctp_n_dri_dyn_iga_fac_lpg
				Cxx_max_run_ac_dyn_iga1
				Cxx_max_stop_dyn_iga_lpg
				Cxx_max_run_dyn_iga_lpg
				Cxx_run_dyn_iga_ofs_lpg
				Cxx_stop_dyn_iga_ofs_lpg
				Cxx_max_stop_ac_dyn_iga1
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION D�part_MAP
			""
			/begin DEF_CHARACTERISTIC
				Ctp_tco_sta_ti
				Ctp_n_cold_eng_sta_iga
				Ctp_tia_sta_ti_fac
				Ctd_tco_min_rest_cor
				Cxx_is_in_ofs_sta_stt
				Ctp_tco_dec_sta_ti
				Ctd_ufld_rest_cor
				Ctp_n_sta_ti
				Ctp_tco_inj_sta_dly
				Ctp_tco_sta_ti_fac
				Ctp_tco_ti_fac1
				Ctp_n_hot_eng_sta_iga
				Ctp_tco_ini_is_i
				Ctp_tco_lim_sta_iga
				Ctp_tco_ti_fac3
				Ctp_sta_is_fil_pwm_dec
				Cxx_alti_pinj_cor_fac
				Cxx_alti_ini_fil_is_i
				Ctp_tco_sta_out_sfg_dly
				Cxx_hot_sta_iga_tco_thd
				Cxx_aper_rich_sta_tco_thd
				Cxx_aper_rich_sta_tia_thd
				Cmp_n_prs_tco_ti_fac2
				Cbx_sfg_bch
				Ctp_ufld_tco_thd
				Ctp_tco_n_ini
				Ctp_tco_pinj_t
				Ctp_tco_sta_is_pwm
				Ctp_tco_sta_rich_dec
				Cxx_stop_ufld_ctr_inc
				Cxx_stal_rest_fac
				Trgmxvsc
				Cxx_stop_rest_tco_thd
				Cxx_stop_rest_ufld_thd
				Tmmyvsc
				Cxx_n_cmp_n_is_sp_in_sta
				Cxx_n_lim_l_tco_thd
				Cxx_n_lim_sta_iga_dec
				Cxx_n_lim_sta_iga_inc
				Cxx_n_lim_up_tco_thd
				Cxx_n_ofs_in_sta_iga
				Srgmnvsc
				Cxx_out_inj_sta_n_thd
				Cxx_tco_fail_pinj_t
				Tmmxvsc
				Tmouto
				Trgmyvsc
				Cxx_tia_tco_fail_sta_tia
				Cxx_stal_dly
				Cxx_tco_inc_tdc_nr
				Cxx_n_ofs_out_sta_iga
				Cxx_sta_rich_dec_nr
				Cxx_mem_tco_fail_max_tco
				Cxx_tia_tco_fail_sta_tco
				Cxx_rest1_ufld_cor
				Cxx_ptc_rov_tia_hys
				Cxx_ptc_rov_tia_thd
				Cxx_sfg_seq_trs_ti_fac
				Cxx_sta_inj_sta_angl
				Cxx_sta_pinj_toth_nr
				Cxx_sfg_seq_trs_ctr
				Cxx_rest_ufld_cor
				Cxx_sfg_seq_trs_n_thd
				Cxx_run_ufld_ctr_inc2
				Cxx_rest_tco_up_ofs
				Cxx_sta_tco_ti_dec_fac
				Cxx_sta_tco_ti_rest_fac
				Cxx_rest_tco_l_ofs
				Cxx_rich_sta_tco_thd
				Cxx_rich_tia_thd
				Cxx_run_ufld_ctr_inc1
				Cxx_rest_pinj_cor_fac
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION Agr�ment_GPL_MAP
			""
			/begin DEF_CHARACTERISTIC
				Cxx_ac_swi_is_ofs_lpg
				Cxx_cut_tqr_thd_prs_lpg
				Cxx_cut_decl_gear_thd4
				Ctp_tqr_cut_lpg
				Ctp_tco_cut_decl_off_dly1
				Ctp_tqr_swi_lpg
				Cxx_ac_aut_swi_is_ofs_lpg
				Cxx_ac_aut_swi1_is_ofs1
				Cxx_cut_decl_tco_thd_lpg
				Ctp_comp_wup_lpg
				Cxx_cut_decl_gear_thd3
				Cxx_cut_tqr_thd_n_lpg
				Cxx_aut_swi1_is_ofs_lpg
				Cxx_cut_decl_tco_thd1_lpg
				Cxx_aut_swi_is_ofs_lpg
				Cxx_swi_is_ofs_lpg
				Cxx_map_cut_decl_dly_lpg
				Cxx_n_ofs_swi_iga_stop1
				Cxx_tkof_fl_rich_fac_lpg
				Cxx_tqr_rtn_nr_tdc_gear2
				Cxx_tmp_cut_map_thd_lpg
				Cxx_tqr_ct_thd_prs_lpg
				Cxx_tqr_max_lpg
				Cxx_tqr_swi_rtn_nr_tdc1
				Cxx_tqr_rtn_nr_tdc_lpg
				Cxx_tqr_max_gear1_lpg
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION Agr�ment_MAP
			""
			/begin DEF_CHARACTERISTIC
				Ctp_acel_aj_tqe_up_thd
				Ctp_decl_aj_tqe_l_thd
				Ctp_gear_acel5_aj_fil_fac
				Ctp_fast_tq_cold_min_lim
				Ctp_gear_decl2_aj_fil_fac
				Ctp_agb_toil_cor
				Cxx_etun_nr
				Cxx_eng_stop_thr_psn_sp
				Ctp_gear_decl4_aj_fil_fac
				Ctp_gear_acel1_aj_fil_fac
				Ctp_fzy_tkof_vs_fac
				Ctp_gear_acel3_aj_fil_fac
				Ctp_fac_n_dif_drv
				Cxx_dyn_iga_fil_ini_n_ofs
				Ctp_decl_aj_tqe_up_thd
				Cxx_dyn_iga_pdl_rel
				Cxx_dyn_iga_vs_hys
				Ctp_comp_wup
				Cxx_dyn_iga_efy_dz
				Cxx_dyn_iga_fil_n_ofs
				Cxx_dyn_iga_vs
				Cxx_dyn_iga_gear_val
				Cxx_dyn_iga_mv_clc_dly
				Cxx_dyn_iga_mv_n_fac
				Cxx_dyn_iga_mv_n_thd
				Cxx_dyn_iga_pdl_rel_hys
				Cxx_el_wind_tco
				Cxx_gear_cge_dly
				Ctb_toil2
				Ctb_tkof_vs_n_rat
				Ctb_tco_thd
				Cxx_gear_cge_tq_max_ofs
				Cxx_ac_aut_swi_is_ofs
				Cxx_gear_cge_n_thd
				Cxx_gear_cge_l_tq_dly
				Ctd_gear_cart_dyn_n_thd
				Cxx_gear_cge_eal_thd
				Ctb_vs_mvac_dp
				Cxx_gear_cge_dec_dly
				Ctb_tco_cut
				Cxx_gear_cge_cut_map_ofs
				Cxx_fzy_tkof_lim_dec_t
				Ctb_n_aj
				Ctb_n_dif
				Ctb_n_gear_cge
				Cxx_gear_cge_fast_lim_dly
				Ctd_gear_dyn_iga_fil
				Cxx_fast_tq_max_lim10
				Cxx_fast_tq_max_lim20
				Cxx_fast_tq_max_lim30
				Cxx_fast_tq_min_lim10
				Cxx_fast_tq_min_lim20
				Cxx_fast_tq_min_lim30
				Ctd_hys_n_ovn
				Ctb_tq_rat_sp
				Cxx_fil_map_fac
				Ctb_vs
				Ctd_gear_aj_fast_tq_fac
				Ctb_n_drv
				Cxx_gear_mem_vs_thd
				Cxx_gear_iga_dec
				Ctd_gear
				Cxx_gear_cge_vs_dly
				Ctd_fil_tq_ovn
				Ctp_acel_aj_tqe_l_thd
				Ctd_gear_max_n
				Cxx_cut_decl_tco_thd1
				Cxx_aftr_inj_map_fac
				Cxx_aftr_inj_map_dif
				Cxx_ct_fac_step_dec
				Cxx_ct_fac_step_inc
				Cxx_ct_stat_tq_ofs
				Cxx_ct_stop_tkof_fil_fac
				Cxx_cut_decl_gear_thd1
				Cxx_deb_dly
				Cxx_cut_decl_tco_thd
				Cxx_aj_tqe_thd_fac
				Cxx_cut_fac_step_dec
				Cxx_cut_n_ofs
				Cxx_cut_n_ofs2
				Cxx_cut_tqr_thd_n
				Cxx_cut_tqr_thd_prs
				Cxx_ac_swi_is_ofs
				Cxx_ac_cut_n_ofs
				Cxx_ac_aut_swi1_is_ofs
				Cxx_cut_decl_gear_thd2
				Cxx_clos_thr_vs_max
				Cxx_clc_gear_det_l_gear
				Cxx_clc_gear_rat_hys_1
				Cxx_clc_gear_rat_hys_2
				Cxx_clc_gear_rat_hys_n
				Cxx_clc_gear_rat_stab_1
				Cxx_clc_gear_rat_stab_2
				Cxx_clc_gear_rat_stab_dly
				Cxx_clos_thr_n_max
				Cxx_aj_fast_tq_dsb_n_thd
				Cxx_clos_thr_tia_min
				Cxx_aj_fast_tq_tco_thd
				Cxx_cart_dyn_iga_vs
				Cxx_cart_dyn_iga_tco_thd
				Cxx_aut_swi1_is_ofs
				Cxx_aut_swi_is_ofs
				Cxx_ar_flr_tmp_min
				Cxx_aod_dly_ini
				Cbx_max_iga_conf
				Cxx_decl_cut_n_ofs
				Cxx_clos_thr_n_min
				Ctp_pos_whl_spd
				Ctp_fzy_tkof_tqe_grd_fac
				Ctp_tco_agb_tq
				Ctp_tco_agb_neut_tq
				Ctp_tco_agb_neut_dly
				Ctp_tco_agb_dri_dly
				Ctp_tco_aftr_ti_fac
				Ctp_sta_tco_oil_temp_t
				Ctp_sta_tco_dly
				Ctp_tco_clos_thr_t
				Ctp_prs_fast_tq_max_lim
				Ctp_tco_cut_decl_off_dly
				Ctp_neg_whl_spd
				Ctp_n_min_gas_lim_tq
				Ctp_n_inj_cut_dly
				Ctp_n_drv_tkof_d
				Ctp_n_dif_tkof_p
				Ctp_n_aj_fast_tq_dif_thd
				Ctp_is_decl_clc_prs_fac
				Ctp_is_decl_clc_n_fac
				Ctp_prs_fast_tq_min_lim
				Ctp_toil_max_n
				Ctp_gear_decl6_aj_fil_fac
				Cxx_dft_lft_trt
				Cxx_dft_rgt_trt
				Ctp_vs_n_tkof_degr
				Ctp_vs_mvac_dp_dec
				Ctp_tqr_swi_fmt
				Ctp_tqr_swi
				Ctp_tqr_cut
				Ctp_tco_aut_thd
				Ctp_tqr_ct
				Cxx_abs_whl_spd_med_zon
				Ctp_toil_lim_tq
				Ctp_thpl_tco
				Ctp_tco_tkof_l_thd
				Cbx_kd_rich_cor_prs_conf
				Ctp_tco_tkof_degr_fac
				Ctp_tco_max_pow_thd
				Ctp_tco_max_n
				Ctp_tco_lim_tqi
				Ctp_tqr_ct_fmt
				Cmp_gear_cge_tq_min_ofs
				Cxx_h_dyn_efy_cor
				Ctb_fac_n_dif_drv
				Ctb_eng_tq
				Ctb_decl_n
				Cxx_inj_stop_n_ofs
				Cxx_gear_vs_thd
				Ctb_agb_toil
				Ctb_agb_sli_tq_eng_n
				Ctb_agb_sli
				Cxx_kd_decl_cut_n_ofs
				Cxx_iga_dec_tdc_nr
				Ctb_fzy_tkof_tqe_grd
				Cmp_eal_tco_cart_iga_cor
				Ctp_fzy_tkof_vs_n_rat_fac
				Cmp_n_eal_max_iga_ofs
				Cmp_n_gear_gear_cge_l_tq
				Cmp_n_gear_lim_tq
				Cmp_n_pdl_fac_frm_pdl
				Cmp_n_prs_aj_fast_tq_fac
				Cxx_is_dyn_iga_n_ofs
				Cxx_is_dyn_iga_fil_fac
				Cxx_is_acel_ac_dsb_dly
				Cxx_inv_ini_acq_dif
				Cxx_inv_dsb
				Cxx_inj_stop_tco_thd
				Cbx_fl_kd_thr_conf
				Cbx_mux_ct_conf
				Cxx_h_cge_n_thd
				Cxx_h_cge_n_dly
				Cxx_l_dyn_efy_cor
				Cxx_l_tco_inj_stop_n
				Cmp_decl_aj_fil_fac_form
				Cmp_acel_aj_fil_fac_form
				Cbx_wup_stop_ac
				Ctb_fzy_tkof_vs
				Cbx_trt_fil_dsb
				Cmp_agb_sli_tq
				Cbx_ol_cl_sp_conf
				Cbx_ovn_tq_cor_dsb
				Cbx_prs_trs_iga_cor_dsb
				Cbx_ptc_max_pow_ena_lim
				Cbx_raw_whl_angl_dsb
				Cbx_rgb_dyn_iga_cor_dsb
				Cxx_gear1_iga_dec_tdc_nr
				Cxx_gear1_iga_dec
				Cbx_wup_fil_tq_dsb
				Ntb_whl_spd
				Cxx_tqr_rtn_nr_tdc
				Cxx_mvac_pump_dft_max_run_t
				Cxx_swi_cor_stop_n_thd
				Cxx_t_dly_cge
				Cxx_min_ovn_cor_fac
				Cxx_tqr_nr_tdc
				Cxx_swi_is_ofs
				Cxx_swi_ena_drv_n_thd
				Cxx_t_dly_n_drv_puls
				Cxx_tqr_nr_tdc_gear1
				Cxx_stab_dyn_prs_up_thd
				Cxx_swi_ac_dsb_pow_thd
				Cxx_min_tqe_fil_fac
				Cxx_tqr_rtn_nr_tdc_gear1
				Cxx_max_dif_whl_angl
				Cxx_max_dyn_iga_tq
				Cxx_stop_tkof_fil_fac
				Cxx_stat_whl_thd
				Cxx_stat_whl_dly
				Cxx_stat_whl_acq_dif
				Cxx_stal_ac_dsb_n_thd
				Cxx_stal_ac_dsb_dly
				Cxx_swi_cor_n_thd
				Cxx_vs_n_rat_fil_fac_1
				Cxx_mvac_dp_chr_l_thd
				Cxx_map_cut_decl_dly
				Cxx_mvac_dp_chr_h_thd
				Cxx_whl_spd_rls
				Cxx_mux_pwst_prs_dly
				Cxx_whl_spd_nul
				Cxx_whl_spd_dsb
				Cxx_whl_mov_thd
				Cxx_tmp_cut_map_thd
				Cxx_tq_rat_fil_fac_ovn
				Cxx_tqe
				Cxx_vs_n_rat_fil_fac_3
				Cxx_tqr_max_gear1
				Cxx_vs_n_rat_fil_fac_2
				Cxx_min_tq_rat_ovn
				Cxx_tqr_clu_ac_ofs
				Cxx_thpl_off_dly
				Cxx_thpl_dsb_max_dly
				Cxx_vs_dsb
				Cxx_tqr_ct_thd_prs
				Cxx_temp_ac_dsb_tco_thd
				Cxx_temp_ac_dsb_prs_thd
				Cxx_tqr_max
				Cxx_temp_ac_dsb_n_thd
				Cxx_temp_ac_dsb_dly
				Cxx_min_tqe_tkof
				Cxx_stab_dyn_iga_fil_fac
				Cxx_thpl_tco_hys
				Cxx_ptc_min_pow_ena_min
				Cxx_tqr_swi_step_inc
				Cxx_trt_inv_dsb
				Cxx_ptc_cut_eng_inc
				Cxx_ptc_cut_n_n_l_thd
				Cxx_ptc_cut_n_n_up_thd
				Cxx_ptc_eal_n_l_thd
				Cxx_ptc_eal_n_up_thd
				Cxx_ptc_eal_pdl_l_thd
				Cxx_ptc_eal_pdl_up_thd
				Cxx_ptc_eal_vs_l_thd
				Cxx_ptc_eal_vs_up_thd
				Cxx_ptc_max_pow_ena_inc
				Cxx_stab_dyn_prs_l_thd
				Cxx_slop_ac_dsb_gear_thd
				Cxx_slop_ac_dsb_thr_thd
				Cxx_slop_ac_dsb_gear_hys
				Cxx_slop_ac_dsb_dly
				Cxx_ptc_tkof_gear_l_thd
				Cxx_ptc_tkof_gear_up_thd
				Cxx_ptc_tkof_n_l_thd
				Cxx_ptc_tkof_n_up_thd
				Cxx_ptc_tkof_pdl_up_thd
				Cxx_ptc_tkof_vs_l_thd
				Cxx_ptc_tkof_vs_up_thd
				Cxx_pump_mvac_dp_max_rat
				Cxx_pump_mvac_prs_fil_fac
				Cxx_run_vh_dsb_dly
				Cxx_slop_ac_dsb_n_hys1
				Cxx_max_n_ovn_ofs
				Cxx_stab_dyn_iga_n_thd
				Cxx_stab_dyn_dif_prs_thd
				Cxx_stab_aj_fast_tq_ofs
				Cxx_stab_aj_fast_tq_fac
				Cxx_sta_n_fil_fac
				Cxx_sta_iga_vld_ctr
				Cxx_sta_iga_dec_tdc_nr
				Cxx_sta_iga_dec
				Cxx_sta_dyn_iga_mv_n_fac
				Cxx_sta_ac_dsb_dly
				Cxx_med_zon_wid
				Cxx_med_zon_vh_vs_dsb
				Cxx_slop_ac_dsb_n_hys2
				Cxx_tqr_step_dec_gear1
				Cxx_slop_ac_dsb_n_thd
				Cxx_max_n_thd_oil_ovn
				Cxx_max_tq_ovn_cor
				Cxx_max_slop_thd_n_ovn
				Cxx_min_gas_inc
				Cxx_min_gas_dec
				Cxx_max_slop_tq_rat_ovn
				Cxx_min_dyn_iga_tq
				Cxx_min_dyn_gear_cge_ofs
				Cxx_tqr_swi_nr_tdc
				Cxx_tqr_swi_rtn_nr_tdc
				Cxx_slop_ac_dsb_vs_thd
				Cxx_slop_ac_dsb_vs_hys
				Cxx_mvac_dp_dec_brk_dft
				Cxx_tqr_step_dec
				Cxx_tkof_ac_dsb_vs_thd
				Cxx_zon_3_act_trt
				Cxx_n_ofs_is_iga_run_vh1
				Cxx_perf_ac_dsb_vs_thd
				Cxx_mvac_n_l_thd
				Cxx_tkof_fl_rich_fac
				Cxx_tkof_vs_thd
				Cxx_n_tkof_inrt_1
				Cxx_tkof_gear_thd
				Cxx_lim_zon_ref_dif_1
				Cxx_n_ofs_is_iga_run_vh
				Cxx_perf_ac_dsb_pow_thd
				Cxx_tkof_ena_vs_thd
				Cxx_perf_ac_dsb_n_thd
				Cxx_tkof_ac_dsb_vs_hys
				Cxx_tkof_ac_dsb_pow_thd
				Cxx_lim_zon_ref_dif_3
				Cxx_no_lim_zon_ref_dif_1
				Cxx_n_ofs_cart_iga_stop
				Cxx_n_ofs_cart_iga_run_vh
				Cxx_mvac_pump_dft_aftr_run_t
				Cxx_n_ofs_is_iga_stop_vh2
				Cxx_zon_3_dsb_trt
				Cxx_lim_zon
				Cxx_lim_zon_ref_dif_2
				Cxx_n_ovs_cor_fac
				Cxx_tkof_l_dyn_efy_cor
				Cxx_ol_ti_fac_dec
				Cxx_ol_ti_fac_inc
				Cxx_n_ofs_is_iga_stop_vh1
				Cxx_tkof_h_dyn_efy_cor
				Cxx_mvac_prs_dif_thd
				Cxx_mvac_prs_cnt_l_dp_thd
				Cxx_mvac_prs_cnt_h_dp_thd
				Cxx_tkof_n_dif_inrt_cge
				Cxx_n_ofs_is_iga_stop_vh3
				Cxx_perf_ac_dsb_vs_hys
				Cxx_mvac_pump_aftr_run_t
				Cxx_zon_3_act_trt_out
				Cxx_n_puls_fil_fac_ovn
				Cxx_n_tkof_fil_fac
				Cxx_n_tkof_inrt_0
				Cxx_tkof_fl_tia_thd
				Cxx_ovn_cor_dec
				Cxx_ovn_cor_inc
				Cxx_perf_ac_dsb_gear_thd
				Cxx_perf_ac_dsb_max_dly
				Cxx_perf_ac_dsb_n_hys
				Cxx_n_ofs_is_iga_stop_vh
				Cxx_n_ofs_swi_iga_stop
				Cxx_tkof_tqe_grd_fil_fac
				Cxx_mvac_dp_diag_dly
				Cxx_mvac_dp_dec_vs_dft
				Cxx_n_lim_is_dyn_iga_dly
				Cxx_tkof_ac_dsb_gear_thd
				Cxx_zon_3_dsb_trt_out
				Cxx_tkof_ac_dsb_dly
				Cxx_tkof_tq_vs_thd
				Cxx_tkof_tqe_fil_fac_1
				Cxx_tkof_tq_p_min
				Cxx_tkof_tqe_fil_fac_3
				Cxx_tkof_ac_dsb_h_thr_thd
				Cxx_mvac_pump_max_run_t
				Cxx_tkof_map_hys
				Cxx_tkof_n_l_thd
				Cxx_tkof_n_hys
				Cxx_tkof_n_h_thd
				Cxx_tkof_map_thd
				Cxx_tkof_vs_n_rat_thd
				Cxx_mvac_prs_fil_fac
				Cxx_tkof_mfld_mdl_fac
				Cxx_tkof_tqe_fil_fac_2
				Cxx_mvac_dp_h_thd
				Cxx_mvac_n_h_thd
				Cxx_no_lim_zon_ref_dif_2
				Cxx_no_lim_zon_ref_dif_3
				Cxx_mvac_dp_l_thd
				Cxx_mvac_dp_inc_dly
				Cxx_tkof_ac_dsb_n_thd
				Cxx_tkof_ac_dsb_l_thr_thd
				Cxx_mvac_dp_diag_sta_dly
				Cxx_tkof_ac_dsb_n_hys
				Cxx_tkof_tq_d_min
				Cxx_tkof_tq_p_max
				Cxx_n_drv_puls_thd
				Cxx_tkof_tq_d_max
				Cbx_dyn_iga_cor_conf
				Cbx_clos_thr_dsb
				Cbx_dyn_tq_tqr_conf
				Cbx_aj_dsb_conf
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION M_Rvlv
			""
			/begin DEF_CHARACTERISTIC
				Ctb_eng_tq
				Cmp_n_pdl_fac_frm_pdl
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION M_OBD
			""
			/begin DEF_CHARACTERISTIC
				Cbx_mena_mis_cata_2_lpg
				Cbx_mena_min_gas_lvl
				Cbx_mena_mis_cata
				Cbx_mena_mis_cata_1
				Cbx_mena_map
				Cbx_mena_mis_cata_2
				Ctb_n_tlz_ad_b
				Cbx_mena_mis_cata_3
				Cbx_mena_mis_cata_3_lpg
				Cbx_mena_mis_cata_4
				Cbx_mena_mis_cata_4_lpg
				Cbx_mena_mis_cata_gas
				Cbx_mena_mis_cata_lpg
				Cbx_mena_mis_cata_1_lpg
				Cbx_mena_lbup
				Cbx_mena_lpg
				Cbx_mena_lbdw
				Cbx_mena_lbup_hot
				Cbx_mena_inj3
				Cbx_mena_inj2
				Cbx_mena_lbdw_hot
				Cbx_mena_inj4
				Cbx_mena_knk
				Cbx_mena_mis_polu
				Ctb_mis_tlz_cor_eal_lpg
				Cbx_mena_obd_sa
				Ctb_mis_tlz_cor_n
				Ctb_mis_tlz_cor_n_lpg
				Cbx_mena_lpg_rcpt
				Cbx_mena_vs
				Cbx_mena_obd_cata
				Cbx_mena_sa_ev
				Cbx_mena_spg
				Cbx_mena_spg_sys
				Cbx_mena_tco
				Cbx_mena_rams_pdl
				Cbx_mena_tlz_ad_b
				Cbx_mena_pow_lbup
				Cbx_mena_vta_intake
				Cbx_mena_vvt_int_ev
				Cbx_mena_vvt_int_old_off
				Cbx_mena_vvt_intake
				Cbx_mena_vvtc_toth_3
				Cbx_mena_wgc
				Cbx_mena_tia
				Cbx_mena_mis_polu_4_lpg
				Cbx_mena_mis_polu_1_lpg
				Cbx_mena_mis_polu_2
				Cbx_mena_mis_polu_2_lpg
				Cbx_mis_lih_conf
				Cbx_mena_mis_polu_3
				Cbx_mena_sa
				Cbx_mena_mis_polu_4
				Cbx_mena_mis_polu_1
				Cbx_mena_mis_polu_gas
				Cbx_mena_mis_polu_lpg
				Ctb_mis_tlz_cor_eal
				Cbx_mena_obd_lamb
				Cbx_mena_flsh_mis_cata_lpg
				Cbx_mena_pow_lbdw
				Cbx_mena_mis_polu_3_lpg
				Cmp_mis_tq_dif_fac_intm_1
				Cbx_mena_fsys_lpg
				Cmp_mis_tlz_cor_cyl_1
				Cmp_mis_tlz_cor_cyl_1_lpg
				Cmp_mis_tlz_cor_cyl_2
				Cmp_mis_tlz_cor_cyl_2_lpg
				Cmp_mis_tq_dif_1_2_dz_1
				Cbx_mux_conf_mil
				Cmp_mis_tq_dif_1_4_dz_1
				Cmp_mis_tq_dif_fac_1_2
				Cmp_mis_tq_dif_fac_1_2_1
				Cmp_mis_tq_dif_fac_1_2_dz
				Cmp_mis_tq_dif_fac_1_4
				Cmp_mis_tq_dif_fac_1_4_1
				Ctb_amp_0_amp_rat_alti
				Cmp_det_thd_tlz_dif_agb
				Cbx_tlz_ad_cor_conf
				Cbx_conf_schd_diag_cata
				Cbx_conf_schd_diag_fsys
				Cbx_conf_schd_diag_lamb
				Cbx_conf_schd_diag_mis
				Cmp_mis_tq_dif_fac_1_4_dz
				Cmp_det_thd_tlz_dif
				Cmp_mis_tq_dif_fac_intm
				Cmp_det_thd_tlz_dif_lpg
				Cbx_act_oten
				Cbx_act_edic
				Cmp_mis_tq_dif_intm_dz_1
				Cmp_mis_tq_dif_intm_dz
				Cmp_mis_tlz_cor_cyl_0
				Cbx_conf_schd_diag_sa
				Cbx_mena_crk
				Cbx_mena_inj1
				Cbx_mena_inj_ecu
				Cbx_mena_igc_4
				Cbx_mena_igc_3
				Cbx_mena_igc_2
				Cbx_mena_igc_1
				Ctb_lbup_prs_min
				Ctb_lamb_diag_n
				Cbx_mena_gas_pump
				Cbx_mena_fsys
				Cbx_mena_flsh_mis_cata
				Cbx_mena_eng_whl
				Cmp_mis_tlz_cor_cyl_0_lpg
				Cbx_mena_crk_nr
				Ctb_dft_comb_n2_lpg
				Cmp_mis_iga_dif
				Cmp_mis_cata_degr_1
				Cmp_mis_cata_degr
				Ctb_dft_comb_eal
				Ctb_dft_comb_eal2
				Ctb_dft_comb_eal2_lpg
				Ctb_dft_comb_n2
				Ctb_mis_n_17
				Cbx_mena_agb
				Cbx_mena_agb_rcpt
				Cbx_mena_air
				Cbx_mena_bkup_mem
				Cbx_mena_clu
				Cbx_mena_cp
				Cxx_vfnrofm_igc_1
				Cxx_vfnrofm_mis_cata_3
				Cxx_vfnrofm_igc_2
				Cxx_vfnrofm_lbdw
				Cxx_vfnrofm_mis_cata_2
				Cxx_cata_maf_mes_max
				Cxx_vfnrofm_mis_cata_1_lpg
				Cxx_vfnrofm_mis_cata_1
				Cxx_vfnrofm_mis_cata
				Cxx_vfnrofm_min_gas_lvl
				Cxx_cata_maf_max
				Cxx_vfnrofm_map
				Cxx_vfnrofm_lpg_rcpt
				Cxx_vfnrofm_lbdw_hot
				Cxx_vfnrofm_lbup
				Cxx_vfnrofm_igc_3
				Cxx_vfnrofm_knk
				Cxx_vfnrofm_mis_cata_2_lpg
				Cxx_cata_maf_min
				Cxx_vfnrofm_inj4
				Cxx_vfnrofm_inj3
				Cxx_vfnrofm_inj2
				Cxx_vfnrofm_inj1
				Cxx_vfnrofm_inj_ecu
				Cxx_vfnrofm_igc_4
				Cxx_vfnrofm_lbup_hot
				Cxx_vfnronm_eng_whl
				Cxx_vfnronm_inj_ecu
				Cxx_vfnronm_igc_4
				Cxx_vfnronm_igc_3
				Cxx_vfnronm_igc_2
				Cxx_vfnronm_igc_1
				Cxx_vfnronm_gas_pump
				Cxx_vfnrofm_wgc
				Cxx_vfnronm_fsys
				Cxx_vfnronm_inj3
				Cxx_vfnronm_crk_nr
				Cxx_vfnronm_crk
				Cxx_vfnronm_cp
				Cxx_vfnronm_clu
				Cxx_vfnronm_bkup_mem
				Cxx_vfnronm_air
				Cxx_vfnrofm_mis_polu_4
				Cxx_vfnronm_fsys_lpg
				Cxx_vfnronm_inj4
				Cxx_cata_asd_diag_nr
				Cxx_cata_asd_cl_stab_dly
				Cxx_cata_asd_in_nr
				Cxx_cata_asd_maf_dif_max
				Cxx_cata_asd_maf_max
				Cxx_cata_asd_maf_mes_max
				Cxx_cata_asd_maf_min
				Cxx_vfnronm_inj1
				Cxx_cata_asd_n_min
				Cxx_vfnronm_inj2
				Ctp_min_eal_off
				Cxx_cata_asd_sf_nr
				Cxx_vfnrofm_gas_pump
				Cxx_cata_asd_tco_min
				Cxx_cata_cl_stab_dly_min
				Cxx_cata_hys_maf
				Cxx_vfnrofm_vvtc_toth_3
				Cxx_cata_asd_n_max
				Cxx_vfnrofm_mis_polu_1_lpg
				Cxx_vfnrofm_obd_cata
				Cxx_vfnrofm_mis_polu_lpg
				Cxx_vfnrofm_mis_polu_gas
				Cxx_vfnrofm_mis_polu_4_lpg
				Cxx_vfnrofm_mis_polu_3_lpg
				Cxx_vfnrofm_mis_polu_3
				Cxx_vfnronm_agb_rcpt
				Cxx_vfnrofm_mis_polu_2
				Cxx_vfnrofm_pow_lbdw
				Cxx_vfnrofm_mis_polu_1
				Cxx_vfnrofm_mis_polu
				Cxx_vfnrofm_mis_cata_lpg
				Cxx_vfnrofm_mis_cata_gas
				Cxx_cata_maf_dif_max
				Cxx_vfnrofm_mis_cata_4_lpg
				Cxx_vfnrofm_mis_cata_4
				Cxx_vfnrofm_mis_polu_2_lpg
				Cxx_cata_in_nr
				Cxx_vfnrofm_vvt_intake
				Cxx_vfnrofm_vvt_int_old_off
				Cxx_vfnrofm_vvt_int_ev
				Cxx_vfnrofm_vta_intake
				Cxx_vfnrofm_vs
				Cxx_vfnrofm_tlz_ad_b
				Cxx_vfnrofm_tia
				Cxx_vfnrofm_obd_lamb
				Cxx_vfnrofm_tco
				Cxx_vfnrofm_obd_sa
				Cxx_vfnrofm_spg_sys
				Cxx_vfnrofm_spg
				Cxx_vfnrofm_sa_ev
				Cxx_vfnrofm_sa
				Cxx_vfnrofm_rams_pdl
				Cxx_vfnrofm_pow_lbup
				Cxx_vfnrofm_mis_cata_3_lpg
				Cxx_cata_hys_n
				Cxx_stop_oten_rec
				Cxx_tlz_b_ini
				Ctp_lbup_ofs_degr_min
				Ctp_lbup_per_max
				Cxx_tlz_ad_b_n_min_3
				Cxx_tlz_ad_b_n_min_4
				Cxx_tlz_ad_b_n_min_5
				Cxx_tlz_ad_b_n_min_6
				Cxx_tlz_ad_b_nr_tdc
				Cxx_tlz_ad_b_slow_nr_tdc
				Cxx_tlz_ad_b1_fil_ini
				Cxx_tlz_ad_b_n_min_2
				Cxx_tlz_ad_cor_fil_fac
				Cxx_tlz_ad_b_n_min_1
				Ctp_min_eal
				Ctp_min_eal_1_2
				Cxx_vfnrw_mis_cata_3_lpg
				Cxx_tlz_ad_cor_fil_ini
				Cxx_cata_n_max
				Ctp_mis_stop_is_iga_dif
				Cxx_tlz_ad_cor_n_max
				Cxx_tlz_ad_cor_n_min
				Cxx_tlz_ad_cor_nr_tdc
				Cxx_stop_edic_rec
				Cxx_tlz_ad_b2_fil_ini
				Cxx_tlz_ad_b_n_max_2
				Ctd_mis_n_max_thd_1_2
				Ctd_tlz_ad_b_ena
				Ctp_amp_0_amp_rat
				Ctp_cata_lbdw_max_maf
				Ctp_cata_ol_per_dly_maf
				Cxx_thr_pos_sc_asd
				Cxx_tlz_a
				Cxx_tlz_ad_b_fil_fac
				Cxx_tlz_ad_b_max
				Cxx_tlz_ad_b_min
				Ctp_lbup_ofs_degr_max
				Cxx_tlz_ad_b_n_max_1
				Cxx_tlz_cor_n_max
				Ctp_ex_gaz_prs_n_temp
				Ctp_ex_gaz_temp_ofs_maf
				Ctp_ex_gaz_temp_ofs_maf_l
				Ctp_ex_gaz_temp_ofs_vs
				Cxx_tlz_ad_b_n_max_3
				Cxx_tlz_ad_b_n_max_4
				Cxx_tco_wup_thd
				Cxx_tlz_ad_b_n_max_5
				Cxx_tlz_ad_b_n_max_6
				Cxx_tlz_ad_b_n_min
				Cxx_tlz_ad_b_n_max
				Cxx_trz_n_max
				Cxx_tlz_ad_cor_val_ini
				Ctp_tlz_fil_rst_eal_dif
				Cxx_trz_a
				Cxx_trz_ad_b_fil_fac
				Cxx_trz_ad_b_grd_prs
				Cxx_trz_ad_b_nr_tdc
				Cxx_trz_ad_b1_fil_ini
				Cxx_trz_ad_b1_val_ini
				Cxx_trz_ad_b2_fil_ini
				Cxx_trz_ad_b2_val_ini
				Ctp_tlz_fil_fac
				Cxx_trz_cor_n_max
				Ctp_tlz_ad_b_grd_prs
				Cxx_trz_n_min
				Cxx_vfnrofm_agb_rcpt
				Cxx_vfnrofm_air
				Cxx_vfnrofm_bkup_mem
				Cxx_vfnrofm_clu
				Cxx_vfnrofm_cp
				Cxx_vfnrofm_crk
				Cxx_vfnrofm_crk_nr
				Cxx_vfnrofm_eng_whl
				Cxx_vfnrofm_fsys
				Cxx_trz_b_ini
				Cxx_sa_map_min
				Cxx_tlz_fil_rat
				Cxx_tlz_fil_rat_lpg
				Cxx_tlz_fil_rst_n_dif_thd
				Cxx_tlz_n_max
				Cxx_tlz_n_min
				Cxx_sa_vb_min
				Cxx_sa_tco_min
				Cxx_sa_stop_diag_lbdw_thd
				Cxx_sa_n_min
				Cxx_sa_n_max
				Ctp_tlz_fil_fac_lpg
				Cxx_sa_mes_dly
				Cxx_vfnrofm_fsys_lpg
				Cxx_sa_map_max
				Cxx_sa_map_fac
				Cxx_sa_map_dif_max
				Cxx_sa_maf_min
				Cxx_sa_maf_max
				Cxx_sa_lbdw_dif_thd
				Cxx_sa_eol_tco_min
				Cxx_sa_diag_lbdw_thd
				Cxx_sa_dec_nr
				Cxx_rich_lean_trs_dly
				Cxx_sa_n_dif_max
				Cxx_mis_lih_re_phs_nr
				Cxx_mis_polu_win_tdc_nr
				Cxx_mis_polu_win_nr_fail
				Cxx_mis_polu_win_mis_nr_1
				Cxx_mis_polu_win_mis_nr
				Cxx_mis_ofs_eal_agb_ena
				Cxx_mis_n_max_thd_1_n
				Cxx_fsys_cor_fac_eol_min
				Cxx_mis_lih_tdc_nr
				Cxx_mux_thr_n_mil_test
				Cxx_vfnrw_mis_cata_3
				Cxx_vfnrw_mis_cata_2
				Cxx_mis_lih_out_mis_nr
				Cxx_mis_lih_n_min
				Cxx_mis_lih_mis_nr
				Cxx_vfnrw_igc_4
				Cxx_mis_n_max_agb_clos_no
				Cxx_edic_dly
				Cxx_obd_conf_mod_1_3
				Cxx_obd_conf_mod_1_2
				Cxx_obd_conf_mod_1_1
				Cxx_obd_conf_lamb
				Cxx_obd_conf_diag_schd
				Cxx_obd_conf_diag_prmt
				Cxx_mis_stab_tdc_nr
				Cxx_no_min_gas_lvl_dly
				Cxx_mux_test_mil_dly
				Cxx_edic_prmt_trg_dly
				Cxx_edic_schd_trg_dly
				Cxx_eol_lbdw_oc_air_wht
				Cxx_ex_gaz_cata_max_temp
				Cxx_ex_gaz_cata_min_temp
				Cxx_ex_gaz_fil_fac_inj
				Cxx_vfnrw_mis_cata_1_lpg
				Cxx_no_min_lpg_lvl_dly
				Cxx_mis_fast_win_tdc_nr
				Cxx_fsys_thd_2_dly
				Cxx_fsys_thd_2_eol_dly
				Cxx_mis_lih_chk_dsb_conf
				Cxx_mis_km_dly
				Cxx_vfnrw_lbdw_hot
				Cxx_vfnrw_lbdw
				Cxx_fsys_cor_fac_eol_max
				Cxx_vfnrw_inj4
				Cxx_vfnrw_lbup_hot
				Cxx_mis_fast_win_mis_nr
				Cxx_mis_ena_tco_min_thd
				Cxx_vfnrw_inj3
				Cxx_vfnrw_inj2
				Cxx_vfnrw_inj1
				Cxx_vfnrw_inj_ecu
				Cxx_vfnrw_knk
				Cxx_fsys_cor_fac_min_2
				Cxx_vfnrw_mis_cata_1
				Cxx_vfnrw_mis_cata
				Cxx_vfnrw_min_gas_lvl
				Cxx_vfnrw_map
				Cxx_vfnrw_lpg_rcpt
				Cxx_fsys_cor_fac_max_1
				Cxx_fsys_n_min_thd
				Cxx_fsys_cor_fac_min_1
				Cxx_vfnrw_lbup
				Cxx_fsys_dly_1
				Cxx_fsys_dly_2
				Cxx_fsys_eal_max_thd
				Cxx_fsys_eal_min_thd
				Cxx_fsys_eol_dly
				Cxx_fsys_n_max_thd
				Cxx_obd_conf_mod_1_6
				Cxx_fsys_cor_fac_max_2
				Cxx_diag_fil_ti_ofs2_fac1
				Cxx_down_eol_diag_hot_t
				Cxx_down_diag_oc_hot_t
				Cxx_oten_schd_trg_dly
				Cxx_diag_trs_l_thd_lpg
				Cxx_diag_trs_l_thd
				Cxx_diag_trs_h_thd_lpg
				Cxx_obd_conf_mod_1_4
				Cxx_diag_fil_ti_ofs2_fac2
				Cxx_obd_min_tia
				Cxx_cata_n_min
				Cxx_det_wup_tco_ofs
				Cxx_vfnrw_wgc
				Cxx_vfnrw_vvtc_toth_3
				Cxx_vfnrw_vvt_intake
				Cxx_vfnrw_vvt_int_old_off
				Cxx_diag_trs_h_thd
				Cxx_obd_conf_mod_9_3
				Cxx_obd_conf_mod_2_3
				Cxx_obd_conf_mod_2_4
				Cxx_obd_conf_mod_6_1
				Cxx_obd_conf_mod_6_2
				Cxx_obd_conf_mod_6_3
				Cxx_obd_conf_mod_6_4
				Cxx_down_eol_oc_det_v
				Cxx_obd_conf_mod_9_2
				Cxx_oten_prmt_trg_dly
				Cxx_obd_conf_mod_9_4
				Cxx_obd_conf_obd
				Cxx_obd_max_alti
				Cxx_obd_max_tco
				Cxx_obd_max_tia
				Cxx_obd_min_tco
				Cxx_vfnrw_vs
				Cxx_obd_conf_mod_9_1
				Cxx_vfnrw_mis_cata_gas
				Cxx_vfnrw_vvt_int_ev
				Cxx_vfnrw_mis_polu_3
				Cxx_vfnrw_mis_polu_2_lpg
				Cxx_vfnrw_mis_polu_2
				Cxx_vfnrw_mis_polu_1_lpg
				Cxx_vfnrw_mis_polu_1
				Cxx_vfnrw_mis_polu_4
				Cxx_vfnrw_mis_cata_lpg
				Cxx_vfnrw_mis_polu_4_lpg
				Cxx_vfnrw_mis_cata_4_lpg
				Cxx_vfnrw_mis_cata_4
				Cxx_obd_conf_mod_2_2
				Cxx_obd_conf_mod_2_1
				Cxx_obd_conf_mod_1_8
				Cxx_obd_conf_mod_1_7
				Cxx_vfnrw_mis_cata_2_lpg
				Cxx_vfnrw_mis_polu
				Cxx_vfnrw_rams_pdl
				Cxx_obd_conf_mod_1_5
				Cxx_vfnrw_tlz_ad_b
				Cxx_vfnrw_tia
				Cxx_vfnrw_tco
				Cxx_vfnrw_spg_sys
				Cxx_vfnrw_spg
				Cxx_vfnrw_mis_polu_3_lpg
				Cxx_vfnrw_sa
				Cxx_vfnrw_vta_intake
				Cxx_vfnrw_pow_lbup
				Cxx_vfnrw_pow_lbdw
				Cxx_vfnrw_obd_sa
				Cxx_vfnrw_obd_lamb
				Cxx_vfnrw_obd_cata
				Cxx_vfnrw_mis_polu_lpg
				Cxx_vfnrw_mis_polu_gas
				Cxx_vfnrw_sa_ev
				Cxx_lbup_asd_n_min
				Cxx_vfnronm_mis_cata
				Cxx_cl_ti_obd_fil_fac
				Cxx_vfnronm_min_gas_lvl
				Cxx_vfnronm_map
				Cxx_vfnronm_lpg_rcpt
				Cxx_lbup_asd_in_nr
				Cxx_lbup_tco_min
				Cxx_lbup_asd_n_max
				Cxx_cl2_ena_ctr
				Cxx_lbup_asd_per_dly
				Cxx_lbup_asd_prs_min
				Cxx_lbup_asd_sf_nr
				Cxx_lbup_asd_tco_min
				Cxx_lgl_dly_asd_diag_lbup
				Cxx_lgl_dly_asd_diag_cata
				Cxx_vfnronm_mis_polu_2
				Cxx_vfnronm_lbup_hot
				Cxx_vfnronm_mis_cata_3_lpg
				Cxx_vfnronm_mis_polu_1_lpg
				Cxx_vfnronm_mis_polu_1
				Cxx_vfnronm_mis_polu
				Cxx_lbdw_oc_air_wht
				Cxx_lbdw_pump_crt_dly
				Cxx_vfnronm_mis_cata_lpg
				Cxx_vfnronm_mis_cata_gas
				Cxx_vfnronm_mis_cata_1
				Cxx_vfnronm_mis_cata_4
				Cxx_lbup_asd_diag_nr
				Cxx_mis_ena_n_min_thd
				Cxx_vfnronm_mis_cata_2_lpg
				Cxx_lbup_n_max
				Cxx_lgl_dly_diag_cata
				Cxx_vfnronm_mis_cata_2
				Cxx_vfnronm_mis_cata_1_lpg
				Cxx_lbup_stab_dly
				Cxx_vfnronm_mis_cata_4_lpg
				Cxx_cata_ol_per_dly_mes
				Cxx_cata_win_min
				Cxx_cata_win_max
				Cxx_cata_tco_min
				Cxx_cata_tb_ofs
				Cxx_cata_tb_fac
				Cxx_cata_ol_thd_lbdw_fil
				Cxx_lean_rich_trs_dly
				Cxx_cata_ol_per_dly_stab
				Cxx_vfnronm_lbdw_hot
				Cxx_cata_ol_per_dly
				Cxx_cata_ol_apl
				Cxx_cata_ofs_pos_2
				Cxx_cata_ofs_pos_1
				Cxx_cata_ofs_ol_lbdw_fil
				Cxx_cata_ofs_neg_2
				Cxx_cata_ofs_neg_1
				Cxx_cata_ol_test_max_nr
				Cxx_lbup_in_nr
				Cxx_lbup_pump_crt_dly
				Cxx_lbup_prs_max
				Cxx_lbup_per_swi_nr
				Cxx_lbup_per_nr_tot
				Cxx_lbup_per_nr_min
				Cxx_lbup_per_dly
				Cxx_lbup_hot_stt_t
				Cxx_vfnronm_knk
				Cxx_lbup_hys_prs
				Cxx_vfnronm_lbdw
				Cxx_lbup_maf_dif_max
				Cxx_lbup_maf_mes_max
				Cxx_lbup_ofs_stab_dly
				Cxx_lbup_n_min
				Cxx_cata_wup_sta_obd_eol
				Cxx_vfnronm_lbup
				Cxx_vfnronm_mis_cata_3
				Cxx_lbup_hys_n
				Cxx_vfnrw_fsys_lpg
				Cxx_vfnronm_spg
				Cxx_vfnronm_sa_ev
				Cxx_vfnronm_sa
				Cxx_vfnronm_rams_pdl
				Cxx_min_diag_ti_ofs2
				Cxx_vfnronm_pow_lbup
				Cxx_mis_cata_win_mis_nr_1
				Cxx_vfnronm_pow_lbdw
				Cxx_mis_cata_win_tdc_nr
				Cxx_max_diag_ti_ofs1
				Cxx_vfnrw_fsys
				Cxx_vfnronm_tia
				Cxx_vfnronm_obd_lamb
				Cxx_min_diag_mis_eol_dly
				Cxx_min_diag_mis_dly
				Cxx_min_diag_fsys_eol_dly
				Cxx_min_diag_fsys_dly
				Cxx_max_imd_ti_ad_ofs
				Cxx_vfnronm_wgc
				Cxx_max_eng_eal
				Cxx_min_gas_lvl_dly
				Cxx_vfnronm_obd_sa
				Cxx_vfnrw_cp
				Cxx_vfnronm_vvtc_toth_3
				Cxx_vfnrw_agb_rcpt
				Cxx_vfnronm_vvt_intake
				Cxx_vfnrw_air
				Cxx_vfnrw_bkup_mem
				Cxx_vfnronm_vvt_int_old_off
				Cxx_vfnronm_vvt_int_ev
				Cxx_vfnronm_vta_intake
				Cxx_vfnrw_clu
				Cxx_vfnronm_spg_sys
				Cxx_min_lpg_lvl_dly
				Cxx_vfnronm_tco
				Cxx_min_imd_ti_ad_ofs
				Cxx_min_imd_ti_ad_fac
				Cxx_vfnrw_crk
				Cxx_mis_cata_win_mis_nr
				Cxx_vfnrw_crk_nr
				Cxx_lgl_dly_diag_lbup
				Cxx_vfnrw_eng_whl
				Cxx_vfnronm_mis_polu_2_lpg
				Cxx_vfnronm_tlz_ad_b
				Cxx_vfnronm_obd_cata
				Cxx_vfnronm_vs
				Cxx_lbdw_h_lvl_fil_fac
				Cxx_max_imd_ti_ad_fac
				Cxx_map_fil_fac
				Cxx_vfnronm_mis_polu_gas
				Cxx_vfnronm_mis_polu_4_lpg
				Cxx_vfnronm_mis_polu_4
				Cxx_vfnronm_mis_polu_3_lpg
				Cxx_lbdw_cata_fil_fac
				Cxx_maf_clc_fac
				Cxx_lbdw_hot_stt_t
				Cxx_vfnronm_mis_polu_3
				Cxx_mis_ena_n_max_thd
				Cxx_vfnronm_mis_polu_lpg
				Cxx_vfnrw_igc_2
				Cxx_maf_clc_off_n_max
				Cxx_maf_clc_fil_fac
				Cxx_vfnrw_igc_3
				Cxx_vfnrw_igc_1
				Cxx_vfnrw_gas_pump
				Cxx_mis_cyl_fail_rat
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION M_MAP
			""
			/begin DEF_CHARACTERISTIC
				Cmp_n_prs_vvt
				Ctb_thr_ar
				Ctb_thr_psn
				Ctb_tia_17
				Ctb_tkof_vs_n_rat
				Ctb_toil
				Ctb_toil2
				Cmp_n_toil
				Cmp_n_prs_tco_ti_fac2
				Cmp_n_prs_lean_ti_cor
				Ctb_tq
				Ctb_tq_rat_sp
				Ctb_tco_thd
				Ctb_rel_tq_wup
				Ctb_vs
				Ctb_rel_pdl_psn
				Ctb_n2
				Ctb_n3
				Ctb_n4
				Ctb_n5
				Ctb_n6
				Ctb_n7
				Ctb_pred_map_max_prs_rat
				Ctb_prs_dif
				Ctb_prs_rat
				Ctb_spg_ar_maf_fac
				Ctb_pump_maf
				Ctb_tco_dif
				Cmp_n_map_fl_rich_sp
				Ctb_rich_sp9
				Ctb_vs_mvac_dp
				Ctb_spg_n
				Ctb_spg_ol_map_sp
				Ctb_spg_tq_rat
				Ctb_tco
				Ctb_tco_cl_off
				Ctb_tco_cut
				Ctb_ptc_pow
				Cmp_n_eal_vvtc_iga
				Cmp_n_map_ol_rich_sp_lpg
				Cmp_n_eal_fl_thd_lpg
				Cmp_n_eal_lpg_cor_iga
				Cmp_n_eal_max_iga_ofs
				Cmp_n_eal_otl_tqi_fac
				Ctb_n1
				Cmp_n_eal_otl_tqi_fac_lpg
				Cmp_n_eal_fl_rich_sp_lpg
				Cmp_n_eal_tia_fil_fac
				Ctd_gear_cart_dyn_n_thd
				Cmp_n_eal_vvtc_off_iga
				Cmp_n_eal_vvtc_on_iga
				Cmp_n_gear_gear_cge_l_tq
				Cmp_n_gear_lim_tq
				Cmp_n_map_bch_appl_iga
				Cmp_n_map_fill_efv
				Ctd_gear_dyn_iga_fil
				Ctd_gear_max_n
				Pgcban
				Cmp_n_map_ol_rich_sp
				Ctb_vvt_n1
				Cmp_n_prs_knk_cyl23_fac
				Ctb_vvt_n2
				Ctb_wet_cor_map
				Cmp_n_prs_knk_cyl14_fac
				Cmp_n_prs_fl_thd
				Cmp_n_prs_eai_ti_cor
				Cmp_n_eal_fl_thd
				Ctb_wet_n
				Ctb_vvt_n
				Cmp_n_map_fill_efv_vvt
				Cmp_n_map_fill_efv_lpg
				Ctb_wet_tdc_rat_ctr
				Ctd_fil_tq_ovn
				Cmp_min_iga
				Cmp_n_eal_fl_rich_sp
				Ctd_gear
				Ctd_gear_aj_fast_tq_fac
				Cmp_n_prs_aj_fast_tq_fac
				Cmp_wet_eal_vol_fac_tco40
				Cmp_n_tq_cart_iga_cor1
				Cmp_n_tq_cart_h_iga_cor
				Cmp_wet_eal_fil_fac_tco00
				Cmp_wet_eal_fil_fac_tco20
				Cmp_wet_eal_fil_fac_tco40
				Cmp_wet_eal_fil_fac_tco60
				Cmp_wet_eal_fil_fac_tco80
				Cmp_wet_prs_vol_fac_tco00
				Cmp_wet_eal_vol_fac_tco20
				Cmp_iga_tq_min_lpg
				Cmp_wet_eal_vol_fac_tco60
				Cmp_wet_eal_vol_fac_tco80
				Cmp_wet_prs_fil_fac_tco00
				Cmp_wet_prs_fil_fac_tco20
				Cmp_wet_prs_fil_fac_tco40
				Cmp_wet_prs_fil_fac_tco60
				Lmbavama
				Cmp_wet_eal_vol_fac_tco00
				Cmp_spg_ol_pwm_thr_n
				Cmp_n_tq_lpg_wup_iga_cor
				Cmp_n_tq_lpg_wup_iga_cor1
				Cmp_n_tq_vvtc_hot_in_angl
				Cmp_otl_iga_tco_cor
				Cmp_pdl_n_driv_abv_tqe
				Cmp_vvt_fill_efv_cor_fac2
				Cmp_vvt_fill_efv_cor_fac1
				Cmp_n_tq_cart_l_iga_cor
				Cmp_thr_ar_n_grd
				Cbx_knk_ad_dsb
				Cmp_prs_dif_ti_cor
				Cmp_prs_n_lamb_v
				Cmp_prs_n_lamb_v_lpg
				Cmp_prs_n_lean_cylr
				Cmp_prs_n_pwm_cp
				Cmp_prs_n_rich_cylr
				Cmp_spg_ol_pwm
				Cmp_wet_prs_vol_fac_tco20
				Cmp_tia_iga_cor
				Ctb_n
				Ctb_is_cata_wup_ctr
				Ctb_is_cor_alt_pow
				Ctb_is_cor_n
				Ctb_lpg_ad_zon_prs
				Ctb_lpg_temp_09
				Ctb_lpg_typ
				Ctb_map
				Cmp_wet_prs_fil_fac_tco80
				Ctb_map_ol
				Ctb_fzy_tkof_tqe_grd
				Ctb_n_aj
				Ctb_n_dif
				Ctb_n_drv
				Ctb_n_eai
				Ctb_n_gear_cge
				Ctb_n_knk
				Ctb_n_ol
				Ctb_map_fl
				Ctb_decl_n
				Cmp_wet_prs_vol_fac_tco40
				Cmp_wet_prs_vol_fac_tco60
				Cmp_wet_prs_vol_fac_tco80
				Lmbavaba
				Ctb_agb_sli
				Ctb_agb_sli_tq_eng_n
				Ctb_agb_toil
				Ctb_iga_cata_wup_ctr
				Ctb_csm_agb_tq
				Ctb_fzy_tkof_vs
				Ctb_eal_eai
				Ctb_eal_fl
				Ctb_eal1
				Ctb_eal2
				Ctb_eal3
				Ctb_eng_alti
				Ctb_fac_n_dif_drv
				Ctb_n_wup
				Ctb_cp_ad_fil
				Cbx_inv_dyn_cor_vvt_dsb
				Cbx_thr_ar_h_lim_dsb
				Cbx_agb_dyn_iga_conf
				Cbx_agb_is_n_req
				Cbx_agb_mdf2_conf
				Cbx_agb_min_tqe_dsb
				Cbx_aj_dsb_conf
				Cbx_alt_tq_conf
				Cbx_fl_kd_thr_conf
				Cbx_knk_out_tq_cor
				Cbx_kd_rich_cor_prs_conf
				Cbx_actr_spg_dsb
				Cbx_is_ad_mdf_conf
				Cbx_rich_dstb_iga_cor
				Cbx_eng_tq_loss_ad_dsb
				Cbx_ena_appl_thr_adj
				Cbx_dyn_tq_tqr_conf
				Cbx_dyn_iga_cor_conf
				Cbx_driv_tq_req_dsb
				Cbx_ctl_mux_dyn_iga_conf
				Cbx_bch_rst_thr_adj
				Cbx_bch_tco_toil
				Cbx_bch_tco_toil_2
				Cbx_spg_tq_off_mod
				Cbx_thr_ar_cor_dsb
				Cbx_is_alt_conf
				Cbx_ol_cl_sp_conf
				Cbx_min_ti
				Cbx_min_lvl_pump_cut_ena
				Cbx_mdl_thr_conf
				Cbx_mdl_cp_load_dsb
				Cbx_max_iga_conf
				Cbx_lpg_sta_ena
				Cbx_lpg_prs_diag_ena
				Cbx_lpg_min_lvl_lih_ena
				Cbx_is_min_ad_pwm_set
				Cbx_lpg_gas_pump_cut_ena
				Cbx_ad_tq_agb_conf
				Avbanc
				Cbx_lpg_aper_pump_run_ena
				Cbx_on_ac_cor_dsb
				Cbx_on_mdf_cor_dsb
				Cbx_on_ptc_cor_dsb
				Cbx_on_pwst_cor_dsb
				Cbx_on_tia_fail_cor_dsb
				Cbx_ovn_tq_cor_dsb
				Cbx_prs_sp_dsb
				Cbx_prs_trs_iga_cor_dsb
				Cbx_ptc_max_pow_ena_lim
				Cbx_raw_whl_angl_dsb
				Cbx_rgb_dyn_iga_cor_dsb
				Cmp_iga_tq_min
				Cmp_eal_n_min_iga_cor_lpg
				Cbx_thr_ar_l_lim_dsb
				Cmp_gear_cge_tq_min_ofs
				Cmp_ex_prs_dif_fac
				Cbx_lpg_min_lvl_diag_ena
				Cmp_eal_tco_cart_iga_cor
				Cmp_eal_n_vvtc_otl_iga
				Cmp_eal_n_vvtc_off_otl_iga
				Cmp_eal_n_min_iga_cor
				Cmp_eal_n_lpg_cor_otl_iga
				Cmp_decl_aj_fil_fac_form
				Cmp_alti_n_max_tqi_cor
				Cmp_agb_sli_tq
				Cmp_acel_aj_fil_fac_form
				Cbx_wup_stop_ac
				Cbx_toil_bch_mod
				Cmp_eal_n_vvtc_on_otl_iga
				Cmp_iga_tco_cor_lpg
				Cbx_wup_fil_tq_dsb
				Cbx_tot_dyn_iga_cor_dsb
				Cbx_tq_abst_agb_aj_dsb
				Cbx_trt_fil_dsb
				Cmp_iga_tco_cor
				Cbx_wet_tb_cor_bch_mod
				Cbx_wet_stat_cor_bch_mod
				Cbx_wet_prs_eal_swi_mod
				Cxx_iga_vvt_req_on_tdc
				Cxx_iga_vvt_req_off_tdc
				Cxx_iga_ofs_cyl4
				Ctp_n_knk_fac_cyl1
				Cxx_iga_ofs_cyl3
				Cxx_iga_ofs_cyl2
				Ctp_n_knk_fac_cyl2
				Cxx_iga_ofs_cyl1
				Ctp_n_knk_ofs_cyl4
				Ctp_n_neut_dyn_iga_fac
				Ctp_n_min_gas_lim_tq
				Ctp_n_mfld_inv_fil_fac
				Ctp_n_lbup_hot_dsb_map
				Ctp_n_lbdw_hot_dsb_map
				Ctp_n_l_ti_i_cor_lpg
				Ctp_n_l_ti_i_cor_lean
				Ctp_n_hot_eng_sta_iga
				Ctp_n_l_ti_i_cor
				Ctp_n_knk_zon
				Ctp_n_knk_win_frst
				Cxx_iga_ofs_cyl
				Ctp_n_knk_ofs_cyl3
				Ctp_n_knk_ofs_cyl2
				Ctp_n_knk_ofs_cyl1
				Ctp_n_knk_ofs
				Ctp_n_knk_fil_fac_2_3
				Ctp_n_knk_fil_fac_1_4
				Ctp_n_knk_fast_inc_iga
				Ctp_n_knk_fac_cyl4
				Ctp_n_knk_fac_cyl3
				Ctp_n_knk_win_long
				Ctp_map_tia_iga_cor
				Cxx_in_vol_rat
				Cxx_inc_knk_fil_fac
				Ctp_n_agb_tq_pwm
				Cxx_inj_clos_angl_bch
				Ctp_n_ac_is_cor
				Cxx_inj_csm
				Ctp_min_mv_cld_ad
				Ctp_min_map
				Ctp_max_pump_maf
				Ctp_max_mv_cld_ad
				Ctp_n_kd_iga_cor
				Ctp_max_map_inj_cut
				Ctp_n_amp_prs_dif
				Ctp_map_fl_ocl_ofs
				Ctp_lpg_typ_adac_fmt_fac
				Ctp_lpg_trs_cor_stop
				Ctp_lpg_tia_thd
				Ctp_lpg_temp_wup_cyc_nr
				Ctp_lpg_temp_wup_cor_fac
				Ctp_lpg_sta_tia_thd
				Ctp_lpg_sta_tco_thd
				Ctp_lpg_gas_trs_cor_ini
				Cxx_inj_dly
				Cxx_inj_stop_n_ofs
				Ctp_max_map_sp
				Ctp_n_dri_dyn_iga_fac3
				Ctp_n_knk_acq_int
				Ctp_n_knk_acq_frq
				Ctp_n_kd_rich_fac_lpg
				Ctp_n_kd_rich_fac
				Cxx_in_hot_temp_hys
				Ctp_n_kd_rel_thr_thd
				Ctp_n_inj_cut_dly
				Ctp_n_h_thr_tq
				Ctp_n_drv_tkof_d
				Ctp_n_dri_dyn_iga_fac5
				Ctp_n_dri_dyn_iga_fac4
				Ctp_n_aj_fast_tq_dif_thd
				Cxx_in_run_stal_step
				Ctp_n_alt_is_cor
				Ctp_n_dri_dyn_iga_fac2
				Ctp_n_dri_dyn_iga_fac1
				Ctp_n_dri_dyn_iga_fac_lpg
				Ctp_n_dri_dyn_iga_fac
				Ctp_n_dly_ofs_dly_lpg
				Ctp_n_dly_ofs_dly
				Ctp_n_dif_tkof_p
				Ctp_n_diag_knk_acq
				Ctp_n_cold_eng_sta_iga
				Ctp_n_amp_spg_dif_cut
				Ctp_n_knk_fac
				Cxx_in_hot_temp_thd
				Ctp_tco_cut_decl_off_dly1
				Ctp_sta_tco_dly
				Cxx_iga_bch_mod
				Ctp_tco_is_bas_iga
				Ctp_tco_inj_sta_dly
				Ctp_tco_ini_is_i
				Cxx_iga_dec_tdc_nr
				Cxx_iga_is_deci_in_dly
				Ctp_tco_ini_fil_is_i_ad
				Ctp_tco_eai_ti_fac_cor
				Ctp_tco_dri_is_iga_lpg
				Ctp_tco_dri_is_cor_ofs
				Ctp_tco_is_bas_iga_lpg
				Ctp_tco_dec_sta_ti
				Ctp_tco_lbdw_hot_dly
				Ctp_tco_cut_decl_off_dly
				Ctp_tco_clos_thr_t
				Ctp_tco_cl2_ena_ctr_lpg
				Ctp_tco_cl2_ena_ctr
				Ctp_tco_cl_off_dly
				Ctp_tco_aut_thd
				Ctp_tco_agb_tq
				Ctp_tco_agb_neut_tq
				Ctp_tco_agb_neut_dly
				Ctp_tco_agb_dri_dly
				Ctp_tco_aftr_ti_fac
				Ctp_n_spg_dft_mod
				Ctp_tco_dri_agb_is_iga
				Ctp_tco_n_ini
				Ctp_tco_ti_fac1
				Ctp_tco_sta_ti_fac
				Ctp_tco_sta_ti
				Ctp_tco_sta_rich_dec
				Cxx_h_cge_n_dly
				Cxx_h_cge_n_thd
				Ctp_tco_sta_out_sfg_dly
				Cxx_h_dly_ocl_tco_thd
				Ctp_tco_sta_is_pwm
				Cxx_h_dyn_efy_cor
				Ctp_tco_rich_cylr
				Cxx_i_agb_driv_tq_thd
				Ctp_tco_neut_is_cor
				Ctp_sta_is_fil_pwm_dec
				Ctp_tco_max_pow_thd
				Ctp_tco_max_n
				Ctp_tco_lim_tqi
				Cxx_h_tq_req
				Cadzerom
				Cadgainm
				Ctp_tco_lim_sta_iga
				Cxx_hot_sta_iga_tco_thd
				Cxx_hot_vb_thd
				Ctp_tco_lean_ti_fac_cor
				Ctp_tco_lean_cylr
				Ctp_tco_lbup_hot_dly
				Ctp_tco_pinj_t
				Ctp_n_ti_p_cor_lean2
				Ctp_sta_tco_oil_temp_t
				Ctp_polu_inj_clos_angl
				Ctp_pn_tco_min_is_n
				Ctp_perf_inj_clos_angl
				Ctp_ol_is_rich_cylr
				Ctp_ol_is_lean_cylr
				Cxx_iga_is_deci_in_n_thd
				Ctp_neut_cata_is_iga_cor1
				Ctp_neut_cata_is_iga_cor
				Ctp_neg_whl_spd
				Ctp_n_tqi_dyn_lim
				Ctp_prs_fast_tq_max_lim
				Ctp_n_ti_p_cor_lpg
				Ctp_prs_fast_tq_min_lim
				Ctp_n_ti_p_cor_lean1
				Ctp_n_ti_p_cor
				Cxx_is_aj_clc_n_drv_fac
				Ctp_n_sta_ti
				Ctp_lpg_gas_trs_cor_inc
				Ctp_n_ptc_is_cor
				Ctp_n_pred_val_fil_fac
				Ctp_n_neut_dyn_iga_fac6
				Ctp_n_neut_dyn_iga_fac5
				Ctp_n_neut_dyn_iga_fac4
				Ctp_n_neut_dyn_iga_fac3
				Ctp_n_neut_dyn_iga_fac2
				Ctp_n_tia_fac
				Ctp_prs_tia_fac
				Ctp_spg_prs_rat_sp
				Ctp_spg_prs_dif_thd_trs
				Ctp_spg_max_grd
				Ctp_spg_cl_spg_prs_thd
				Ctp_rvr_pdl_fac
				Ctp_rich_otl_iga_mv_tqi
				Ctp_rich_lpg_otl_iga_tqi
				Ctp_pwst_iga_cor_max_lim
				Ctp_pwm_cp_efv_ar2
				Ctp_pwm_cp_efv_ar1
				Ctp_ptc_pow_cor
				Ctp_pos_whl_spd
				Ctp_prs_tmp_flr_val
				Ctp_n_neut_dyn_iga_fac1
				Ctp_prs_ti_ofs2_lpg
				Ctp_prs_ti_ofs2
				Ctp_prs_ti_ofs1_lpg
				Ctp_prs_ti_ofs1
				Ctp_prs_rat_fil_fac
				Ctp_prs_lpg_trs_cor_min
				Ctp_prs_l_ti_i_cor_lpg
				Ctp_prs_l_ti_i_cor_lean
				Ctp_prs_l_ti_i_cor
				Ctp_prs_knk_win_frst
				Ctp_prs_is_i_set
				Ctp_prs_gas_trs_cor_min
				Ctp_prs_tq_trs_fac
				Cxx_l_ti_slop_thd_lean1
				Cxx_l_dyn_efy_cor
				Cxx_l_is_pwm
				Cxx_l_min_iga_ctr_dec
				Cxx_l_min_iga_ctr_inc
				Cxx_l_min_iga_ctr_thd
				Cxx_l_min_iga_inc
				Ctp_cold_neut_is_iga_cor1
				Ctp_cold_neut_is_iga_cor
				Ctp_cold_neut_hot_is_cor1
				Cxx_l_tco_inj_stop_n
				Ctp_cold_neut_hot_is_cor
				Ctp_cold_dri_sta_is_cor
				Ctp_lpg_gas_trs_cor_dec
				Cxx_l_ti_slop_thd
				Ctp_cold_tdc_agb_is_n_ofs
				Cxx_l_ti_slop_thd_lean2
				Cxx_l_ti_slop_thd_lpg
				Cxx_l_tq_req
				Ctp_cold_dri_hot_is_cor
				Ctp_cold_drag_red_sta_is_cor
				Cxx_l_v_lamb_thd
				Ctp_cold_drag_red_is_iga_cor
				Cxx_lamb_swi_ctr_ini
				Cxx_lamb_swi_ctr_ini_lpg
				Cxx_last_bkp_prs_rat
				Cxx_lbdw_fil_fac
				Ctp_cold_drag_red_hot_is_cor
				Ctp_cold_dri_is_iga_cor
				Cxx_knk_zon_tco_thd
				Cxx_knk_slow_cor_prs_dif
				Cxx_knk_slow_fil_mv_hys
				Cxx_knk_slow_fil_mv_iga
				Cxx_knk_slow_iga_efy
				Cxx_knk_slow_iga_efy_hys
				Cxx_knk_tq_cor_dec_dly
				Cxx_knk_tq_cor_dec_fac
				Cxx_knk_tq_cor_dec_ofs
				Ctp_eal_fac
				Ctp_eai_rich_cl_ctr
				Ctp_dri_cata_is_iga_cor
				Cxx_knk_tq_cor_inc_dly
				Ctp_cold_neut_sta_is_cor
				Cxx_knk_tq_cor_inc_ofs
				Ctp_cold_neut_sta_is_cor1
				Cxx_l_ad_is_alt_pow
				Ctp_drag_tco_min_is_n
				Ctp_drag_red_cata_is_iga_cor
				Ctp_decl_n_ti_p_cor
				Ctp_decl_aj_tqe_up_thd
				Ctp_decl_aj_tqe_l_thd
				Ctp_cylr_prs_stab_dif
				Ctp_cp_load_fac_cor
				Ctp_comp_wup_lpg
				Ctp_comp_wup
				Ctp_cold_tdc_pn_is_n_ofs
				Ctp_cold_tdc_drag_red_is_n_ofs
				Cxx_lbdw_hot_cmd_vs_hys
				Cxx_knk_tq_cor_inc_fac
				Ctp_ac_is_cor_appl_dly
				Ctp_cl_lean_stop
				Ctp_air_pump_sta_tdc_thd
				Ctp_agb_toil_cor
				Ctp_agb_tco_min_is_n
				Ctp_acel_n_ti_p_cor
				Cxx_lbup_hot_cmd_map_hys
				Cxx_lbup_hot_cmd_vs_hys
				Ctp_acel_aj_tqe_up_thd
				Ctp_acel_aj_tqe_l_thd
				Ctp_ac_pow_is_iga
				Ctp_ac_pow_dri_is_iga
				Ctp_ac_neut_tmp_is_cor
				Ctp_alt_dri_is_cor
				Cxx_lbup_hot_dsb_vs
				Ctp_alt_neut_is_cor
				Ctp_ac_dri_tmp_is_cor
				Ctp_ac_dri_is_cor
				Ctd_ufld_rest_cor
				Ctd_ti_b_cor
				Ctd_ti_ad_ofs_cor
				Ctd_ti_ad_fac_cor
				Ctd_tco_min_rest_cor
				Ctd_n_ptc_is_cor
				Ctd_n_prs_trs_cor_iga
				Ctd_n_ovt_tqi_ofs
				Ctd_n_max_tqi
				Ctd_n_iga_prs_thd
				Ctd_n_iga_pred_prs_thd
				Ctp_ac_neut_is_cor
				Ctp_cata_neut_sta_is_cor1
				Cxx_knk_slow_cor_iga_inc
				Cxx_lbdw_hot_dsb_vs
				Ctp_cl_lean_sta
				Ctp_cl_is_rich_cylr
				Ctp_cl_is_lean_cylr
				Ctp_cata_wup_lean_lpg
				Ctp_cata_wup_lean
				Ctp_cata_wup_eng_lpg
				Ctp_cata_wup_eng
				Ctp_cata_wup_eai
				Ctp_cata_wup_dstb_lpg
				Ctp_cata_wup_dstb
				Ctp_air_pump_stop_tdc_thd
				Ctp_cata_wup_cold
				Cxx_lbdw_hot_cmd_map_hys
				Ctp_cata_neut_sta_is_cor
				Ctp_cata_neut_hot_is_cor1
				Ctp_cata_neut_hot_is_cor
				Ctp_cata_dri_sta_is_cor
				Ctp_cata_dri_hot_is_cor
				Ctp_cata_drag_red_sta_is_cor
				Ctp_cata_drag_red_hot_is_cor
				Ctp_bch_mod_stat_ofs
				Ctp_bch_mod_stat_inc
				Ctp_bch_mod_dyn_ofs
				Ctp_bch_mod_dyn_inc
				Ctp_bch_mod_cyc_nr
				Ctp_alti_sta_cor
				Ctp_cata_wup_cold_lpg
				Cxx_is_i_fac1
				Cxx_is_in_ofs_sta_stt
				Ctp_gear_acel5_aj_fil_fac
				Ctp_gear_acel3_aj_fil_fac
				Cxx_is_d_cor_min
				Cxx_is_d_dsb_n_drv_thd
				Cxx_is_dclu_acc
				Cxx_is_deci_in_dly
				Cxx_is_deci_in_n_thd
				Cxx_is_dstb_ti_ofs_cor
				Cxx_is_dstb_ti_ofs_cor1
				Cxx_is_dyn_iga_fil_fac
				Cxx_is_dyn_iga_n_ofs
				Ctp_gear_decl4_aj_fil_fac
				Cxx_is_hot_ti_cl_dly
				Ctp_gear_decl6_aj_fil_fac
				Cxx_is_i_fac2
				Cxx_is_i_fac3
				Cxx_is_i_fil_fac1
				Cxx_is_i_fil_fac2
				Cxx_is_i_n_drv_thd
				Cxx_is_i_sp_fil_fac
				Cxx_is_i_zon_out_dly
				Cxx_is_iga_cor_fil_step
				Cxx_is_iga_prop_sp_fac
				Cxx_is_iga_sp_max_ofs
				Cxx_is_in_cdn_ofs
				Cxx_is_in_cdn_ofs2
				Cxx_knk_slow_cor_iga_max
				Cxx_is_hot_tco_thd
				Cxx_is_aj_n_drv_l_hys
				Cxx_inj_vvt_req_off_tdc
				Cxx_inj_vvt_req_on_tdc
				Cxx_inv_dsb
				Cxx_inv_ini_acq_dif
				Cxx_is_acel_ac_dsb_dly
				Ctp_tdc_agb_tco_is_n_ofs
				Ctp_lpg_aftr_sta_ini_dly
				Ctp_l_vs_pdl_fac
				Cxx_is_aj_clc_step
				Ctp_knk_rel_tq_cor_max
				Ctp_is_pwm_thr_ar_sp
				Ctp_is_decl_clc_tco_fac
				Ctp_gear_decl2_aj_fil_fac
				Cxx_is_aj_n_drv_h_hys
				Ctp_gear_acel1_aj_fil_fac
				Ctp_is_decl_clc_n_fac
				Ctp_is_decl_clc_cut_n_fac
				Ctp_is_d_clc_tco_fac
				Ctp_is_d_clc_n_drv_fac
				Ctp_is_aj_clc_n_cor
				Cxx_is_cdn_h_sta_n_dly
				Ctp_inv_prs_rat
				Ctp_iga_prs_fl_thd
				Ctp_iga_efv_lpg
				Ctp_iga_efv
				Ctp_iga_dif
				Ctp_h_vs_pdl_fac
				Ctp_h_l_iga_cata_wup
				Ctp_is_decl_clc_prs_fac
				Ctp_fast_slop_out
				Cxx_is_in_dly
				Cxx_kd_decl_cut_n_ofs
				Ctp_frn_tq_loss_tco_fac
				Ctp_frn_tq_loss
				Cxx_kd_thr_thd
				Cxx_knk_1cyl_slow_cor_max
				Cxx_knk_2cyl_slow_dif_max
				Cxx_knk_det_n_thd
				Cxx_knk_det_prs_thd
				Cxx_knk_det_tco_thd
				Ctp_fil_fac_mdl_map
				Cxx_knk_fast_cor_dec_ctr
				Cxx_is_ti_p_cor_lean2
				Ctp_fast_tq_cold_min_lim
				Cxx_is_ti_p_cor_lean1
				Cxx_knk_fast_cor_iga_thd
				Ctp_fast_slop_in
				Cxx_knk_fil_inc
				Cxx_knk_fmt_fil_fac
				Cxx_knk_fmt_fil_max
				Cxx_knk_fmt_fil_min
				Ctp_fac_n_dif_drv
				Ctp_el_csm_n_sp_ofs
				Cxx_knk_iga_cor
				Cxx_knk_iga_cor_fil_fac
				Cxx_knk_noi_lvl
				Cxx_knk_slow_cor_dec_ctr
				Cxx_inj_stop_tco_thd
				Cxx_knk_fast_cor_iga_max
				Cxx_is_out_n_ofs2
				Ctp_gas_trs_cor_stop
				Ctp_gas_lpg_trs_cor_ini
				Ctp_gas_lpg_trs_cor_inc
				Cxx_is_in_pump_thd
				Ctp_gas_lpg_trs_cor_dec
				Cxx_is_min_ad_pwm_ini
				Cxx_is_n_sp_max
				Cxx_is_n_stab_clc_fac
				Cxx_is_ocl_tco_thd
				Cxx_is_out_n_ofs
				Ctp_fzy_tkof_vs_n_rat_fac
				Ctp_fzy_tkof_vs_fac
				Cxx_is_ti_p_cor_lpg
				Ctp_fzy_tkof_tqe_grd_fac
				Ctp_eal_fl_ocl_ofs
				Cxx_is_out_pump_thd
				Cxx_is_p_clc_fac1
				Cxx_is_p_clc_fac2
				Cxx_is_p_clc_fac3
				Cxx_is_p_clc_fac4
				Cxx_is_p_dsb_n_hys
				Cxx_is_p_max
				Cxx_is_p_min
				Cxx_is_stab_n_drv_thd
				Cxx_is_ti_i_cor
				Cxx_is_ti_i_cor_lean
				Cxx_is_ti_i_cor_lpg
				Cxx_is_ti_p_cor
				Cxx_is_out_n_ofs_sta
				Cxx_clc_gear_rat_stab_dly
				Cxx_air_pump_pow2
				Cxx_cold_drag_red
				Cxx_cold_agb_tco_is_n_ofs
				Cxx_cold_agb
				Cxx_cmd_vvt_req_on_tdc
				Cxx_cmd_vvt_req_off_tdc
				Cxx_cmd_mdf_dly
				Cxx_clu_acc
				Cxx_clos_thr_vs_max
				Cxx_clos_thr_tia_min
				Cxx_clos_thr_n_min
				Cxx_cold_loop_kd_rich_fac
				Cxx_cld_ad_nr
				Cxx_cold_pn
				Cxx_clc_gear_rat_stab_2
				Cxx_clc_gear_rat_stab_1
				Cxx_clc_gear_rat_hys_n
				Cxx_clc_gear_rat_hys_2
				Cxx_clc_gear_rat_hys_1
				Cxx_clc_gear_det_l_gear
				Cxx_cl2_n_thd
				Cxx_dft_rgt_trt
				Cxx_cl2_map_thd
				Cxx_diag_knk_acq_fac
				Cxx_cl2_asd_map_thd
				Cxx_cl2_act_ctr
				Cxx_clos_thr_n_max
				Cxx_cp_is_cor
				Cxx_cp_ol_tco_min_thd
				Cxx_cp_n_thd
				Cxx_cp_n_frq
				Cxx_cp_min_dly
				Cxx_cp_min_ad_dly
				Cxx_cp_max_prs_thd
				Cxx_cp_max_dly
				Cxx_cp_max_ad_dly
				Cxx_cp_max_ad
				Cxx_cp_lamb_fac_mv_thd_2
				Cxx_cp_lamb_fac_mv_thd_1
				Cxx_cold_drag_red_tco_is_n_ofs
				Cxx_cp_is_tco_min_thd
				Cxx_cl_run_prs_thd
				Cxx_cp_inc_ad
				Cxx_cp_hys_n_frq
				Cxx_cp_grd_fac
				Cxx_cp_fil_cl_ti_fac
				Cxx_cp_fac_rel
				Cxx_cp_fac_pwm
				Cxx_cp_ad_thd
				Cxx_cp_ad_tco_min_thd
				Cxx_cor_fil_cata_hot_inc
				Cxx_cor_fil_cata_hot_dec
				Cxx_cold_sta_tco
				Cxx_cold_pn_tco_is_n_ofs
				Cxx_cp_is_tia_min_thd
				Cxx_alti_ini_fil_is_i
				Cxx_aod_dly_ini
				Cxx_amp_spg_dif_fac
				Cxx_amp_prs_cge_n_thd
				Cxx_amp_kd_dly
				Cxx_amp_is_dly
				Cxx_amp_inj_cut_dly
				Cxx_alti_upd_t_rst
				Cxx_alti_prs2_fac
				Cxx_alti_prs_fil_fac
				Cxx_alti_pinj_cor_fac
				Cxx_alti_is_dec
				Cxx_cl_t_fac
				Cxx_alti_inj_cor
				Cxx_appl_ti_ofs_ctr
				Cxx_alt_tq_fil_fac
				Cxx_alt_pow_fil_fac
				Cxx_aj_tqe_thd_fac
				Cxx_aj_fast_tq_tco_thd
				Cxx_aj_fast_tq_dsb_n_thd
				Cxx_air_wht_mpl_fac
				Cxx_air_tq_t_dly
				Cxx_air_tq_angl_dly
				Cxx_air_pump_thr_ar_sp_hys
				Cxx_air_pump_thr_ar_sp
				Cxx_air_pump_stop_dly
				Ctp_tco_tkof_l_thd
				Cxx_alti_is_cor
				Cxx_bch_mod_tq
				Cxx_cp_pwm_max_3
				Cxx_cl_lean_ctr
				Cxx_lim_zon_ref_dif_2
				Cxx_cata_wup_dstb_prs_min
				Cxx_cata_wup_dstb_prs_max
				Cxx_cata_wup_dstb_ofs
				Cxx_cata_wup_dstb_n_max
				Cxx_cart_iga_fil_inc
				Cxx_cart_iga_fil_dec
				Cxx_cart_iga_fil_cold_inc
				Cxx_cart_dyn_iga_vs
				Cxx_cart_dyn_iga_tco_thd
				Cxx_aper_rich_sta_tco_thd
				Cxx_bfr_cl_ctr
				Cxx_aper_rich_sta_tia_thd
				Cxx_bch_mod_nr
				Cxx_bch_in_angl
				Cxx_aut_swi1_is_ofs_lpg
				Cxx_aut_swi1_is_ofs
				Cxx_aut_swi_is_ofs_lpg
				Cxx_aut_swi_is_ofs
				Cxx_asd_rich_cylr
				Cxx_asd_lean_cylr
				Cxx_ar_flr_tmp_min
				Cxx_ar_flr_tmp_dsb
				Cxx_appl_ti_ofs_ctr_lpg
				Cxx_cl_stop_prs_thd
				Cxx_bfr_cl_ctr_lpg
				Cxx_cylr_gear
				Cxx_cyl2_ti_dstb_iga_lpg
				Cxx_cyl3_ti_dstb_iga
				Cxx_cyl3_ti_dstb_iga_is
				Cxx_cyl3_ti_dstb_iga_lpg
				Cxx_cyl4_ti_dstb_iga
				Cxx_cyl4_ti_dstb_iga_is
				Cxx_cyl4_ti_dstb_iga_lpg
				Cxx_cylr_alti_prs_max_fac
				Cxx_cylr_alti_prs_min_fac
				Cxx_cylr_clc_ctr
				Cxx_cylr_clc_ctr_lpg
				Cxx_cylr_l_prs_dif_fac
				Cxx_cylr_eol_mod
				Cxx_cyl1_ti_dstb_iga_lpg
				Cxx_cylr_is_clc_ctr
				Cxx_cylr_is_clc_ctr_lpg
				Cxx_cylr_is_max_test_nr
				Cxx_cylr_is_max_tq_dec
				Cxx_cylr_is_max_tq_dec1
				Cxx_cylr_is_min_tq_dec
				Cxx_cylr_is_min_tq_dec1
				Cxx_cylr_is_run_max_tco
				Cxx_cylr_is_run_min_tco
				Cxx_cylr_is_run_n_fac
				Cxx_cylr_is_ti_fac_min
				Cxx_cp_pwm_max_1
				Cxx_cylr_cp_ti_fac
				Cxx_cut_decl_tco_thd_lpg
				Cxx_cp_trs_h_thd
				Cxx_cp_trs_h_thd_lpg
				Cxx_cp_trs_l_thd
				Cxx_cp_trs_l_thd_lpg
				Cxx_ct_fac_step_dec
				Cxx_ct_fac_step_inc
				Cxx_ct_pdl_tco_thd
				Cxx_ct_stat_tq_ofs
				Cxx_ct_stop_tkof_fil_fac
				Cxx_cut_decl_gear_thd1
				Cxx_cut_decl_gear_thd2
				Cxx_cut_decl_gear_thd3
				Cxx_cyl2_ti_dstb_iga_is
				Cxx_cut_decl_tco_thd
				Cxx_cyl2_ti_dstb_iga
				Cxx_cut_decl_tco_thd1
				Cxx_cut_decl_tco_thd1_lpg
				Cxx_cut_fac_step_dec
				Cxx_cut_n_ofs
				Cxx_cut_n_ofs2
				Cxx_cut_tqr_thd_n
				Cxx_cut_tqr_thd_n_lpg
				Cxx_cut_tqr_thd_prs
				Cxx_cut_tqr_thd_prs_lpg
				Cxx_cyl1_ti_dstb_iga
				Cxx_cyl1_ti_dstb_iga_is
				Cxx_cylr_l_prs_re_phs
				Cxx_cut_decl_gear_thd4
				Cxx_dft_lft_trt
				Cxx_cp_stab_dly
				Cxx_cp_rtn_dly_dec
				Cxx_cp_rel_step_lamb_fac
				Cxx_cp_pwm_step_5
				Cxx_decl_esti_tqe_fil_fac
				Cxx_decl_fast_slop
				Cxx_decl_fast_slop_lean
				Cxx_decl_knk_fil_fac
				Cxx_decl_lean_dsb_n_ofs
				Cxx_decl_lean_dsb_n_thd
				Cxx_decl_prs_lean_dsb_dly
				Cxx_cylr_l_n_re_phs
				Cxx_dft_cp_load
				Cxx_cp_t_on
				Cxx_dft_lght_off_tco_thd
				Cxx_dft_lght_on_tco_thd
				Cxx_cp_pwm_step_4
				Cxx_cp_pwm_step_3
				Cxx_cp_pwm_step_2
				Cxx_cp_pwm_step_1
				Cxx_cp_pwm_sp4
				Cxx_cp_pwm_sp3
				Cxx_cp_pwm_sp2
				Cxx_cp_pwm_sp1
				Cxx_cp_pwm_max_4
				Cxx_air_pump_pow1
				Cxx_degr_cut_gear_thd
				Cxx_cylr_min_tco
				Cxx_cylr_max_dif_iga
				Cxx_cylr_max_mv_lamb_fac
				Cxx_cylr_max_prs
				Cxx_cylr_max_prs_lpg
				Cxx_cylr_max_tco
				Cxx_cylr_max_test_nr
				Cxx_cylr_max_tq_dec
				Cxx_cylr_max_tq_dec_lpg
				Cxx_cylr_min_mv_lamb_fac
				Cxx_cp_tco_min_thd
				Cxx_cylr_min_n
				Cxx_cylr_min_n_lpg
				Cxx_cp_step_lamb_fac
				Cxx_cylr_min_prs_lpg
				Cxx_cp_t_off
				Cxx_cylr_min_tq_dec
				Cxx_cylr_min_tq_dec_lpg
				Cxx_cylr_n_stab_dif
				Cxx_cylr_stab_ctr
				Cxx_cylr_stab_ctr_lpg
				Cxx_cylr_stab_inj_dif
				Cxx_cylr_stab_is_ctr
				Cxx_cylr_stab_is_ctr_lpg
				Cxx_cylr_tco_thd
				Cxx_deb_dly
				Cxx_decl_cut_n_ofs
				Cxx_cp_pwm_max_2
				Cxx_cylr_min_prs
				Cxx_fast_slop_h_thd
				Cxx_air_pump_sta_dly
				Cxx_fail_decl_cut_n_ofs
				Ctp_vvtc_act_temp_h_thd
				Cxx_fail_decl_inj_cut
				Ctp_vs_n_tkof_degr
				Cxx_fail_decl_inj_cut_lpg
				Cxx_fast_ad_cdn_dly
				Ctp_vs_mvac_dp_dec
				Ctp_vs_l_tq_pdl_thd
				Ctp_vb_inj_dly_cor
				Ctp_ufld_tco_thd
				Ctp_vvtc_angl_iga_fac2
				Ctp_tqr_swi_fmt
				Cxx_fac_cor_thr_adj
				Cxx_fast_slop_l_thd
				Cxx_fast_tq_max_lim10
				Cxx_fast_tq_max_lim20
				Cxx_fast_tq_max_lim30
				Cxx_fast_tq_min_lim10
				Cxx_fast_tq_min_lim20
				Cxx_fast_tq_min_lim30
				Cxx_fil_cl_ti_fac
				Cxx_fil_cl_ti_fac_lpg
				Ctp_tqr_swi
				Ctp_tqr_cut_lpg
				Ctp_tqr_cut
				Ctp_tqr_swi_lpg
				Cxx_el_wind_n_dec
				Cxx_el_bk_wind_dly
				Cxx_el_bk_wind_is_cor
				Cxx_el_bk_wind_is_cor_dec
				Cxx_el_bk_wind_is_cor_dly
				Cxx_el_bk_wind_is_n
				Cxx_el_csm_clc_dly
				Cxx_el_csm_clc_neg_fac
				Cxx_el_csm_clc_pos_fac
				Cxx_el_wind_dec_dly
				Cxx_el_wind_dly
				Cxx_el_wind_dri_is_cor
				Ctp_vvtc_angl_iga_fac1
				Cxx_el_wind_is_cor_dly
				Cxx_fil_inj_clos_inc
				Cxx_el_wind_neut_is_cor
				Cxx_el_wind_pow
				Cxx_el_wind_tco
				Ctp_wet_tb_decl_vol_fac
				Cxx_eng_air_wht_ref
				Ctp_wet_tb_acel_vol_fac
				Ctp_wet_ini_acel_cor_ofs
				Ctp_wet_decl_fil_fac
				Cxx_eng_stop_thr_psn_sp
				Ctp_wet_decl_cor_fac
				Ctp_wet_acel_cor_fac
				Cxx_etun_nr
				Cxx_el_wind_is_cor_dec
				Cxx_gear_cge_n_thd
				Cxx_fmt_pdl_l_vs_thd
				Ctp_thpl_is_n
				Cxx_fzy_tkof_lim_dec_t
				Cxx_gas_lpg_trs_cyc_nr
				Cxx_gas_pump_dly
				Ctp_thpl_air_fac
				Cxx_gear_cge_cut_map_ofs
				Cxx_gear_cge_dec_dly
				Cxx_gear_cge_dly
				Ctp_tdc_pn_tco_is_n_ofs
				Cxx_gear_cge_eal_thd
				Ctp_tqr_ct_fmt
				Cxx_gear_cge_l_tq_dly
				Cxx_fl_tq_ofs
				Cxx_gear_cge_tq_max_ofs
				Cxx_gear_cge_vs_dly
				Ctp_tdc_drag_red_tco_is_n_ofs
				Cxx_gear_iga_dec
				Cxx_gear_mem_vs_thd
				Cxx_cp_tia_min_thd
				Ctp_tco_toil_ofs
				Ctp_tco_tkof_degr_fac
				Cxx_gear_vs_thd
				Cxx_gear1_iga_dec
				Cxx_gear1_iga_dec_tdc_nr
				Cxx_h_ad_is_alt_pow
				Cxx_gear_cge_fast_lim_dly
				Ctp_tia_max_tqi_cor
				Ctp_wet_vol_dif_thd_acel
				Cxx_fil_is_i_sp
				Cxx_fil_map_fac
				Ctp_tqr_ct
				Ctp_tq_rat_fil_fac
				Ctp_tq_agb_is_iga_lpg
				Cxx_fil_thr_psn_dif_thd
				Cxx_fil_ti_ofs2_fac
				Ctp_tq_agb_is_iga
				Ctp_toil_max_n
				Ctp_toil_lim_tq
				Ctp_toil_is_n_ofs
				Cxx_fmt_pdl_h_vs_thd
				Ctp_tia_sta_ti_fac
				Cxx_flr_clc_dsb_prs_thd
				Ctp_tia_is_cor
				Ctp_tia_inj_cor
				Ctp_ti_cor_eai_fil_ctr
				Ctp_thr_ar_pos
				Ctp_thpl_tco
				Cxx_fl_bfr_cl_ctr
				Cxx_fl_ena_n_thd
				Cxx_fl_max_thr_ar
				Cxx_fl_n_thd
				Cxx_fl_n_thd_hys
				Cxx_fl_tq_hys
				Cxx_fil_inj_clos_dec
				Ctp_toil_fil
				Cxx_ac_mdf1_is_cor1
				Cxx_ad_off_ti_ad_fac
				Cxx_ad_lamb_swi_ctr
				Cxx_ad_cor_dsb_dly
				Cxx_acel_is_req_dclu_acc
				Cxx_acel_fast_slop_lean
				Cxx_acel_fast_slop
				Cxx_acel_esti_tqe_fil_fac
				Cxx_ac_swi_is_ofs_lpg
				Cxx_ac_swi_is_ofs
				Cxx_ac_min_is_n_step_dly
				Cxx_ac_min_is_n_step
				Cxx_diag_knk_n
				Cxx_ac_mdf2_is_cor
				Cxx_ad_tq_fil_fac
				Cxx_ac_mdf1_is_cor
				Cxx_ac_load_dft
				Cxx_ac_is_out_n_ofs2
				Cxx_ac_is_out_n_ofs
				Cxx_ac_is_in_dly
				Cxx_ac_is_in_cdn_ofs2
				Cxx_ac_is_in_cdn_ofs
				Cxx_ac_is_i_n_drv_thd
				Cxx_ac_ena_tco_thd
				Cxx_diag_knk_acq_frq
				Cxx_diag_knk_acq_int
				Cxx_dz_pdl
				Cxx_ac_mdf2_is_cor1
				Cxx_agb_min_is_n_step_dly
				Cxx_air_pump_n_dsb_hys
				Cxx_air_pump_n_dsb
				Cxx_air_pump_is_cor2
				Cxx_air_pump_is_cor1
				Cxx_air_pump_eal_dsb_hys
				Cxx_air_pump_eal_dsb
				Cxx_air_pump_cor
				Cxx_agb_wind_min_is_n
				Cxx_agb_vh_min_is_n
				Cxx_agb_tq_max_ofs
				Cxx_agb_tco_is_n_ofs
				Cxx_agb_pwst_min_is_n
				Cxx_ad_off_ti_ad_ofs
				Cxx_agb_min_tqe_fac
				Cxx_ad_ptc_pow_thd
				Cxx_agb_min_is_n_step
				Cxx_agb_min_is_n
				Cxx_agb_ac_min_is_n
				Cxx_aftr_inj_map_fac
				Cxx_aftr_inj_map_dif
				Cxx_adj_fac_thr_adj
				Cxx_adac_ti_ofs_lpg
				Cxx_adac_ti_ofs
				Cxx_adac_ti_csm_fac
				Cxx_adac_csm_mux_lpg
				Cxx_adac_csm_mux
				Cxx_diag_knk_tco
				Cxx_agb_ptc_min_is_n
				Cxx_dyn_iga_gear_val
				Cxx_dstb_inj3_ti_fac
				Cxx_dstb_inj3_ti_fac_is
				Cxx_dstb_inj3_ti_fac_lpg
				Cxx_dstb_inj4_ti_fac
				Cxx_dstb_inj4_ti_fac_is
				Cxx_dstb_inj4_ti_fac_lpg
				Cxx_dstb_ti_ofs_cor
				Cxx_dstb_ti_ofs_cor_lpg
				Cxx_dstb_ti_p_cor
				Cxx_dstb_ti_p_cor_lpg
				Cxx_dyn_iga_efy_dz
				Cxx_diag_knk_bpf_frq
				Cxx_dyn_iga_fil_n_ofs
				Cxx_dstb_inj2_ti_fac_is
				Cxx_dyn_iga_mv_clc_dly
				Ctp_wet_vol_dif_thd_sta
				Cxx_dyn_iga_mv_n_fac
				Ctp_wet_vol_dif_thd_ini
				Ctp_wet_vol_dif_thd_decl
				Cxx_dyn_iga_mv_n_thd
				Cxx_dyn_iga_pdl_rel
				Cxx_dyn_iga_pdl_rel_hys
				Cxx_dyn_iga_vs
				Cxx_dyn_iga_vs_hys
				Cxx_dyn_prs_fil_ofs2
				Ctp_tco_ti_fac3
				Cxx_dyn_iga_fil_ini_n_ofs
				Cxx_dly_ocl_tco_thd
				Cxx_diag_knk_tdc_nr
				Cxx_diag_knk_win_frst
				Cxx_diag_knk_win_long
				Cxx_ac_dsb_tco_thd
				Cxx_ac_cut_n_ofs
				Cxx_ac_aut_swi1_is_ofs1
				Cxx_ac_aut_swi1_is_ofs
				Cxx_ac_aut_swi_is_ofs_lpg
				Cxx_ac_aut_swi_is_ofs
				Cxx_diag_tmp_max_is_n
				Cxx_diag_tmp_min_is_n
				Cxx_dly_ocl_alti_thd
				Cxx_dstb_inj2_ti_fac_lpg
				Cxx_dly_ocl_l_n_thd
				Ctp_wet_vol_dif_thd_sta_t
				Cxx_dly_ocl_up_n_thd
				Cxx_drag_red_tco_is_n_ofs
				Cxx_dri_agb_ad_is_fil
				Cxx_dri_sp_is_cor
				Cxx_abs_whl_spd_med_zon
				Ctx_fac_cor_thr_ar_min
				Ctx_fac_cor_thr_ar_max
				Cxx_dstb_inj1_ti_fac
				Cxx_dstb_inj1_ti_fac_is
				Cxx_dstb_inj1_ti_fac_lpg
				Cxx_dstb_inj2_ti_fac
				Cxx_dz_iga_efv
				Cxx_dly_ocl_knk_thd
				Cxx_spg_err_drv_fil_fac
				Cxx_spg_min_err_drv
				Cxx_spg_max_pwm
				Cxx_spg_max_prs_dif
				Cxx_spg_max_err_drv
				Cxx_spg_i_pwm_sp
				Cxx_spg_i_pwm_min_cor
				Cxx_spg_i_pwm_max_cor
				Cxx_spg_ad_stab_prs_thd
				Cxx_spg_err_up_thd_drv
				Cxx_spg_prop_dz
				Cxx_spg_err_down_thd_drv
				Cxx_spg_drv_pwm_fac
				Cxx_spg_down_ad_dz
				Cxx_spg_cl_tco_thd
				Cxx_spg_alti_ol_pwm_fac
				Cxx_spg_alti_ofs_ofs
				Cxx_spg_alti_ofs_fac
				Cxx_stab_aj_fast_tq_fac
				Cxx_spg_i_pwm_fac
				Cxx_sta_fl_off_dly_lpg
				Cxx_n_lim_l_tco_thd
				Cxx_sta_tco_ti_dec_fac
				Cxx_sta_stt_is_in_dly
				Cxx_sta_rich_dec_nr
				Cxx_sta_pinj_toth_nr
				Cxx_sta_n_fil_fac
				Cxx_sta_inj_sta_angl
				Cxx_sta_iga_vld_ctr
				Cxx_spg_min_pwm
				Cxx_sta_iga_dec
				Cxx_spg_ol_spg_sp_thd
				Cxx_sta_fl_off_dly
				Cxx_sta_dyn_iga_mv_n_fac
				Cxx_sta_ac_dsb_dly
				Cxx_spg_up_ad_dz
				Cxx_spg_pwm_dif_trt_ad
				Cxx_spg_pwm_bch_mod_val
				Cxx_spg_prop_pwm_fac
				Cxx_spg_ad_spg_thd
				Cxx_sta_iga_dec_tdc_nr
				Cxx_tqr_ct_thd_prs
				Cxx_tmp_mdf2_is_cor
				Cxx_toil_bch_mod
				Cxx_toil_is_n_ofs
				Cxx_tq_rat_fil_fac_ovn
				Cxx_tqe
				Cxx_sfg_seq_trs_ti_fac
				Cxx_sfg_seq_trs_n_thd
				Cxx_spg_ad_up_vb_thd
				Cxx_tqr_clu_ac_ofs
				Cxx_tmp_cut_map_thd
				Cxx_sens_dif_alti_prs_thd
				Cxx_ol_ti_fac_dec
				Cxx_ol_ti_fac_inc
				Cxx_out_inj_sta_n_thd
				Cxx_ovn_cor_dec
				Cxx_ovn_cor_inc
				Cxx_ovt_dly
				Cxx_ovt_gear_thd
				Cxx_sfg_seq_trs_ctr
				Cxx_slop_ac_dsb_n_thd
				Cxx_spg_ad_pwm_min_cor
				Cxx_spg_ad_pwm_max_cor
				Cxx_spg_ad_pwm_fac
				Cxx_spg_ad_n_thd
				Cxx_spg_ad_down_vb_thd
				Cxx_spg_ad_alti_thd
				Cxx_slop_fil_map_fac
				Cxx_slop_ac_dsb_vs_thd
				Cxx_tmp_mdf1_is_cor
				Cxx_slop_ac_dsb_thr_thd
				Cxx_tmp_cut_map_thd_lpg
				Cxx_slop_ac_dsb_n_hys2
				Cxx_slop_ac_dsb_n_hys1
				Cxx_slop_ac_dsb_gear_thd
				Cxx_slop_ac_dsb_gear_hys
				Cxx_slop_ac_dsb_dly
				Cxx_tmp_ac_cor_dec_dly
				Cxx_tmp_ac_is_cor_dec
				Cxx_stab_aj_fast_tq_ofs
				Cxx_slop_ac_dsb_vs_hys
				Cxx_tdc_nr_pred_dly_ref
				Cxx_n_ofs_swi_iga_stop
				Cxx_n_ofs_swi_iga_stop1
				Cxx_n_ovs_cor_fac
				Cxx_n_puls_fil_fac_ovn
				Cxx_n_tkof_fil_fac
				Cxx_n_tkof_inrt_0
				Cxx_temp_ac_dsb_n_thd
				Cxx_tco_toil_fil
				Cxx_tdc_per_fac
				Cxx_n_ofs_is_iga_stop_vh3
				Cxx_tdc_nr_bfr_lpg_gas
				Cxx_n_tkof_inrt_1
				Cxx_tdc_nr_bfr_gas_lpg
				Cxx_neut_ad_is_fil
				Cxx_neut_sp_is_cor
				Cxx_no_lim_zon_ref_dif_2
				Cxx_no_min_gas_dly
				Cxx_sta_tco_ti_rest_fac
				Cxx_temp_ac_dsb_dly
				Cxx_n_ofs_cart_iga_stop
				Cxx_n_lim_sta_iga_dec
				Cxx_thd_n_in_thr_adj
				Cxx_n_lim_sta_iga_inc
				Cxx_thd_map_out_thr_adj
				Cxx_thd_map_in_thr_adj
				Cxx_n_lim_up_tco_thd
				Cxx_n_max_thr_adj
				Cxx_temp_ac_dsb_tco_thd
				Cxx_n_ofs_out_sta_iga
				Cxx_n_ofs_cart_iga_run_vh
				Cxx_temp_ac_dsb_prs_thd
				Cxx_n_ofs_cart_iga_stop2
				Cxx_n_ofs_in_sta_iga
				Cxx_n_ofs_is_iga_run_vh
				Cxx_n_ofs_is_iga_run_vh1
				Cxx_n_ofs_is_iga_stop_vh
				Cxx_n_ofs_is_iga_stop_vh1
				Cxx_n_ofs_is_iga_stop_vh2
				Cxx_nr_tdc_inj_cut
				Cxx_n_min_thr_adj
				Cxx_stal_rest_fac
				Cxx_stop_rest_ufld_thd
				Cxx_stop_rest_tco_thd
				Cxx_stop_dyn_iga_ofs_lpg
				Cxx_stop_dyn_iga_ofs
				Cxx_stop_ac_dyn_iga_fac
				Cxx_stat_whl_thd
				Cxx_stat_whl_dly
				Cxx_tco_toil_thd
				Cxx_stal_step
				Cxx_stop_ufld_ctr_inc
				Cxx_stal_dly
				Cxx_stal_ac_dsb_n_thd
				Cxx_stal_ac_dsb_dly
				Cxx_stab_dyn_prs_up_thd
				Cxx_stab_dyn_prs_l_thd
				Cxx_stab_dyn_iga_n_thd
				Cxx_stab_dyn_iga_fil_fac
				Cxx_stab_dyn_dif_prs_thd
				Cxx_stat_whl_acq_dif
				Cxx_t_dly_n_drv_puls
				Cxx_tco_ti_fil_nr2
				Cxx_tco_ti_fil_nr
				Cxx_tco_mdf_dly
				Cxx_tco_kd_rich_cor_fac
				Cxx_tco_is_n_ofs_rat_lim
				Cxx_tco_inc_tdc_nr
				Cxx_tco_fail_pinj_t
				Cxx_tco_fail_cmd_mdf_dly
				Cxx_stop_tkof_fil_fac
				Cxx_t_pred_dly_ref
				Cxx_stop_toil_fil
				Cxx_t_dly_cge
				Cxx_swi_is_ofs_lpg
				Cxx_swi_is_ofs
				Cxx_swi_ena_drv_n_thd
				Cxx_swi_cor_stop_n_thd
				Cxx_swi_cor_n_thd
				Cxx_swi_ac_dsb_pow_thd
				Cxx_perf_ac_dsb_max_dly
				Cxx_tbn_prs_dif_cut_fac
				Cxx_ptc_tkof_vs_l_thd
				Cxx_pwst_min_is_n_rtn_dly
				Cxx_pwst_min_is_n_dec_dly
				Cxx_pwst_min_is_n_dec
				Cxx_pwst_iga_cor_cge_t
				Cxx_tqr_step_dec_gear1
				Cxx_tqr_swi_nr_tdc
				Cxx_pump_mvac_prs_fil_fac
				Cxx_ptc_min_pow_ena_min
				Cxx_ptc_tkof_vs_up_thd
				Cxx_pwst_prs_tco_thd
				Cxx_ptc_tkof_pdl_up_thd
				Cxx_ptc_tkof_n_up_thd
				Cxx_ptc_tkof_n_l_thd
				Cxx_ptc_tkof_gear_up_thd
				Cxx_ptc_tkof_gear_l_thd
				Cxx_ptc_rov_tia_thd
				Cxx_ptc_rov_tia_hys
				Cxx_ovt_inc_lim
				Cxx_pump_mvac_dp_max_rat
				Cxx_tqr_nr_tdc
				Cxx_rest_tco_l_ofs_lpg
				Cxx_rest_tco_l_ofs
				Cxx_rest_pinj_cor_fac
				Cxx_rest_mod_dsb_tco_thd
				Cxx_rest_mod_dsb_max_dly
				Cxx_tqr_ct_thd_prs_lpg
				Cxx_tqr_max
				Cxx_tqr_max_gear1
				Cxx_pwst_off_is_cor_dly
				Cxx_tqr_max_lpg
				Cxx_pwst_on_is_cor_dly
				Cxx_tqr_nr_tdc_gear1
				Cxx_tqr_rtn_nr_tdc
				Cxx_tqr_rtn_nr_tdc_gear1
				Cxx_tqr_rtn_nr_tdc_gear2
				Cxx_tqr_rtn_nr_tdc_lpg
				Cxx_tqr_step_dec
				Cxx_pwst_tq_loss
				Cxx_ptc_min_is_n_step_dly
				Cxx_tqr_max_gear1_lpg
				Cxx_pn_vh_min_is_n
				Cxx_prs_pred_prs_dif_thd
				Cxx_prs_dif_lpg_cdn_thd
				Cxx_prs_dft_min_is_n
				Cxx_trt_inv_dsb
				Cxx_pred_map_dif_pos_fac
				Cxx_pred_map_dif_neg_fac
				Cxx_pred_map_dif_max_fac
				Cxx_ptc_pow
				Cxx_pn_wind_min_is_n
				Cxx_prs_zon
				Cxx_pn_tco_is_n_ofs
				Cxx_pn_pwst_min_is_n
				Cxx_pn_ptc_min_is_n
				Cxx_pn_ac_min_is_n
				Cxx_lim_zon
				Cxx_typ_lpg_thd1
				Cxx_typ_lpg_thd2
				Cxx_up_v_lamb_thd
				Cxx_pred_map_dif_dz
				Cxx_ptc_eal_pdl_l_thd
				Cxx_ptc_min_is_n_step
				Cxx_tqr_swi_rtn_nr_tdc
				Cxx_tqr_swi_rtn_nr_tdc1
				Cxx_ptc_max_pow_ena_inc
				Cxx_tqr_swi_step_inc
				Cxx_ptc_is_cor_appl_dly1
				Cxx_ptc_is_cor_appl_dly
				Cxx_ptc_eal_vs_up_thd
				Cxx_prs_spg_fil_fac
				Cxx_ptc_eal_pdl_up_thd
				Cxx_prs_thd_inj_cut
				Cxx_ptc_eal_n_up_thd
				Cxx_ptc_eal_n_l_thd
				Cxx_ptc_cut_n_n_up_thd
				Cxx_ptc_cut_n_n_l_thd
				Cxx_ptc_cut_eng_inc
				Cxx_ptc_cor
				Cxx_prs_zon0
				Cxx_rest_ufld_cor
				Cxx_ptc_eal_vs_l_thd
				Cxx_whl_mov_thd
				Cxx_wpmp_tco_thd
				Cxx_wpmp_tco_hys
				Cxx_wpmp_max_tco_t
				Cxx_wpmp_max_t
				Cxx_whl_spd_rls
				Cxx_whl_spd_nul
				Cxx_run_ufld_ctr_inc1
				Cxx_rest_tco_up_ofs
				Cxx_run_mdf1_off_tco_thd
				Cxx_wup_dstb_l_map_lpg
				Cxx_wet_ti_cut_tdc_nr
				Cxx_wet_ti_cut_nr
				Cxx_wet_tdc_ctr_rat
				Cxx_wet_tb_cor_fac
				Cxx_wet_min_air_stab_thd
				Cxx_wet_ini_acel_sta_t
				Cxx_wet_ini_acel_ofs_t
				Cxx_wet_decl_bch_fil_fac
				Cxx_whl_spd_dsb
				Cxx_sa_alt_dly_is_cor
				Cxx_no_lim_zon_ref_dif_1
				Cxx_perf_ac_dsb_n_hys
				Cxx_perf_ac_dsb_n_thd
				Cxx_perf_ac_dsb_pow_thd
				Cxx_perf_ac_dsb_vs_hys
				Cxx_perf_ac_dsb_vs_thd
				Cxx_perf_inj_tco_thd
				Ctd_hys_n_ovn
				Cxx_wup_dstb_h_map_lpg
				Cxx_zon_dif_min_hys
				Cxx_wup_dstb_h_n_lpg
				Cxx_zon_3_dsb_trt_out
				Cxx_run_vh_min_is_n
				Cxx_zon_3_dsb_trt
				Cxx_zon_3_act_trt_out
				Cxx_run_vh_dsb_dly
				Cxx_run_ufld_ctr_inc2
				Cxx_zon_3_act_trt
				Cxx_wet_acel_bch_fil_fac
				Cxx_sa_dly_is_cor
				Cxx_rich_tia_thd
				Cxx_wet_decl_bch_cor_fac
				Cxx_vh_stop_tmp_pwst_cor
				Cxx_vh_stop_pwst_is_cor3
				Cxx_vh_stop_pwst_is_cor2
				Cxx_vh_stop_ini_is_i_ofs
				Cxx_vh_run_tmp_pwst_cor
				Cxx_vh_run_pwst_is_cor3
				Cxx_vh_run_pwst_is_cor2
				Cxx_run_ac_dyn_iga_fac
				Cxx_vh_run_max_is_i_ofs
				Cxx_vs_n_rat_fil_fac_1
				Cxx_vh_run_ini_is_i_ofs
				Cxx_rich_sta_tco_thd
				Cxx_rich_ol_ti_thd
				Cxx_rich_cor_ena_n_thd
				Cxx_rich_cl_tco_thd
				Cxx_rich_cl_alti_fac
				Cxx_rest1_ufld_cor
				Cxx_perf_ac_dsb_gear_thd
				Cxx_vh_run_min_is_i_ofs
				Cxx_run_dyn_iga_ofs
				Cxx_rest_tco_up_ofs_lpg
				Cxx_wet_acel_bch_cor_fac
				Cxx_vvtc_min_iga_cor
				Cxx_vvtc_h_trt
				Cxx_vvtc_dsb_ena_fil_inc
				Cxx_vvtc_angl_tdc_fac
				Cxx_vvtc_act_temp_h_hys
				Cxx_vvtc_act_ena_n_thd
				Cxx_vs_dsb
				Cxx_run_dyn_iga_ofs_lpg
				Cxx_wet_bch_vol_fac
				Cxx_vvt_req_on_tdc
				Cxx_vvt_req_off_tdc
				Cxx_vvt_on_thd
				Cxx_vvt_off_thd
				Cxx_vvt_fill_efv_cam_ofs
				Cxx_vvt_cmd_min_tco
				Cxx_vs_n_rat_fil_fac_3
				Cxx_vs_n_rat_fil_fac_2
				Cxx_vvtc_act_ena_n_hys
				Cxx_mdf1_on_tco_thd_hys
				Cxx_lpg_ad_lpg_min_temp
				Cxx_lpg_ad_min_tco
				Cxx_mdf1_clu_off_dly
				Cxx_lpg_ad_min_prs
				Cxx_mdf1_is_cor
				Cxx_mdf1_is_cor_appl_dly
				Cxx_mdf1_is_cor_appl_dly1
				Cxx_mdf1_is_cor1
				Cxx_lpg_aper_dly
				Cxx_mdf1_on_tco_thd
				Cxx_mdf_cor
				Cxx_mdf1_pow
				Cxx_mdf2_is_cor
				Cxx_lpg_ad_min_n
				Cxx_mdf2_is_cor_appl_dly
				Cxx_mdf2_is_cor_appl_dly1
				Cxx_lpg_ad_max_prs
				Cxx_lpg_ad_max_n
				Cxx_max_run_dyn_iga4
				Cxx_mdf1_off_tco_thd
				Cxx_max_stop_dyn_iga4
				Cxx_mdf2_pow
				Cxx_max_slop_thd_n_ovn
				Cxx_max_slop_tq_rat_ovn
				Cxx_max_stop_ac_dyn_iga
				Cxx_max_stop_ac_dyn_iga1
				Cxx_max_stop_dyn_iga
				Cxx_max_stop_dyn_iga_lpg
				Cxx_max_stop_dyn_iga1
				Cxx_mdf1_clu_dly
				Cxx_max_stop_dyn_iga3
				Cxx_mdf2_is_cor1
				Cxx_max_stop_dyn_iga5
				Cxx_max_tco_fil_ofs2
				Cxx_max_thr_ar
				Cxx_max_ti_ofs1
				Cxx_max_ti_p_cor
				Cxx_max_ti_p_cor_lpg
				Cxx_max_tq_ovn_cor
				Cxx_mdf_1_cmd_ena_thd_tco
				Cxx_max_stop_dyn_iga2
				Cxx_ti_ad_prs_l_thd
				Cxx_tkof_ac_dsb_n_thd
				Tmouto
				Trgmyvsc
				Trgmxvsc
				Table_long_clq_num_regime
				Table_freq_centrale_clq
				Table_facteur_form_clq_num_cyl4
				Table_facteur_form_clq_num_cyl3
				Tmmyvsc
				Cxx_lim_zon_ref_dif_1
				Tiban
				Table_facteur_form_clq_num_cyl2
				Table_facteur_form_clq_num_cyl1
				Table_dec_clq_num_pression
				Table_deb_clq_num_regime
				Srgmnvsc
				Navban
				Seuil_min_reg_detect_cliq
				Rcoban
				Cxx_tkof_ac_dsb_l_thr_thd
				Cxx_lpg_ad_cl_ti_fac_thd
				Cxx_mdf2_off_tco_thd
				Cxx_mdf2_on_tco_thd
				Cxx_no_lim_zon_ref_dif_3
				Cxx_lpg_ad_lpg_max_temp
				Cxx_n_lim_is_dyn_iga_dly
				Cxx_lpg_ad_l_thd
				Cxx_lpg_ad_h_thd
				Cxx_lpg_ad_fac_fac
				Tmmxvsc
				Cxx_med_zon_wid
				Cxx_max_run_dyn_iga3
				Cxx_ti_ad_max_n
				Cxx_lim_zon_ref_dif_3
				Cxx_mem_tco_fail_max_tco
				Cxx_mem_tia_fail_max_tia
				Cxx_mfld_dly_fac
				Cxx_mfld_mdl_fac
				Cxx_mfld_vol_fac
				Cxx_mfld_vol_rat
				Cxx_med_zon_vh_vs_dsb
				Cxx_lpg_tco_ti_cor_fac
				Cxx_tkof_fl_rich_fac
				Cxx_lpg_max_nr_lpg_stal
				Cxx_lpg_max_nr_lpg_stall
				Cxx_lpg_prs_diag_dly
				Cxx_lpg_prs_dif_stab_thd
				Cxx_lpg_prs_dif_trs_thd
				Cxx_lpg_prs_fil_fac
				Cxx_lpg_pump_run_cdn_dly
				Cxx_lpg_gas_pump_wup_dly
				Cxx_lpg_stall_dly
				Cxx_lpg_gas_pump_cut_dly
				Cxx_lpg_wup_cor_dec
				Cxx_lpg_wup_cor_inc
				Cxx_lpg_zon_2_ad_prs_min
				Cxx_lpg_zon_3_ad_prs_min
				Cxx_lpg_zon_4_ad_prs_min
				Cxx_lpg_zon_5_ad_prs_min
				Cxx_tkof_ac_dsb_vs_thd
				Cxx_max_run_dyn_iga5
				Cxx_lpg_rich_cl_tco_thd
				Cxx_lpg_gas_lpg_dly
				Cxx_lpg_aper_pump_run_dly
				Cxx_lpg_cl_lean_diag_dly
				Cxx_lpg_diag_ti_fac_thd
				Cxx_tkof_ac_dsb_pow_thd
				Cxx_lpg_ena_ad_prs_max_thd
				Cxx_tkof_ac_dsb_vs_hys
				Cxx_lpg_ena_ad_prs_min_thd
				Cxx_lpg_fl_lean_diag_dly
				Cxx_lpg_gas_trs_cyc_nr
				Cxx_lpg_gas_dly
				Cxx_map_cut_decl_dly
				Cxx_lpg_gas_lpg_max_n
				Cxx_lpg_gas_lpg_max_prs
				Cxx_lpg_gas_lpg_min_n
				Cxx_lpg_gas_lpg_min_prs
				Cxx_lpg_gas_max_n
				Cxx_lpg_gas_max_prs
				Cxx_lpg_gas_min_n
				Cxx_lpg_gas_min_prs
				Cxx_lpg_flow_fmt_fac
				Cxx_max_prs_fil_ofs2
				Cxx_tkof_ena_vs_thd
				Cxx_max_is_min_ad_pwm
				Cxx_max_is_ocl_t
				Cxx_max_is_ti_ofs2
				Cxx_max_mv_ti_ad_fac
				Cxx_max_mv_ti_ad_ofs
				Cxx_max_n_ad_sp_dif
				Cxx_max_n_fil_ofs2
				Cxx_tkof_h_dyn_efy_cor
				Cxx_max_n_thd_oil_ovn
				Cxx_lpg_aper_n_thd
				Cxx_max_prs_spg_dif
				Cxx_max_run_ac_dyn_iga
				Cxx_max_run_ac_dyn_iga1
				Cxx_max_run_dyn_iga
				Cxx_max_run_dyn_iga_fac
				Cxx_max_run_dyn_iga_lpg
				Cxx_max_run_dyn_iga1
				Cxx_max_run_dyn_iga2
				Cxx_max_n_ovn_ofs
				Cxx_max_cl_ti_fac
				Cxx_map_cut_decl_dly_lpg
				Cxx_tkof_fl_rich_fac_lpg
				Cxx_map_min_thr_adj
				Cxx_map_rat_max_thr_adj
				Cxx_map_slop_inj_cut
				Cxx_max_b0_ini
				Cxx_max_b1_ini
				Cxx_max_b2_ini
				Cxx_max_is_i_ofs
				Cxx_max_b4_ini
				Pcrcoban
				Cxx_max_cld_fac_thd
				Cxx_max_cld_ofs_thd
				Cxx_tkof_fl_tia_thd
				Cxx_max_dif_whl_angl
				Cxx_max_dyn_iga_tq
				Cxx_tkof_gear_thd
				Cxx_max_fast_agb_tq
				Cxx_max_fast_slop_ctr
				Cxx_max_b3_ini
				Cxx_tkof_tqe_fil_fac_2
				Cxx_tkof_mfld_mdl_fac
				Cxx_tkof_n_thd
				Cxx_tkof_tq_d_max
				Cxx_tkof_tq_d_min
				Cxx_tkof_tq_p_max
				Cxx_tkof_tq_p_min
				Cxx_tia_tco_fail_sta_tco
				Cxx_tkof_tqe_fil_fac_1
				Cxx_tkof_ac_dsb_n_hys
				Cxx_tkof_tqe_fil_fac_3
				Cxx_tkof_tqe_grd_fil_fac
				Cxx_tkof_ac_dsb_dly
				Cxx_thr_ar_max_slop
				Cxx_tkof_vs_n_rat_thd
				Cxx_thpl3_is_cor
				Cxx_thpl2_is_cor
				Cxx_tkof_tq_vs_thd
				Cxx_ti_ad_prs_trs_thd
				Cxx_ti_i2_cor_fac
				Cxx_ti_ofs_vs_thd
				Cxx_lbup_tco_rest_thd
				Cxx_ti_ofs_vs_thd_lpg
				Cxx_ti_p_prs_thd
				Cxx_ti_p_prs_thd_lpg
				Cxx_tia_tco_fail_sta_tia
				Cxx_thr_mdl_fil_fac
				Cxx_thpl_tco_hys
				Cxx_tkof_n_hys
				Seuil_max_reg_detect_cliq
				Cxx_ti_p2_cor_fac
				Cxx_tia_fac
				Cxx_tia_iga_cor_prs
				Cxx_tia_max_thr_adj
				Cxx_tia_min_thr_adj
				Cxx_tkof_n_dif_inrt_cge
				Cxx_mvac_n_l_thd
				Cxx_mvac_dp_dec_brk_dft
				Cxx_mvac_dp_dec_vs_dft
				Cxx_mvac_dp_diag_dly
				Cxx_mvac_dp_diag_sta_dly
				Cxx_mvac_dp_h_thd
				Cxx_mvac_dp_inc_dly
				Cxx_thpl1_is_cor
				Cxx_mvac_n_h_thd
				Cxx_mv_vb_fil_fac
				Cxx_mvac_prs_cnt_h_dp_thd
				Cxx_mvac_prs_cnt_l_dp_thd
				Cxx_mvac_prs_dif_thd
				Cxx_mvac_prs_fil_fac
				Cxx_n_cmp_n_is_sp_in_sta
				Cxx_n_drv_puls_thd
				Cxx_n_iga_tco_thd
				Cxx_mvac_dp_l_thd
				Cxx_mon_stop_tco_thd
				Cxx_tkof_n_h_thd
				Cxx_thpl_pow
				Cxx_thpl_off_dly
				Cxx_tkof_ac_dsb_gear_thd
				Cxx_tkof_ac_dsb_h_thr_thd
				Cxx_thpl_is_cor_dly
				Cxx_thpl_is_cor_dec
				Cxx_mvac_dp_chr_l_thd
				Cxx_thd_n_out_thr_adj
				Cxx_mvac_dp_chr_h_thd
				Cxx_mux_mfld_inv_fil_fac
				Cxx_mux_pwst_prs_dly
				Cxx_mv_ad_dly
				Cxx_mv_ad_lsm_ctr_ini
				Cxx_mv_ti_ad_fac_ini
				Cxx_mv_ti_ad_ofs_ini
				Cxx_tkof_vs_thd
				Cxx_thpl_dsb_max_dly
				Offset_avance_banc_
				Cxx_min_dyn_gear_cge_ofs
				Fftibm
				Ntb_whl_spd
				Cxx_min_dyn_iga_tq
				Cxx_tkof_n_l_thd
				Ntibanc
				Ofdbmyba
				Cxx_min_gas_dly
				Cxx_ti_ad1_zon0_ini
				Cxx_ti_ad1_zon1_ini
				Cxx_min_gas_inc
				Cxx_thr_pos_sc_bch
				Cxx_min_iga_dsb_t
				Cxx_ti_ad1_zon2_ini
				Cxx_thr_pos_min_thr_adj
				Cxx_ti_ad_tco_thd
				Cxx_tkof_map_thd
				Cxx_tkof_map_hys
				Cxx_min_cl_ti_fac
				Cxx_min_cld_fac_thd
				Cxx_min_b4_ini
				Cxx_min_b3_ini
				Cxx_min_cld_ofs_thd
				Cxx_min_cp_ti
				Cxx_tkof_l_dyn_efy_cor
				Cxx_min_dif_ti_b
				Cxx_min_b1_ini
				Cxx_thr_psn_cge_fil_fac
				Cxx_min_b0_ini
				Cxx_ti_ad_prs_up_thd
				Cxx_thr_psn_dif_thd
				Cxx_min_ar_grd_thr_adj
				Cxx_min_ad_ofs_thd
				Cxx_min_ad_fac_thd
				Ofdbmyma
				Cxx_min_b2_ini
				Cxx_min_thr_ar
				Cxx_ti_ad1_zon3_ini
				Cxx_min_ovn_cor_fac
				Cxx_min_prs_fil_ofs2
				Cxx_ti_ad1_zon4_ini
				Cxx_min_tco_ad_cor
				Cxx_min_tco_fil_ofs2
				Cxx_min_otl_iga_mv_tqi
				Cxx_ti_i_cor_fac_lpg
				Cxx_min_n_fil_ofs2
				Rrcobanc
				Cxx_min_ti
				Cxx_min_ti_ofs2
				Cxx_min_tq_rat_ovn
				Cxx_min_tqe_fac
				Cxx_min_tqe_fil_fac
				Cxx_min_tqe_tkof
				Cxx_ti_i_cor_fac
				Ofsthman
				Ofban
				Cxx_min_is_min_ad_pwm
				Cxx_min_is_ti_ofs2
				Cxx_min_lpg_cl_n_thd
				Cxx_min_otl_iga_tqi_lpg
				Cxx_min_is_i_2
				Cxx_min_is_i_ofs
				Ofsthban
				Cxx_min_lpg_cl_prs_thd
				Cxx_min_lpg_fl_n_thd
				Cxx_min_lpg_fl_prs_thd
				Cxx_min_is_i
				Cxx_thr_pos_max_thr_adj
				Cxx_min_mv_ti_ad_fac
				Cxx_min_mv_ti_ad_ofs
				Cxx_min_gas_dec
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION OBD_MAP
			""
			/begin DEF_CHARACTERISTIC
				Cxx_cata_asd_cl_stab_dly
				Cbx_tlz_ad_cor_conf
				Ctp_ex_gaz_temp_ofs_vs
				Cxx_cata_asd_diag_nr
				Cxx_cata_asd_in_nr
				Cbx_mena_sa_ev
				Cbx_tq_dft_ini_req
				Cbx_tq_ini_req
				Cxx_cata_win_min
				Cxx_cata_tco_min
				Ctp_tlz_fil_rst_eal_dif
				Cxx_cata_ol_per_dly_stab
				Cbx_mena_vvt_int_old_off
				Cxx_cata_ol_test_max_nr
				Cxx_cata_tb_ofs
				Cxx_cata_ol_thd_lbdw_fil
				Cxx_cata_tb_fac
				Cxx_cata_in_nr
				Cxx_cata_win_max
				Cxx_cata_ol_per_dly
				Cxx_cata_hys_maf
				Cxx_cata_n_min
				Cbx_mena_agb
				Cxx_cata_ofs_neg_1
				Cxx_cata_ofs_neg_2
				Cxx_cata_ofs_ol_lbdw_fil
				Cxx_cata_ofs_pos_1
				Cxx_cata_maf_min
				Cbx_mux_conf_mil
				Cbx_mena_vvt_intake
				Ctb_amp_0_amp_rat_alti
				Cbx_obd_fail_dft_ini_req
				Cxx_cata_ol_apl
				Cbx_mena_wgc
				Cxx_cata_ofs_pos_2
				Ctp_cata_ol_per_dly_maf
				Cmp_det_thd_tlz_dif
				Ctd_mis_n_max_thd_1_2
				Cbx_mis_lih_conf
				Cxx_cata_hys_n
				Ctp_tlz_ad_b_grd_prs
				Cxx_cata_asd_maf_max
				Cxx_cata_asd_maf_mes_max
				Cxx_cata_asd_maf_min
				Cxx_cata_asd_n_max
				Cxx_cata_asd_n_min
				Cxx_cata_asd_sf_nr
				Cxx_cata_n_max
				Cxx_cata_cl_stab_dly_min
				Cxx_cata_asd_maf_dif_max
				Cxx_cata_maf_dif_max
				Cxx_cata_maf_max
				Ctp_ex_gaz_temp_ofs_maf_l
				Ctp_ex_gaz_temp_ofs_maf
				Ctp_ex_gaz_prs_n_temp
				Cxx_cata_ol_per_dly_mes
				Cmp_det_thd_tlz_dif_agb
				Cxx_cata_maf_mes_max
				Cxx_cata_asd_tco_min
				Cbx_mena_tia
				Ctb_mis_tlz_cor_eal
				Ctb_mis_n_17
				Ctb_lbup_prs_min
				Ctb_lamb_diag_n
				Cbx_mena_vvtc_toth_3
				Cmp_mis_tlz_cor_cyl_2
				Cmp_mis_tlz_cor_cyl_1
				Cmp_mis_tlz_cor_cyl_0
				Cbx_mena_mis_cata_1
				Cbx_mena_mis_cata_gas
				Ctd_tlz_ad_b_ena
				Cbx_mena_tlz_ad_b
				Cbx_mena_mis_cata_4
				Cbx_mena_vs
				Ctp_mis_stop_is_iga_dif
				Ctp_tlz_fil_fac
				Ctb_n_tlz_ad_b
				Cbx_mena_mis_cata_3
				Cmp_mis_iga_dif
				Cbx_mena_tco
				Cmp_mis_tq_dif_fac_1_4_dz
				Cbx_mena_pow_lbdw
				Cmp_mis_tq_dif_fac_1_2
				Cmp_mis_tq_dif_fac_1_2_dz
				Cmp_mis_tq_dif_fac_1_4
				Cbx_mena_rams_pdl
				Cbx_mena_obd_sa
				Cbx_mena_obd_lamb
				Cbx_mena_obd_cata
				Cmp_mis_tq_dif_intm_dz
				Cbx_mena_sa
				Ctp_amp_0_amp_rat
				Cmp_mis_tq_dif_fac_intm
				Cbx_mena_spg
				Ctb_mis_tlz_cor_n
				Cbx_mena_mis_polu_4
				Cbx_mena_mis_polu_3
				Cbx_mena_mis_polu_2
				Cbx_mena_mis_polu_1
				Cbx_mena_mis_polu
				Cbx_mena_mis_cata
				Cbx_mena_mis_polu_gas
				Ctb_dft_comb_eal
				Ctp_lbup_ofs_degr_max
				Ctp_cata_lbdw_max_maf
				Cbx_mena_igc_2
				Cbx_mena_igc_1
				Cbx_mena_pow_lbup
				Cbx_mena_gas_pump
				Cmp_mis_cata_degr
				Cbx_mena_fsys
				Cbx_mena_mis_cata_2
				Ctb_dft_comb_eal2
				Cbx_mena_igc_3
				Cbx_mena_flsh_mis_cata
				Cbx_mena_eng_whl
				Cbx_mena_crk_nr
				Cbx_mena_crk
				Cbx_mena_cp
				Cbx_mena_clu
				Cbx_mena_bkup_mem
				Cbx_mena_air
				Ctb_dft_comb_n2
				Cbx_mena_inj3
				Cbx_mena_min_gas_lvl
				Cbx_mena_map
				Cbx_mena_lpg_rcpt
				Cbx_mena_vta_intake
				Cbx_mena_lbup_hot
				Cbx_mena_lbup
				Cbx_mena_lbdw_hot
				Cbx_mena_lbdw
				Ctp_lbup_ofs_degr_min
				Cbx_mena_inj4
				Ctp_lbup_per_max
				Cbx_mena_inj2
				Cbx_mena_inj1
				Cbx_mena_inj_ecu
				Ctp_min_eal_off
				Ctp_min_eal_1_2
				Ctp_min_eal
				Cbx_mena_vvt_int_ev
				Cbx_mena_igc_4
				Cbx_mena_agb_rcpt
				Cbx_mena_knk
				Cxx_lbup_asd_sf_nr
				Cxx_ex_gaz_fil_fac_inj
				Cxx_lbdw_oc_air_wht
				Cxx_lbdw_pump_crt_dly
				Cxx_lbup_asd_diag_nr
				Cxx_lbup_asd_in_nr
				Cxx_lbup_asd_n_max
				Cxx_lbup_asd_n_min
				Cxx_lbup_asd_per_dly
				Cxx_lbup_asd_prs_min
				Cxx_fsys_thd_2_eol_dly
				Cxx_edic_dly
				Cxx_fsys_n_min_thd
				Cxx_lbdw_hot_stt_t
				Cxx_eol_lbdw_oc_air_wht
				Cxx_ex_gaz_cata_max_temp
				Cxx_fsys_n_max_thd
				Cxx_fsys_eol_dly
				Cxx_fsys_eal_min_thd
				Cxx_fsys_eal_max_thd
				Cxx_fsys_dly_2
				Cxx_ex_gaz_cata_min_temp
				Cxx_lbup_asd_tco_min
				Cxx_fsys_dly_1
				Cxx_fsys_cor_fac_min_2
				Cxx_fsys_thd_2_dly
				Cxx_diag_fil_ti_ofs2_fac1
				Cxx_lbup_pump_crt_dly
				Cxx_lbup_prs_max
				Cxx_lbup_per_swi_nr
				Cxx_lbup_per_nr_tot
				Cxx_lbup_per_nr_min
				Cxx_lbup_per_dly
				Cxx_lbup_ofs_stab_dly
				Cxx_lbup_n_min
				Cxx_lbup_n_max
				Cxx_lbup_maf_mes_max
				Cxx_edic_schd_trg_dly
				Cxx_det_wup_tco_ofs
				Cxx_edic_prmt_trg_dly
				Cxx_diag_fil_ti_ofs2_fac2
				Cxx_diag_trs_h_thd
				Cxx_diag_trs_l_thd
				Cxx_down_diag_oc_hot_t
				Cxx_down_eol_diag_hot_t
				Cxx_down_eol_oc_det_v
				Cbx_act_oten
				Cbx_act_edic
				Autorisation_misfire_
				Cxx_lbdw_cata_fil_fac
				Cxx_lbdw_h_lvl_fil_fac
				Cxx_lbup_maf_dif_max
				Cxx_cl2_ena_ctr
				Cxx_cata_wup_sta_obd_eol
				Cxx_lbup_hys_prs
				Cxx_cl_ti_obd_fil_fac
				Cbx_mena_spg_sys
				Cxx_lbup_hys_n
				Cxx_fsys_cor_fac_min_1
				Cxx_lbup_in_nr
				Cxx_lbup_hot_stt_t
				Cxx_fsys_cor_fac_max_2
				Cxx_fsys_cor_fac_max_1
				Cxx_fsys_cor_fac_eol_min
				Cxx_fsys_cor_fac_eol_max
				Cxx_vfnrofm_fsys
				Cxx_trz_ad_b1_val_ini
				Cxx_vfnrofm_eng_whl
				Cxx_vfnrofm_crk_nr
				Cxx_trz_cor_n_max
				Cxx_min_diag_fsys_eol_dly
				Cxx_min_diag_mis_dly
				Cxx_min_diag_fsys_dly
				Cxx_trz_a
				Cxx_trz_ad_b_fil_fac
				Cxx_trz_ad_b_grd_prs
				Cxx_trz_ad_b_nr_tdc
				Cxx_trz_ad_b1_fil_ini
				Cxx_trz_ad_b2_val_ini
				Cxx_trz_b_ini
				Cxx_vfnrofm_crk
				Cxx_trz_n_max
				Cxx_trz_n_min
				Cxx_vfnronm_igc_1
				Cxx_vfnrofm_agb_rcpt
				Cxx_vfnrofm_air
				Cxx_vfnrofm_bkup_mem
				Cxx_vfnrofm_clu
				Cxx_vfnrofm_cp
				Cxx_trz_ad_b2_fil_ini
				Cxx_vfnrofm_sa_ev
				Cxx_vfnrofm_mis_polu
				Cxx_vfnrofm_mis_cata_4
				Cxx_vfnrofm_mis_cata_gas
				Cxx_vfnrofm_mis_polu_1
				Cxx_vfnrofm_mis_polu_2
				Cxx_vfnrofm_mis_polu_3
				Cxx_vfnrofm_mis_polu_4
				Cxx_vfnrofm_mis_polu_gas
				Cxx_vfnrofm_obd_cata
				Cxx_vfnrofm_obd_lamb
				Cxx_vfnrofm_obd_sa
				Cxx_vfnrofm_pow_lbdw
				Cxx_vfnrofm_pow_lbup
				Cxx_vfnrofm_mis_cata_2
				Cxx_min_diag_mis_eol_dly
				Cxx_vfnrofm_vs
				Cxx_vfnrofm_tlz_ad_b
				Cxx_vfnrofm_vta_intake
				Cxx_vfnrofm_tia
				Cxx_vfnrofm_vvt_int_ev
				Cxx_vfnrofm_rams_pdl
				Cxx_obd_conf_mod_1_4
				Cxx_vfnrofm_sa
				Cxx_vfnrofm_vvt_int_old_off
				Cxx_vfnrofm_vvt_intake
				Cxx_vfnrofm_vvtc_toth_3
				Cxx_vfnrofm_spg_sys
				Cxx_vfnrofm_spg
				Cxx_vfnrofm_mis_cata_1
				Cxx_vfnrofm_tco
				Cxx_vfnrofm_inj_ecu
				Cxx_vfnronm_fsys
				Cxx_vfnronm_eng_whl
				Cxx_vfnronm_crk_nr
				Cxx_vfnronm_crk
				Cxx_vfnronm_cp
				Cxx_vfnronm_clu
				Cxx_vfnronm_bkup_mem
				Cxx_vfnronm_air
				Cxx_vfnrofm_gas_pump
				Cxx_vfnrofm_igc_1
				Cxx_vfnrofm_igc_2
				Cxx_vfnrofm_igc_3
				Cxx_vfnronm_agb_rcpt
				Cxx_vfnrofm_mis_cata_3
				Cxx_vfnrofm_lbdw
				Cxx_vfnrofm_mis_cata
				Cxx_vfnrofm_min_gas_lvl
				Cxx_vfnrofm_map
				Cxx_vfnrofm_lpg_rcpt
				Cxx_vfnrofm_lbup_hot
				Cxx_vfnrofm_igc_4
				Cxx_vfnrofm_lbdw_hot
				Cxx_vfnrofm_wgc
				Cxx_vfnrofm_knk
				Cxx_vfnrofm_inj4
				Cxx_vfnrofm_inj3
				Cxx_vfnrofm_inj2
				Cxx_vfnrofm_inj1
				Cxx_vfnronm_gas_pump
				Cxx_vfnrofm_lbup
				Cxx_obd_conf_mod_2_4
				Cxx_obd_min_tia
				Cxx_obd_min_tco
				Cxx_obd_max_tia
				Cxx_obd_max_tco
				Cxx_obd_max_alti
				Cxx_obd_conf_obd
				Cxx_obd_conf_mod_9_4
				Cxx_obd_conf_mod_9_3
				Cxx_obd_conf_mod_9_2
				Cxx_obd_conf_mod_9_1
				Cxx_obd_conf_mod_6_4
				Cxx_obd_conf_mod_6_3
				Cxx_obd_conf_mod_1_2
				Cxx_obd_conf_mod_6_1
				Cxx_maf_clc_fil_fac
				Cxx_obd_conf_mod_2_3
				Cxx_obd_conf_mod_2_2
				Cxx_tlz_a
				Cxx_tlz_ad_b_fil_fac
				Cxx_tlz_ad_b_max
				Cxx_tlz_ad_b_min
				Cxx_tlz_ad_b_n_max
				Cxx_tlz_ad_b_n_max_1
				Cxx_tlz_ad_b_n_max_2
				Cxx_tlz_ad_b_n_max_3
				Cxx_tlz_ad_b_n_max_4
				Cxx_tlz_ad_b_n_max_5
				Cxx_tlz_ad_b_n_max_6
				Cxx_obd_conf_mod_6_2
				Cxx_sa_stop_diag_lbdw_thd
				Cxx_rich_lean_trs_dly
				Cxx_sa_dec_nr
				Cxx_sa_diag_lbdw_thd
				Cxx_sa_eol_tco_min
				Cxx_sa_lbdw_dif_thd
				Cxx_sa_maf_max
				Cxx_sa_maf_min
				Cxx_sa_map_dif_max
				Cxx_sa_map_fac
				Cxx_sa_map_max
				Cxx_sa_map_min
				Cxx_sa_mes_dly
				Cxx_sa_n_dif_max
				Cxx_oten_prmt_trg_dly
				Cxx_stop_edic_rec
				Cxx_tlz_ad_b_n_min_2
				Cxx_map_fil_fac
				Cxx_thr_pos_sc_asd
				Cxx_tco_wup_thd
				Cxx_max_diag_ti_ofs1
				Cxx_sa_n_max
				Cxx_stop_oten_rec
				Cxx_sa_n_min
				Cxx_max_imd_ti_ad_fac
				Cxx_max_imd_ti_ad_ofs
				Cxx_vfnronm_igc_2
				Cxx_sa_vb_min
				Cxx_sa_tco_min
				Cxx_oten_schd_trg_dly
				Cxx_max_eng_eal
				Cxx_mis_lih_mis_nr
				Cxx_tlz_ad_b_n_min
				Cxx_tlz_cor_n_max
				Cxx_tlz_fil_rat
				Cxx_tlz_fil_rst_n_dif_thd
				Cxx_tlz_n_max
				Cxx_tlz_n_min
				Cxx_mis_polu_win_mis_nr
				Cxx_mis_ofs_eal_agb_ena
				Cxx_mis_n_max_thd_1_n
				Cxx_mis_n_max_agb_clos_no
				Cxx_mis_lih_tdc_nr
				Cxx_maf_clc_fac
				Cxx_mis_lih_re_phs_nr
				Cxx_tlz_ad_cor_val_ini
				Cxx_mis_ena_n_min_thd
				Cxx_min_gas_lvl_dly
				Cxx_min_imd_ti_ad_fac
				Cxx_min_imd_ti_ad_ofs
				Cxx_mis_cata_win_mis_nr
				Cxx_mis_cata_win_tdc_nr
				Cxx_mis_lih_out_mis_nr
				Cxx_mis_ena_n_max_thd
				Cxx_mis_lih_n_min
				Cxx_mis_ena_tco_min_thd
				Cxx_mis_fast_win_mis_nr
				Cxx_mis_fast_win_tdc_nr
				Cxx_mis_km_dly
				Cxx_mis_lih_chk_dsb_conf
				Cxx_mis_polu_win_nr_fail
				Cxx_mis_cyl_fail_rat
				Cxx_obd_conf_mod_1_6
				Cxx_min_diag_ti_ofs2
				Cxx_tlz_ad_b_n_min_3
				Cxx_tlz_ad_b_n_min_4
				Cxx_tlz_ad_b_n_min_5
				Cxx_tlz_ad_b_n_min_6
				Cxx_tlz_ad_b_nr_tdc
				Cxx_tlz_ad_b_slow_nr_tdc
				Cxx_tlz_ad_b1_fil_ini
				Cxx_tlz_ad_b2_fil_ini
				Cxx_tlz_ad_cor_fil_fac
				Cxx_tlz_ad_cor_fil_ini
				Cxx_obd_conf_mod_2_1
				Cxx_tlz_ad_cor_n_max
				Cxx_tlz_b_ini
				Cxx_obd_conf_diag_prmt
				Cxx_tlz_ad_cor_nr_tdc
				Cxx_mis_polu_win_tdc_nr
				Cxx_mis_stab_tdc_nr
				Cxx_mux_test_mil_dly
				Cxx_tlz_ad_cor_n_min
				Cxx_obd_conf_mod_1_8
				Cxx_no_min_gas_lvl_dly
				Cxx_obd_conf_mod_1_7
				Cxx_obd_conf_diag_schd
				Cxx_obd_conf_lamb
				Cxx_obd_conf_mod_1_1
				Cxx_obd_conf_mod_1_3
				Cxx_obd_conf_mod_1_5
				Cxx_tlz_ad_b_n_min_1
				Cxx_mux_thr_n_mil_test
				Cxx_vfnrw_lbup_hot
				Cxx_vfnrw_igc_1
				Cxx_vfnrw_mis_polu_4
				Cxx_vfnrw_mis_polu_3
				Cxx_vfnrw_mis_polu_2
				Cxx_vfnrw_mis_polu_1
				Cxx_vfnrw_mis_polu
				Cxx_vfnrw_mis_cata_gas
				Cxx_vfnrw_mis_cata_4
				Cxx_vfnrw_mis_cata_3
				Cxx_vfnrw_mis_cata_1
				Cxx_vfnrw_obd_cata
				Cxx_vfnrw_obd_lamb
				Cxx_vfnrw_map
				Cxx_vfnrw_obd_sa
				Cxx_vfnrw_lbup
				Cxx_vfnrw_lbdw_hot
				Cxx_vfnrw_lbdw
				Cxx_vfnrw_knk
				Cxx_vfnrw_inj4
				Cxx_vfnrw_inj3
				Cxx_vfnrw_inj2
				Cxx_vfnrw_inj1
				Cxx_vfnrw_inj_ecu
				Cxx_vfnrw_igc_4
				Cxx_vfnrw_igc_3
				Cxx_vfnrw_igc_2
				Cxx_vfnrw_min_gas_lvl
				Cxx_vfnrw_vvt_int_ev
				Cxx_vfnronm_igc_3
				Cxx_maf_clc_off_n_max
				Cxx_lbup_stab_dly
				Cxx_lbup_tco_min
				Cxx_lean_rich_trs_dly
				Cxx_lgl_dly_asd_diag_cata
				Cxx_lgl_dly_asd_diag_lbup
				Cxx_lgl_dly_diag_cata
				Cxx_lgl_dly_diag_lbup
				Cxx_vfnrw_wgc
				Cxx_vfnrw_vvtc_toth_3
				Cxx_vfnrw_mis_polu_gas
				Cxx_vfnrw_vvt_int_old_off
				Cxx_vfnrw_mis_cata
				Cxx_vfnrw_vta_intake
				Cxx_vfnrw_vs
				Cxx_vfnrw_tlz_ad_b
				Cxx_vfnrw_tia
				Cxx_vfnrw_tco
				Cxx_vfnrw_spg_sys
				Cxx_vfnrw_spg
				Cxx_vfnrw_sa_ev
				Cxx_vfnrw_sa
				Cxx_vfnrw_rams_pdl
				Cxx_vfnrw_pow_lbup
				Cxx_vfnrw_pow_lbdw
				Cxx_vfnrw_vvt_intake
				Cxx_vfnronm_min_gas_lvl
				Cxx_vfnronm_obd_cata
				Cxx_vfnronm_mis_polu_gas
				Cxx_vfnronm_mis_polu_4
				Cxx_vfnronm_mis_polu_3
				Cxx_vfnronm_mis_polu_2
				Cxx_vfnrw_gas_pump
				Cxx_vfnronm_mis_polu
				Cxx_vfnrw_mis_cata_2
				Cxx_vfnronm_mis_cata_gas
				Cxx_vfnronm_mis_cata_4
				Cxx_vfnronm_mis_cata_3
				Cxx_vfnronm_mis_cata_2
				Cxx_vfnronm_obd_lamb
				Cxx_vfnronm_mis_cata
				Cxx_vfnronm_mis_polu_1
				Cxx_vfnronm_map
				Cxx_vfnronm_lpg_rcpt
				Cxx_vfnronm_lbup_hot
				Cxx_vfnronm_lbup
				Cxx_vfnronm_lbdw_hot
				Cxx_vfnronm_lbdw
				Cxx_vfnronm_knk
				Cxx_vfnronm_inj4
				Cxx_vfnronm_inj3
				Cxx_vfnronm_inj2
				Cxx_vfnronm_inj1
				Cxx_vfnronm_inj_ecu
				Cxx_vfnronm_igc_4
				Cxx_vfnronm_mis_cata_1
				Cxx_vfnrw_air
				Cxx_vfnronm_tlz_ad_b
				Cxx_vfnronm_obd_sa
				Cxx_vfnronm_vta_intake
				Cxx_vfnronm_vvt_int_ev
				Cxx_vfnronm_vvt_int_old_off
				Cxx_vfnronm_vvt_intake
				Cxx_vfnronm_vvtc_toth_3
				Cxx_vfnronm_tia
				Cxx_vfnrw_agb_rcpt
				Cxx_vfnronm_vs
				Cxx_vfnrw_bkup_mem
				Cxx_vfnrw_clu
				Cxx_vfnrw_cp
				Cxx_vfnrw_crk
				Cxx_vfnrw_crk_nr
				Cxx_vfnrw_eng_whl
				Cxx_vfnrw_fsys
				Cxx_vfnronm_wgc
				Cxx_vfnronm_sa_ev
				Cxx_vfnronm_tco
				Cxx_vfnronm_pow_lbdw
				Cxx_vfnronm_pow_lbup
				Cxx_vfnronm_rams_pdl
				Cxx_vfnronm_sa
				Cxx_vfnronm_spg
				Cxx_vfnronm_spg_sys
				Cbx_conf_schd_diag_sa
				Cbx_conf_schd_diag_cata
				Cbx_conf_schd_diag_fsys
				Cbx_conf_schd_diag_lamb
				Cbx_conf_schd_diag_mis
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION OBD_GPL_MAP
			""
			/begin DEF_CHARACTERISTIC
				Ctb_dft_comb_n2_lpg
				Cbx_mena_mis_cata_1_lpg
				Ctb_mis_tlz_cor_n_lpg
				Cbx_mena_mis_polu_2_lpg
				Cbx_mena_mis_cata_2_lpg
				Cmp_mis_tq_dif_fac_1_4_1
				Cbx_mena_fsys_lpg
				Cbx_mena_mis_polu_3_lpg
				Cmp_mis_cata_degr_1
				Cmp_mis_tq_dif_fac_intm_1
				Cbx_mena_mis_polu_4_lpg
				Cbx_mena_mis_cata_3_lpg
				Cmp_mis_tq_dif_1_4_dz_1
				Cxx_diag_trs_l_thd_lpg
				Cbx_mena_lpg
				Cxx_diag_trs_h_thd_lpg
				Cbx_mena_mis_polu_1_lpg
				Cmp_mis_tlz_cor_cyl_0_lpg
				Cbx_mena_mis_cata_lpg
				Cmp_mis_tq_dif_1_2_dz_1
				Cmp_mis_tq_dif_fac_1_2_1
				Cmp_det_thd_tlz_dif_lpg
				Ctb_mis_tlz_cor_eal_lpg
				Cbx_mena_mis_polu_lpg
				Cbx_mena_flsh_mis_cata_lpg
				Cbx_mena_mis_cata_4_lpg
				Cmp_mis_tlz_cor_cyl_2_lpg
				Ctp_tlz_fil_fac_lpg
				Ctb_dft_comb_eal2_lpg
				Cmp_mis_tq_dif_intm_dz_1
				Cmp_mis_tlz_cor_cyl_1_lpg
				Cxx_vfnrofm_mis_cata_1_lpg
				Cxx_vfnrofm_mis_cata_4_lpg
				Cxx_vfnrw_mis_polu_4_lpg
				Cxx_vfnrw_lpg_rcpt
				Cxx_vfnrofm_mis_cata_3_lpg
				Cxx_vfnrw_mis_polu_3_lpg
				Cxx_tlz_fil_rat_lpg
				Cxx_vfnrw_mis_cata_lpg
				Cxx_vfnrw_mis_polu_1_lpg
				Cxx_vfnrw_mis_polu_2_lpg
				Cxx_vfnrw_fsys_lpg
				Cxx_mis_polu_win_mis_nr_1
				Cxx_vfnrw_mis_cata_4_lpg
				Cxx_no_min_lpg_lvl_dly
				Cxx_vfnrofm_mis_cata_2_lpg
				Cxx_vfnronm_fsys_lpg
				Cxx_vfnronm_mis_cata_3_lpg
				Cxx_vfnrw_mis_cata_1_lpg
				Cxx_vfnronm_mis_polu_1_lpg
				Cxx_min_lpg_lvl_dly
				Cxx_vfnrofm_fsys_lpg
				Cxx_vfnronm_mis_polu_2_lpg
				Cxx_vfnronm_mis_cata_lpg
				Cxx_vfnronm_mis_cata_4_lpg
				Cxx_vfnrofm_mis_polu_1_lpg
				Cxx_vfnronm_mis_cata_1_lpg
				Cxx_vfnronm_mis_polu_3_lpg
				Cxx_vfnronm_mis_polu_4_lpg
				Cxx_vfnrofm_mis_cata_lpg
				Cxx_vfnronm_mis_polu_lpg
				Cxx_vfnrw_mis_cata_2_lpg
				Cxx_vfnronm_mis_cata_2_lpg
				Cxx_vfnrofm_mis_polu_lpg
				Cxx_vfnrw_mis_cata_3_lpg
				Cxx_vfnrofm_mis_polu_4_lpg
				Cxx_vfnrofm_mis_polu_3_lpg
				Cxx_vfnrofm_mis_polu_2_lpg
				Cxx_vfnrw_mis_polu_lpg
				Cxx_mis_cata_win_mis_nr_1
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION SDF_Acquisitions_sys
			""
			/begin DEF_CHARACTERISTIC
				Cbx_ffm2_map_chr
				Cbx_ffm1_vb
				Ctp_n_map_fil_fac
				Cbx_ffm2_wat_temp
				Cbx_ffm2_vb
				Cbx_ffm1_wat_temp
				Cbx_ffm2_map
				Cbx_ffm1_map
				Cbx_ffm1_map_chr
				Cxx_pfinc_vb_high
				Cxx_pfinc_vb_low
				Cxx_pfinc_map
				Dft_thr_3_map
				Dft_thr_3_map_chr
				Dft_thr_1_vb_low
				Dft_thr_1_tia
				Cxx_mfnrsta_map
				Cxx_mfnrsta_map_chr
				Seuil_tension_panne_basse_vbr_
				Seuil_regime_tension_bat_basse_
				Dft_thr_2_tia
				Dft_thr_2_vb_low
				Dft_thr_2_map_chr
				Dft_thr_1_map_chr
				Dft_thr_2_map
				Dft_thr_1_map
				Cxx_mfnrsta_vb_low
				Dft_thr_3_vb_low
				Dft_thr_3_tia
				Dft_thr_5_tia
				Dft_thr_5_vb_low
				Dft_thr_0_map_chr
				Dft_thr_4_map
				Dft_thr_0_tia
				Dft_thr_4_tia
				Cxx_pfdec_vb_low
				Temperature_air_acqui_min_
				Cxx_pfdec_vb_high
				Cxx_pfdec_map
				Dft_thr_0_map
				Dft_thr_0_vb_low
				Cxx_pfinc_map_chr
				Dft_thr_4_map_chr
				Cxx_thd_n_diag
				Dft_thr_5_map
				Dft_thr_5_map_chr
				Cxx_pfdec_map_chr
				Temperature_air_acqui_max_
				Dft_thr_4_vb_low
				Cxx_thd_vb_fail
				Cxx_mfnrsta_vb_high
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION SDF_VVT_sys
			""
			/begin DEF_CHARACTERISTIC
				Cbx_ffm2_vvtc_toth_3
				Cbx_ffm1_vvt_int
				Cbx_ffm1_vvt_int_ev
				Cbx_ffm1_vvt_intake
				Cbx_ffm1_vvtc_toth_3
				Cbx_vvtc_pwm_bch
				Cbx_ffm2_vta_intake
				Cbx_ffm2_vvt_int
				Cbx_ffm2_vvt_int_ev
				Cbx_ffm2_vvt_intake
				Cbx_ffm1_vta_intake
				Dft_vvt_0_vta_intake_shift
				Dft_vvt_0_vta_intake_pmh
				Vta_intake_der_mod
				Vta_intake_comp_reg_carto
				Dft_vvt_0_vvt_int_ev_cc0
				Cxx_pfinc_vta_intake_shift
				Vta_intake_der_gain
				Dft_vvt_0_crk_nr
				Dft_vvt_0_crk
				Vta_intake_def_tooth
				Dft_vvt_0_vvt_int_ev_cc1
				Cxx_pfinc_vta_intake_pmh
				Cxx_pfinc_vvt_int_old_off
				Cxx_pfinc_vvtc_toth_3
				Cxx_pfinc_vvt_intake_dyn
				Cxx_pfinc_vvt_intake_bound
				Vta_intake_3_tooth_check
				Vta_intake_advance_configuration
				Cxx_pfinc_vvt_int_ev_oc
				Vta_intake_block_failure_delay
				Cxx_pfinc_vvt_intake_blk
				Vta_intake_cam_offsets_manu_inh
				Vta_intake_camshaft_shift_def
				Cxx_pfinc_vvt_int_ev_vb_sc
				Vta_intake_capture_falling_edge
				Cxx_pfinc_vvt_intake_int
				Cxx_pfinc_vvt_int_ev_scg
				Vta_intake_band
				Vta_intake_to_1
				Vta_intake_int_failure_delay
				Vta_intake_resynchro_manu_inh
				Vta_intake_run_learning_dsb
				Vta_intake_threshold_error
				Cxx_mfnrsta_vta_intake_pmh
				Vta_intake_threshold_int_max
				Vta_intake_threshold_int_min
				Cxx_mfnrsta_vta_intake_shift
				Vta_intake_prop_gain_map
				Cxx_vvtc_pwm_bch
				Vta_intake_prop_gain_bkpt
				Vta_intake_to_2
				Cxx_mfnrsta_vvtc_toth_3
				Cxx_mfnrsta_vvt_intake_int
				Cxx_mfnrsta_vvt_intake_dyn
				Cxx_mfnrsta_vvt_intake_bound
				Cxx_mfnrsta_vvt_intake_blk
				Cxx_mfnrsta_vvt_int_old_off
				Cxx_mfnrsta_vvt_int_ev_vb_sc
				Cxx_mfnrsta_vvt_int_ev_oc
				Vta_intake_learning_oil_max
				Vta_intake_force_off_learning
				Vta_intake_gain_hb
				Vta_intake_higher_def_limit
				Vta_intake_hot_oil_condition
				Vta_intake_init_max_int_value
				Vta_intake_int_gain
				Dft_vvt_0_vvt_intake_dyn
				Vta_intake_vel_calc_mod
				Vta_intake_reference_angle
				Vta_intake_learn_delay
				Vta_intake_dyn_lim
				Vta_intake_learning_oil_min
				Vta_intake_learning_reg_max
				Vta_intake_lower_def_limit
				Vta_intake_min_reg
				Vta_intake_min_reg_inh
				Vta_intake_off_margin
				Vta_intake_old_off_margin
				Vta_intake_pmh_threshold
				Vta_intake_int_inh_band
				Dft_vvt_0_vvt_int_ev_co
				Dft_vvt_1_vvt_intake_int
				Dft_vvt_1_vvt_intake_old_off
				Kcvcpi_learn_zero_offsets
				Kevcpi_u_voltage_comp
				Kfvcpi_initial_current_int
				Kfvcpi_initial_int_step_size
				Kfvcpi_noise_learn_count
				Kfvcpi_phi_peak_to_peak_noise
				Kfvcpi_set_edge_count
				Kfvcpi_t_offset_learn_delay
				Dft_vvt_1_vvt_intake_dyn
				Kfvcpi_u_reference_voltage
				Kfvcpi_k_offset_filter
				Cxx_pfdec_vvtc_toth_3
				Cxx_pfdec_vvt_intake_int
				Cxx_pfdec_vvt_intake_dyn
				Cxx_pfdec_vvt_intake_bound
				Cxx_pfdec_vvt_intake_blk
				Cxx_pfdec_vvt_int_old_off
				Cxx_pfdec_vvt_int_ev_vb_sc
				Cxx_pfdec_vvt_int_ev_scg
				Cxx_pfdec_vvt_int_ev_oc
				Cxx_pfdec_vta_intake_shift
				Cxx_pfdec_vta_intake_pmh
				Kfvcpi_t_zero_set_time
				Dft_vvt_0_vvt_intake_int
				Cxx_mfnrsta_vvt_int_ev_scg
				Dft_vvt_0_vvt_intake_bound
				Dft_vvt_1_vvt_intake_bound
				Dft_vvt_0_vvt_intake_blk
				Dft_vvt_1_vvt_int_ev_cc0
				Dft_vvt_1_vvt_int_ev_cc1
				Dft_vvt_0_vvt_intake_old_off
				Dft_vvt_1_crk
				Dft_vvt_1_crk_nr
				Dft_vvt_1_vta_intake_pmh
				Dft_vvt_1_vta_intake_shift
				Dft_vvt_1_vvt_int_ev_co
				Dft_vvt_1_vvt_intake_blk
				Kfvcpi_phi_maximum_cam_advance
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION VVT_sys
			""
			/begin DEF_CHARACTERISTIC
				Cbx_schd_vvtc_toth_3_pf
				Cbx_mis_polu_vvtc_toth_3_pf
				Cbx_lamb_vvtc_toth_3_pf
				Cxx_h_vvtc_fil_fac
				Cxx_l_vvtc_fil_fac
				Cbx_fsys_vvtc_toth_3_pf
				Consigne_rco_vvt_adm_max
				Consigne_rco_vvt_adm_min
				Cbx_mis_cata_vvtc_toth_3_pf
				Cxx_fil_fac_vvtc_dif
				Seuil_mini_vbatt_activ_vvt_adm
				Cxx_vvtc_in_sp_fil_fac
				Periode_vvt_adm_cal
				Cxx_pb7_conf
				Sens_rco_vvt_adm
				Cxx_vvt_conf
				Cxx_vvt_cmd_min_vb
				Seuil_maxi_vbatt_activ_vvt_adm
				Cbx_cam_long_toth_conf
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION SDF_Voyant_MD
			""
			/begin DEF_CHARACTERISTIC
				Cbx_inj_srs2_dsb_3
				Cbx_inj_srs1_dsb_0
				Cbx_inj_srs2_dsb_5
				Cbx_inj_srs2_dsb_4
				Cbx_inj_srs1_dsb_5
				Cbx_inj_srs2_dsb_2
				Cbx_inj_srs2_dsb_0
				Cbx_inj_srs1_dsb_4
				Cbx_inj_srs1_dsb_3
				Cbx_inj_srs1_dsb_2
				Cbx_inj_srs2_dsb_1
				Cbx_inj_srs1_dsb_1
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION R�gul_Ralenti_sys
			""
			/begin DEF_CHARACTERISTIC
				Ctp_tco_alt_cor
				Cmp_alt_n_fac2
				Ctp_is_d_clc_aj_fac
				Ctb_alt_n
				Cmp_alt_n_lim
				Cmp_alt_n_fac1
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION SDF_Voyant_autre
			""
			/begin DEF_CHARACTERISTIC
				Cbx_ffm1_cp
				Cbx_ffm1_crk_nr
				Cbx_ffm1_cru
				Cbx_ffm2_crk_nr
				Cbx_ffm2_mis_polu_2_lpg
				Cbx_ffm2_mis_polu_3
				Cbx_ffm2_wpmp
				Cbx_ffm2_mis_polu_2
				Cbx_ffm2_alt_load_in
				Cbx_ffm1_crk
				Cbx_ffm2_bkup_mem
				Cbx_ffm2_mis_polu_1
				Cbx_ffm2_mis_cata_lpg
				Cbx_ffm2_mis_polu_1_lpg
				Cbx_ffm2_clu
				Cbx_ffm2_cp
				Cbx_ffm2_crk
				Cbx_ffm2_tlz_ad_b
				Cbx_ffm2_mis_polu
				Cbx_ffm2_pow_lbdw
				Cbx_ffm2_fsys_lpg
				Cbx_ffm2_mvac_pump
				Cbx_ffm1_fsys
				Cbx_ffm2_el_wind_rcpt
				Cbx_ffm2_acr
				Cbx_ffm2_air
				Cbx_ffm2_eng_temp
				Cbx_ffm2_obd_sa
				Cbx_ffm2_agb
				Cbx_ffm1_eng_temp
				Cbx_ffm2_mis_polu_lpg
				Cbx_ffm2_actr_rly
				Cbx_ffm2_actr_rly_cut
				Cbx_ffm2_fsys
				Cbx_ffm2_mis_polu_gas
				Cbx_ffm2_mis_polu_4_lpg
				Cbx_ffm2_cru
				Cbx_ffm2_obd_cata
				Cbx_ffm1_clu
				Cbx_ffm1_wpmp
				Cbx_ffm2_oil
				Cbx_ffm2_mis_lih
				Cbx_ffm2_ac_prs
				Cbx_ffm2_eng_whl
				Cbx_ffm2_mis_polu_4
				Cbx_ffm2_ac_rcpt
				Cbx_ffm2_alt
				Cbx_ffm2_mvac_sys
				Cbx_ffm2_mis_fast
				Cbx_ffm2_mis_polu_3_lpg
				Cbx_ffm2_vs
				Cbx_ffm1_el_wind_rcpt
				Cbx_ffm2_pmh
				Cbx_ffm2_obd_lamb
				Cbx_ffm1_igc_4
				Cbx_ffm2_sa_ev
				Cbx_ffm1_mis_fast
				Cbx_ffm1_mis_lih
				Cbx_ffm1_mis_polu
				Cbx_ffm1_inj2
				Cbx_ffm2_inj4
				Cbx_ffm2_ip_inj_cnt
				Cbx_ffm1_mis_polu_1
				Cbx_ffm1_mis_polu_1_lpg
				Cbx_ffm1_mis_polu_2
				Cbx_ffm1_eng_whl
				Cbx_ffm1_mis_cata_gas
				Cbx_ffm1_inj1
				Cbx_ffm1_inj3
				Cbx_ffm1_igc_3
				Cbx_ffm1_mis_polu_3
				Cbx_ffm1_mis_polu_3_lpg
				Cbx_ffm1_mis_polu_4
				Cbx_ffm1_igc_2
				Cbx_ffm1_igc_1
				Cbx_ffm1_mis_polu_4_lpg
				Cbx_ffm1_mis_polu_gas
				Cbx_ffm1_mis_polu_lpg
				Cbx_ffm1_mvac_pump
				Cbx_ffm2_ptc_rov
				Cbx_ffm1_obd_sa
				Cbx_ffm1_mis_polu_2_lpg
				Cbx_ffm1_mis_cata_2
				Cbx_ffm1_mdf1
				Cbx_ffm1_mastervac
				Cbx_ffm1_mdf2
				Cbx_ffm2_ptc
				Cbx_ffm1_lpg_rcpt
				Cbx_ffm1_min_gas_lvl
				Cbx_ffm1_min_lpg_lvl
				Cbx_ffm1_mis_cata
				Cbx_ffm1_lbup_pump_crt
				Cbx_ffm1_lbup_hot
				Cbx_ffm1_mis_cata_1
				Cbx_ffm1_mis_cata_lpg
				Cbx_ffm1_mis_cata_1_lpg
				Cbx_ffm2_pow_lbup
				Cbx_ffm1_lbdw_pump_crt
				Cbx_ffm1_lbdw_hot
				Cbx_ffm1_lbdw
				Cbx_ffm1_knk
				Cbx_ffm1_ip_inj_cnt
				Cbx_ffm1_inj4
				Cbx_ffm1_mis_cata_2_lpg
				Cbx_ffm1_mis_cata_3
				Cbx_ffm1_mis_cata_3_lpg
				Cbx_ffm1_mis_cata_4
				Cbx_ffm1_mis_cata_4_lpg
				Cbx_ffm2_inj3
				Cbx_ffm1_lbup
				Cbx_ffm2_mis_cata_2_lpg
				Cbx_ffm2_igc_1
				Cbx_ffm2_mastervac
				Cbx_ffm2_mdf1
				Cbx_ffm2_mdf2
				Cbx_ffm2_min_gas_lvl
				Cbx_ffm2_min_lpg_lvl
				Cbx_ffm2_mis_cata
				Cbx_ffm2_mis_cata_1
				Cbx_ffm1_reserve_3
				Cbx_ffm1_sa
				Cbx_ffm1_sa_ev
				Cbx_ffm2_sa
				Cbx_ffm2_mis_cata_2
				Cbx_ffm2_igc_4
				Cbx_ffm2_mis_cata_3
				Cbx_ffm1_swlk
				Cbx_ffm1_tco
				Cbx_ffm1_thpl
				Cbx_ffm2_mis_cata_3_lpg
				Cbx_ffm2_mis_cata_4
				Cbx_ffm1_tia
				Cbx_ffm1_tlz_ad_b
				Cbx_ffm2_mis_cata_4_lpg
				Cbx_ffm1_vs
				Cbx_ffm2_tia
				Cbx_ffm2_reserve_3
				Cbx_ffm2_mis_cata_1_lpg
				Cbx_ffm2_lbup_hot
				Cbx_ffm2_swlk
				Cbx_ffm2_tco
				Cbx_ffm2_thpl
				Cbx_ffm2_knk
				Cbx_ffm2_lbdw
				Cbx_ffm2_lbdw_hot
				Cbx_ffm1_mvac_sys
				Cbx_ffm1_obd_cata
				Cbx_ffm2_lbdw_pump_crt
				Cbx_ffm1_obd_lamb
				Cbx_ffm1_gas_pump
				Cbx_ffm2_igc_2
				Cbx_ffm1_oil
				Cbx_ffm2_igc_3
				Cbx_ffm2_lbup_pump_crt
				Cbx_ffm2_gas_pump
				Cbx_ffm2_lpg_rcpt
				Cbx_ffm1_pmh
				Cbx_ffm1_fsys_lpg
				Cbx_ffm1_pow_lbdw
				Cbx_ffm1_pow_lbup
				Cbx_ffm1_ptc
				Cbx_ffm1_ptc_rov
				Cbx_ffm2_inj2
				Cbx_ffm2_inj1
				Cbx_ffm2_mis_cata_gas
				Cbx_ffm2_lbup
				Cbx_ffm1_ac_rcpt
				Cbx_ffm1_actr_rly_cut
				Cbx_ffm1_agb
				Cbx_ffm1_air
				Cbx_ffm1_alt
				Cbx_ffm1_acr
				Cbx_ffm1_bkup_mem
				Cbx_ffm1_alt_load_in
				Cbx_ffm1_ac_prs
				Cbx_ffm1_actr_rly
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION VSC_sys
			""
			/begin DEF_CHARACTERISTIC
				Tmatvsc
				Tmatsta
				Tmdefva
				Rgmnvsc
				Tmatdem
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION SDF_sys
			""
			/begin DEF_CHARACTERISTIC
				Cxx_l_thd_prs_l_fail
				Cxx_dif_mes_esti_prs_err
				Cxx_h_thd_prs_h_fail
				Cbx_rgb_conf
				Cxx_nr_tdc_dif_prs_fail
				Cxx_rel_thd_thr_prs_h_err
				Cxx_min_n_test_acq
				Cxx_max_mes_prs_fail_sens
				Cxx_min_mes_prs_fail_sens
				Tension_alim_capteur_maxi_sdf_
				Cxx_max_val_dif_prs_acq
				Cxx_mfnrsta_cru_brk_cnt2
				Cxx_mfnrsta_cru_on_off_chr
				Tension_alim_capteur_mini_sdf_
				Cxx_mfnrsta_cru_brk_cnt1
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION Verrou_sys
			""
			/begin DEF_CHARACTERISTIC
				Cbx_swlk_dsb
				Tmattrps
				Tmatscan
				Serievl
				Tmwlvl
				Cnrztvl
				Tmclear
				Tmattski
				Tmotopro
				Specifreq
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION SDF_Sural_sys
			""
			/begin DEF_CHARACTERISTIC
				Cbx_ffm1_spg_sys
				Cbx_up_thr_prs_sens
				Cbx_ffm2_spg
				Cbx_ffm1_wgc
				Cbx_ffm1_spg
				Cbx_ffm2_spg_sys
				Cbx_ffm2_wgc
				Ctb_tq_stat_ref
				Cxx_min_amp
				Cxx_mfnrsta_wgc_scg
				Cxx_pfinc_wgc_vb_sc
				Cxx_mfnrsta_wgc_oc
				Cxx_mfnrsta_wgc_vb_sc
				Cxx_pfdec_wgc_vb_sc
				Cxx_pfinc_wgc_scg
				Dft_thr_1_spg
				Dft_thr_1_spg_sys
				Cxx_max_amp
				Dft_thr_1_wgc
				Dft_thr_2_spg
				Dft_thr_2_spg_sys
				Cxx_stab_spg_dif_thd
				Cxx_spg_fail_ctr
				Cxx_spg_fail_up_thd
				Dft_thr_3_spg
				Cxx_spg_n_thd
				Cxx_pfdec_spg
				Cxx_pfdec_spg_sys
				Cxx_pfdec_wgc_scg
				Cxx_spg_fail_l_thd
				Cxx_pfdec_wgc_oc
				Dft_thr_4_spg
				Cxx_spg_min
				Dft_thr_2_wgc
				Dft_thr_5_wgc
				Dft_thr_3_wgc
				Dft_thr_3_spg_sys
				Dft_thr_4_spg_sys
				Cxx_spg_diag_dsb
				Dft_thr_4_wgc
				Cxx_mfnrsta_spg_sys
				Cxx_pfinc_wgc_oc
				Cxx_mfnrsta_spg
				Cxx_spg_diag_max_tia
				Cxx_pfinc_spg
				Cxx_pfinc_spg_sys
				Dft_thr_0_spg
				Dft_thr_0_spg_sys
				Dft_thr_0_wgc
				Dft_thr_5_spg_sys
				Dft_thr_5_spg
				Cxx_spg_diag_min_tia
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION Sural_sys
			""
			/begin DEF_CHARACTERISTIC
				Consigne_rco_wastegate_min
				Consigne_rco_wastegate_max
				Cxx_mfnrsta_wpmp_vb_sc
				Cxx_pfinc_wpmp_vb_sc
				Cxx_mfnrsta_wpmp_scg
				Seuil_maxi_vbatt_activ_wastegate
				Cxx_mfnrsta_wpmp_oc
				Cxx_pfinc_wpmp_scg
				Cxx_pfinc_wpmp_oc
				Cxx_pfdec_wpmp_oc
				Cxx_pfdec_wpmp_scg
				Cxx_pfdec_wpmp_vb_sc
				Seuil_mini_vbatt_activ_wastegate
				Pres_sural_ad_conv_offset
				Periode_wastegate_turbo
				Pres_sural_ad_conv_gain
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION SDF_Etats_moteur_sys
			""
			/begin DEF_CHARACTERISTIC
				Cxx_h_thd_dif_prs_dsb_sp
				Cxx_crk_toth_nr
				Cxx_crk_nr_dft_n_min
				Cxx_h_dif_prs_dsb_sp
				Cxx_crk_nr_dft_n_max
				Cxx_h_thd_prs_sp_fail
				Cxx_l_thd_dif_prs_dsb_sp
				Cxx_nr_vld_crk_fail1
				Cxx_off_crk_dly
				Cxx_stal_det_thd
				Cxx_min_t_toth
				Cxx_max_t_toth
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION RVLV_sys
			""
			/begin DEF_CHARACTERISTIC
				Cxx_cru_lk_ena_dly
				Cxx_cru_sl_sp_inc_t
				Cxx_cru_abst_vs_dly
				Cxx_cru_cmf_cut_tqe_dec
				Cxx_cru_efv_vs_thd
				Cbx_sys_wf_conf
				Cxx_brk_min_decl_thd
				Ctd_gear_red_rat
				Cxx_cru_max_vs
				Cxx_brk_det_dly
				Cxx_cru_sl_rls_min_rat
				Cxx_cru_svkl_ig
				Cxx_cru_sl_rls_max_rat
				Cxx_cru_sl_smal_step
				Cxx_cru_sl_swi_dly
				Cxx_cru_min_vs
				Cxx_cru_sl_long_sp_inc_t
				Cxx_cru_vs_sp_rat
				Cxx_cru_svkl_vs_thd
				Cxx_cru_sl_warn_dly
				Cxx_cru_svkl_pg
				Cxx_cru_sl_whl_swi_dly
				Cxx_cru_sp_acel_grd
				Cxx_cru_svkl_min_i_cor
				Cxx_cru_svkl_max_i_cor
				Cxx_cru_sl_long_sp_dec_t
				Cxx_cru_sp_max_inc
				Cxx_cru_sp_decl_grd
				Cxx_cru_sl_susp_max_rat
				Ctb_cru_sl_vs
				Cxx_cru_sl_acel_min_rat
				Cxx_cru_sl_nok_swi_dly
				Cxx_cru_sl_acel_max_rat
				Cxx_cru_min_tq
				Cxx_cru_sl_decl_min_rat
				Cxx_cru_sl_nok_whl_swi_dly
				Cxx_cru_ref_vs_decl_grd
				Cxx_cru_sl_fil_acel_fac
				Cxx_cru_sl_fil_vs_fac
				Cxx_cru_sl_decl_max_rat
				Cxx_cru_ref_vs_acel_ofs
				Cxx_cru_ref_vs_decl_ofs
				Cxx_cru_ref_vs_acel_grd
				Cxx_cru_sl_open_min_rat
				Cxx_cru_sl_lk_ena_dly
				Cxx_cru_sl_resu_max_rat
				Cxx_cru_sl_long_step
				Cxx_cru_sl_lk_vb_thd
				Ctb_gear
				Cxx_cru_nok_vs_dly
				Cxx_cru_no_efv_vs_thd
				Cxx_cru_sl_resu_min_rat
				Ctp_dyn_forc
				Cxx_lih_dly
				Cxx_sp_vs_dif_brk_det
				Cxx_sl_svkl_max_i_cor
				Cxx_pfdec_cru_brk_cnt1
				Cxx_sl_svkl_min_i_cor
				Cxx_sudn_brk_min_decl_thd
				Cxx_no_chr_brk_dly
				Cxx_pfdec_cru_whl_cmd
				Cxx_pfdec_cru_on_off_chr
				Cxx_vs_n_rat_fil_fac
				Cxx_vs_n_rat_min
				Cxx_pfdec_cru_brk_cnt2
				Cxx_sl_svkl_pg
				Cxx_whl_rad
				Cxx_sl_cmf_cut_tqe_inc
				Cxx_sudn_brk_det_dly
				Cxx_n_min_cru_sl_dsb
				Cxx_pfinc_cru_brk_cnt1
				Cxx_pfinc_cru_brk_cnt2
				Cxx_vh_wht
				Cxx_pfinc_cru_on_off_chr
				Cxx_pfinc_cru_whl_cmd
				Cxx_pdl_frm_dec
				Cxx_pdl_frm_inc
				Cxx_sl_svkl_vs_thd
				Cxx_n_max_cru_sl_dsb
				Cxx_sl_svkl_ig
				Cxx_sl_efv_vs_thd
				Cxx_sl_lk_ena_dly
				Cxx_vs_n_rat_max
				Cxx_sl_sp_max_dec
				Cxx_sl_max_tq
				Cxx_sl_max_vs
				Cxx_sl_min_vs
				Cxx_sl_no_efv_vs_thd
				Cbx_cru_sl_wit_vs_n_rat
				Cbx_cru_sl_stt_ip
				Cbx_cru_sl_no_lim_grd
				Cbx_cru_sl_lk_rls_ena
				Cbx_cru_sl_dspl_pres
				Cbx_cru_sl_dspl_vs
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION SDF_LIS_sys
			""
			/begin DEF_CHARACTERISTIC
				Cxx_asr_ctr
				Cxx_agb_clck_max_val
				Cxx_asr_msr_abst_dly
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION SDF_VVT_voyant_MD
			""
			/begin DEF_CHARACTERISTIC
				Cbx_inj_srs1_dsb_vvtc_1
				Cbx_inj_srs2_dsb_vvtc_0
				Cbx_inj_srs2_dsb_vvtc_1
				Cbx_inj_srs1_dsb_vvtc_0
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION SDF_Alim_sys
			""
			/begin DEF_CHARACTERISTIC
				Cbx_ffm1_pws
				Cbx_ffm2_pws
				Cxx_pfinc_pws_pdl2
				Cxx_pfinc_pws_thr_pdl1
				Cxx_pfdec_pws_pdl2
				Cxx_pfinc_pws_2
				Cxx_pfinc_pws_1
				Cxx_pfdec_pws_2
				Cxx_pfdec_pws_1
				Dft_thr_4_pws_thr_pdl1
				Dft_thr_4_pws_pdl2
				Dft_thr_0_pws_pdl2
				Cxx_mfnrsta_pws_pdl2
				Dft_thr_5_pws_pdl2
				Dft_thr_5_pws_thr_pdl1
				Cxx_mfnrsta_pws_thr_pdl1
				Cxx_pfdec_pws_thr_pdl1
				Cxx_mfnrsta_pws_2
				Dft_thr_1_pws_thr_pdl1
				Dft_thr_0_pws_thr_pdl1
				Dft_thr_1_pws_pdl2
				Cxx_mfnrsta_pws_1
				Dft_thr_2_pws_thr_pdl1
				Dft_thr_2_pws_pdl2
				Dft_thr_3_pws_pdl2
				Dft_thr_3_pws_thr_pdl1
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION SDF_BVA_sys
			""
			/begin DEF_CHARACTERISTIC
				Cxx_pfdec_agb_tq_nok
				Cxx_pfinc_agb_tq_nok
				Cxx_pfinc_agb_rcpt
				Cxx_pfdec_agb_rcpt
				Cxx_mfnrsta_agb_tq_nok
				Cbx_agb_conf
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION SDF_Calculateur
			""
			/begin DEF_CHARACTERISTIC
				Cbx_ffm2_checksum
				Cbx_ffm1_rmc
				Cbx_ffm1_spi_cc
				Cbx_ffm2_inj_ecu
				Cbx_ffm1_inj_ecu
				Cbx_ffm2_rmc
				Cbx_ffm2_spi_cc
				Dft_thr_2_rmc_comspipp
				Cxx_mfnrsta_checksum
				Dft_thr_1_rmc_monitpp
				Dft_thr_1_rmc_papmpp
				Dft_thr_1_rmc_pedmpp
				Dft_thr_1_rmc_timeoutpp
				Cxx_mfnrsta_inj_ecu
				Cxx_pfdec_rmc_comspipp
				Dft_thr_1_rmc_inhwp
				Cxx_pfdec_rmc_monitpp
				Dft_thr_1_rmc_comspipp
				Cxx_pfinc_checksum
				Cxx_pfinc_rmc_algopp
				Cxx_pfinc_rmc_clockpp
				Cxx_pfinc_rmc_comspipp
				Cxx_pfinc_rmc_inhwp
				Cxx_pfinc_rmc_monitpp
				Cxx_pfinc_rmc_papmpp
				Cxx_pfinc_rmc_pedmpp
				Cxx_pfdec_rmc_papmpp
				Cxx_pfdec_rmc_algopp
				Dft_thr_2_rmc_pedmpp
				Cxx_pfdec_rmc_clockpp
				Dft_thr_2_rmc_timeoutpp
				Dft_thr_2_rmc_clockpp
				Dft_thr_2_rmc_algopp
				Dft_thr_2_checksum_faux
				Cxx_pfdec_spi_cc
				Cxx_pfinc_inj_ecu
				Dft_thr_2_rmc_inhwp
				Dft_thr_2_rmc_papmpp
				Cxx_pfdec_rmc_timeoutpp
				Dft_thr_4_rmc_inhwp
				Cxx_pfinc_rmc_timeoutpp
				Cxx_pfdec_rmc_inhwp
				Cxx_pfdec_rmc_pedmpp
				Dft_thr_1_checksum_faux
				Dft_thr_1_rmc_algopp
				Dft_thr_1_rmc_clockpp
				Dft_thr_2_rmc_monitpp
				Dft_thr_3_rmc_inhwp
				Dft_thr_5_rmc_inhwp
				Dft_thr_4_rmc_timeoutpp
				Cxx_mfnrsta_rmc_papmpp
				Dft_thr_3_rmc_timeoutpp
				Dft_thr_3_rmc_pedmpp
				Dft_thr_3_rmc_papmpp
				Dft_thr_5_rmc_monitpp
				Dft_thr_5_rmc_papmpp
				Dft_thr_5_rmc_pedmpp
				Dft_thr_5_rmc_timeoutpp
				Cxx_pfdec_inj_ecu
				Dft_thr_3_rmc_monitpp
				Cxx_pfdec_checksum
				Dft_thr_3_rmc_comspipp
				Seuil_detection_panne_horloge_
				Dft_thr_3_rmc_clockpp
				Dft_thr_3_rmc_algopp
				Dft_thr_4_rmc_papmpp
				Dft_thr_3_checksum_faux
				Dft_thr_4_rmc_pedmpp
				Dft_thr_4_rmc_algopp
				Dft_thr_4_rmc_clockpp
				Dft_thr_4_rmc_comspipp
				Cxx_mfnrsta_rmc_pedmpp
				Dft_thr_0_rmc_comspipp
				Dft_thr_4_checksum_faux
				Cxx_mfnrsta_rmc_inhwp
				Cxx_mfnrsta_rmc_comspipp
				Cxx_mfnrsta_spi_cc
				Dft_thr_0_rmc_timeoutpp
				Dft_thr_0_rmc_pedmpp
				Cxx_pfinc_spi_cc
				Dft_thr_0_rmc_papmpp
				Cxx_mfnrsta_rmc_monitpp
				Dft_thr_0_checksum_faux
				Dft_thr_0_rmc_inhwp
				Dft_thr_4_rmc_monitpp
				Cxx_mfnrsta_rmc_timeoutpp
				Cxx_mfnrsta_rmc_clockpp
				Dft_thr_5_rmc_algopp
				Dft_thr_0_rmc_clockpp
				Dft_thr_5_checksum_faux
				Dft_thr_0_rmc_algopp
				Cxx_mfnrsta_rmc_algopp
				Dft_thr_5_rmc_clockpp
				Dft_thr_5_rmc_comspipp
				Dft_thr_0_rmc_monitpp
				Cbx_ffm1_checksum
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION SDF_CAN_sys
			""
			/begin DEF_CHARACTERISTIC
				Cbx_ffm2_tjy_ctl
				Cbx_ffm1_tjy_ctl
				Cxx_mfnrsta_tjy_ctl
				Cxx_pfdec_tjy_ctl
				Cxx_pfinc_tjy_ctl
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION SDF_Configuration_sys
			""
			/begin DEF_CHARACTERISTIC
				Cbx_brk_pdl_conf
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION Services_diag_sys
			""
			/begin DEF_CHARACTERISTIC
				Cxx_fac_n_mmv
				Cfgpsobd
				Autorisation_test_power_latch_
				Temps_apres_test_actionneur_
				Test_stat_duree_ho2_
				Fcinjcyc
				Test_stat_duree_divers_1_
				Test_stat_duree_actionneurs_
				Cxx_n_min_mmv
				Table_temps_test_actionneur
				Tmdiamux
				Fcallof
				Fcinjoff
				Fcallon
				Fcinjon
				Idinjpas
				Srgdmux
				Table_nb_cycle_test_actionneur_
				Fcallcyc
				Pap_poson
				Test_stat_duree_divers_2_
				Pap_posoff
				Idpasbas
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION SDF_Pression_sys
			""
			/begin DEF_CHARACTERISTIC
				Cxx_amp_prs_dif_thd
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION SDF_P�dale_sys
			""
			/begin DEF_CHARACTERISTIC
				Cbx_ffm1_pdl
				Cbx_ffm1_rams_pdl
				Cxx_h_pdl_psn_ofs
				Cbx_ffm2_rams_pdl
				Ctp_pdl_psn_fil_mes_v2_v1
				Cxx_ct_pdl_mem_ofs
				Cxx_ct_pdl_psn_hys
				Cxx_ct_pdl_psn_thd
				Cxx_ct_dsb_pdl_psn_thd
				Aps_coh_filter_gain_
				Cxx_l_pdl_psn_ofs
				Cxx_ct_dsb_pdl_psn_dif
				Cbx_ffm2_pdl
				Ctp_v1_v2_max_dif
				Cxx_ct_pdl_ofs
				Dft_thr_2_pdl_sens2_vb_sc
				Dft_thr_1_sens_pdl
				Cxx_mfnrsta_pdl_sens1_vb_sc
				Cxx_mfnrsta_pdl_sens1_oc
				Cxx_mfnrsta_rams_pdl
				Cxx_mfnrsta_pdl_sens_chr
				Dft_thr_2_rams_pdl
				Dft_thr_0_sens_pdl
				Cxx_rams_max_ct_pdl
				Dft_thr_1_pdl_sens_chr
				Cxx_rams_min_ct_pdl
				Dft_thr_2_pdl_sens2_oc
				Cxx_pfinc_pdl_sens_chr
				Cxx_pfinc_pdl_sens1_oc
				Cxx_pfinc_pdl_sens1_vb_sc
				Cxx_pfinc_pdl_sens2_oc
				Dft_thr_2_pdl_sens1_vb_sc
				Cxx_pfinc_pdl_sens2_vb_sc
				Dft_thr_3_pdl_sens2_vb_sc
				Dft_thr_1_pdl_sens2_oc
				Cxx_mfnrsta_pdl_sens2_vb_sc
				Dft_thr_3_pdl_sens2_oc
				Dft_thr_4_pdl_sens1_oc
				Dft_thr_3_pdl_sens1_vb_sc
				Dft_thr_4_sens_pdl
				Dft_thr_4_sens_thr
				Dft_thr_3_pdl_sens1_oc
				Dft_thr_3_pdl_sens_chr
				Dft_thr_3_rams_pdl
				Dft_thr_4_pdl_sens2_vb_sc
				Dft_thr_4_pdl_sens1_vb_sc
				Dft_thr_3_sens_thr
				Dft_thr_4_pdl_sens_chr
				Cxx_rams_pdl_max_psn_thd
				Cxx_rams_pdl_dif
				Dft_thr_5_pdl_sens1_vb_sc
				Dft_thr_5_sens_thr
				Dft_thr_3_sens_pdl
				Cxx_pfdec_rams_pdl
				Dft_thr_5_pdl_sens_chr
				Cxx_mfnrsta_pdl_sens2_oc
				Cxx_pdl_slow_ad_trs_nr
				Cxx_v2_max_thd_vld
				Dft_thr_4_rams_pdl
				Dft_thr_1_rams_pdl
				Dft_thr_2_sens_thr
				Dft_thr_1_pdl_sens1_vb_sc
				Dft_thr_1_pdl_sens1_oc
				Dft_thr_0_sens_thr
				Dft_thr_4_pdl_sens2_oc
				Cxx_pdl_ufld_psn_thd
				Cxx_v1_min_thd_vld
				Dft_thr_5_sens_pdl
				Cxx_pdl_max_psn_thd
				Cxx_pdl_fast_ad_trs_nr
				Dft_thr_5_rams_pdl
				Dft_thr_5_pdl_sens2_vb_sc
				Dft_thr_5_pdl_sens2_oc
				Cxx_pfinc_rams_pdl
				Cxx_v2_min_thd_vld
				Dft_thr_1_sens_thr
				Dft_thr_0_pdl_sens2_vb_sc
				Dft_thr_1_pdl_sens2_vb_sc
				Dft_thr_2_sens_pdl
				Cxx_pfdec_pdl_sens2_vb_sc
				Cxx_pfdec_pdl_sens2_oc
				Dft_thr_5_pdl_sens1_oc
				Dft_thr_0_pdl_sens_chr
				Dft_thr_0_pdl_sens1_oc
				Dft_thr_0_pdl_sens2_oc
				Cxx_pfdec_pdl_sens_chr
				Cxx_pfdec_pdl_sens1_vb_sc
				Cxx_rams_ct_pdl_psn
				Dft_thr_2_pdl_sens1_oc
				Dft_thr_0_rams_pdl
				Cxx_v1_max_thd_vld
				Dft_thr_2_pdl_sens_chr
				Cxx_pfdec_pdl_sens1_oc
				Dft_thr_0_pdl_sens1_vb_sc
				Cbx_clu_cnt_inv
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION SDF_Papillon_sys
			""
			/begin DEF_CHARACTERISTIC
				Ctp_thr_mcut_ol_v
				Cbx_ffm1_mcut_sens1
				Cbx_ffm1_thr_cmd
				Cbx_ffm2_svkl
				Cxx_l_trt_rate_lim_thd
				Cbx_ffm2_thr
				Cbx_ffm1_thr
				Ctb_thr_sge_psn
				Cbx_thr_mcut_ena
				Cbx_thr_sge_ena
				Cbx_thr_vdo_pwm_select
				Cxx_1_thr_ad_lh_lim_max
				Cxx_2_thr_ad_lh_lim_max
				Cbx_ffm2_mcut_sens1
				Cbx_ffm2_thr_cmd
				Ctb_thr_mcut_psn
				Cxx_filt_output_pdt1_coef
				Cxx_l_trt_limit_sp
				Cxx_filt_input_pdt1_coef
				Cbx_ffm1_svkl
				Ctp_thr_sge_ol_v
				Dft_thr_4_svkl_lih
				Cxx_thr_sge_err_dly
				Cxx_pfdec_thr_sens2_vb_sc
				Cxx_thr_sge_err_thd
				Cxx_thr_sge_fil_fac_1
				Tpac_1_closed_pos_min_
				Cxx_thr_sge_fil_fac_2
				Cxx_thr_sge_fil_fac_3
				Dft_thr_4_svkl_oc
				Cxx_thr_sge_fil_fac_4
				Tpac_dithering_filter_coef_
				Dft_thr_4_thr_sens_chr
				Cxx_thr_sge_fil_fac_5
				Cxx_thr_sge_svkl_int_thd
				Cxx_thr_sge_svkl_ol_dly
				Tpac_1_closed_pos_max_
				Cxx_pfdec_thr_sens2_scg
				Dft_thr_4_thr_cmd_cpt
				Dft_thr_4_thr_cmd_vb_sc
				Dft_thr_4_svkl_sge
				Cxx_thr_mcut_chr_thd
				Tpac_check_limp_home_delay
				Tpac_2_open_pos_max_
				Tpac_2_open_pos_min_
				Cxx_mfnrsta_mcut_sens1
				Dft_thr_1_chk_springs
				Cxx_mfnrsta_thr_sens2_vb_sc
				Cxx_pfdec_mcut_sens1
				Dft_thr_0_thr_sens2_vb_sc
				Dft_thr_0_thr_sens2_scg
				Cxx_pfdec_svkl_lih
				Dft_thr_0_mcut_sens1
				Tpac_2_closed_pos_min_
				Cxx_thr_sge_dsb_dly
				Dft_thr_0_thr_sens1_vb_sc
				Dft_thr_0_thr_sens1_oc
				Dft_thr_0_thr_sens_chr
				Dft_thr_0_thr_cmd_vb_sc
				Dft_thr_0_servcoh_papdw
				Dft_thr_0_servcoh_papup
				Dft_thr_0_svkl_lih
				Dft_thr_0_svkl_oc
				Dft_thr_0_thr_cmd_cpt
				Dft_thr_0_chk_springs
				Dft_thr_0_svkl_sge
				Cxx_pfdec_thr_sens1_oc
				Cxx_pfdec_thr_sens_chr
				Cxx_pfdec_thr_cmd_vb_sc
				Cxx_pfdec_thr_cmd_cpt
				Cxx_mfnrsta_svkl_chk_springs
				Cxx_mfnrsta_thr_sens2_scg
				Cxx_trt_clos_frst_srch_sp
				Cxx_pfdec_svkl_trt_srch
				Cxx_pfdec_svkl_sge
				Cxx_pfdec_svkl_psn
				Tpac_2_limp_home_min_
				Cxx_pfdec_svkl_chk_springs
				Tpac_2_limp_home_max_
				Tpac_1_limp_home_max_
				Tpac_1_limp_home_min_
				Tpac_1_open_pos_max_
				Dft_thr_1_mcut_sens1
				Dft_thr_4_servcoh_papdw
				Tpac_1_open_pos_min_
				Sdf_limp_home_position_thresh_
				Dft_thr_4_servcoh_papup
				Tpac_2_closed_pos_max_
				Cxx_pfdec_thr_sens1_vb_sc
				Cxx_pfdec_svkl_oc
				Cxx_pfinc_thr_sens2_vb_sc
				Cxx_pfinc_svkl_trt_srch
				Dft_thr_5_thr_cmd_cpt
				Cxx_pfinc_thr_cmd_cpt
				Cxx_pfinc_thr_cmd_vb_sc
				Cxx_pfinc_thr_sens_chr
				Cxx_pfinc_thr_sens1_oc
				Tps_position_tolerance_
				Cxx_pfinc_thr_sens2_scg
				Cxx_pfinc_svkl_oc
				Dft_thr_5_svkl_sge
				Dft_thr_5_svkl_oc
				Dft_thr_5_svkl_lih
				Tps_2_default_cc_thresh_
				Tps_2_default_scg_thresh
				Dft_thr_5_servcoh_papup
				Dft_thr_2_chk_springs
				Cxx_pfinc_thr_sens1_vb_sc
				Dft_thr_2_servcoh_papup
				Dft_thr_2_mcut_sens1
				Cxx_mfnrsta_svkl_trt_srch
				Tpc_comp_diag_inh_delay_
				Dft_thr_2_servcoh_papdw
				Dft_thr_5_thr_sens2_vb_sc
				Dft_thr_5_thr_sens2_scg
				Dft_thr_5_thr_sens1_vb_sc
				Cxx_pfinc_svkl_sge
				Dft_thr_5_thr_sens_chr
				Cxx_pfinc_svkl_psn
				Dft_thr_5_thr_cmd_vb_sc
				Cxx_mfnrsta_svkl_lih
				Tps_1_default_co_thresh_
				Cxx_thr_mcut_det_thd
				Cxx_pfinc_svkl_chk_springs
				Cxx_pfinc_svkl_lih
				Dft_thr_2_svkl_lih
				Dft_thr_5_thr_sens1_oc
				Dft_thr_3_svkl_sge
				Dft_thr_3_servcoh_papdw
				Dft_thr_3_servcoh_papup
				Cxx_mfnrsta_thr_cmd_vb_sc
				Dft_thr_5_chk_springs
				Dft_thr_4_chk_springs
				Cxx_mfnrsta_thr_cmd_cpt
				Tps_coh_filter_gain_
				Dft_thr_3_svkl_oc
				Cxx_mfnrsta_thr_sens_chr
				Dft_thr_3_thr_cmd_cpt
				Dft_thr_3_thr_cmd_vb_sc
				Dft_thr_3_thr_sens_chr
				Dft_thr_3_thr_sens1_oc
				Dft_thr_3_thr_sens1_vb_sc
				Dft_thr_3_thr_sens2_scg
				Dft_thr_3_thr_sens2_vb_sc
				Dft_thr_3_svkl_lih
				Dft_thr_2_thr_sens2_vb_sc
				Dft_thr_2_svkl_oc
				Dft_thr_2_svkl_sge
				Dft_thr_2_thr_cmd_cpt
				Dft_thr_2_thr_cmd_vb_sc
				Dft_thr_2_thr_sens_chr
				Dft_thr_5_servcoh_papdw
				Dft_thr_2_thr_sens1_oc
				Dft_thr_4_thr_sens2_vb_sc
				Dft_thr_2_thr_sens2_scg
				Dft_thr_4_thr_sens2_scg
				Dft_thr_3_chk_springs
				Dft_thr_3_mcut_sens1
				Cxx_pws_1_fil_fac
				Dft_thr_4_mcut_sens1
				Dft_thr_4_thr_sens1_oc
				Dft_thr_4_thr_sens1_vb_sc
				Tps_1_default_cc_thresh_
				Dft_thr_2_thr_sens1_vb_sc
				Tpac_thrusts_air_temp_maxi_
				Tpac_open_thrust_search_inh
				Dft_thr_1_svkl_sge
				Dft_thr_1_thr_cmd_cpt
				Dft_thr_1_thr_cmd_vb_sc
				Tpac_servo_failure_detect_delay_
				Tpac_servo_failure_diag_delay
				Dft_thr_5_mcut_sens1
				Tpac_thrust_search_cleoff_delay
				Tpac_maximum_throttle_pos_error_
				Dft_thr_1_thr_sens1_oc
				Tpac_thrusts_air_temp_mini_
				Dft_thr_1_thr_sens1_vb_sc
				Dft_thr_1_thr_sens2_scg
				Dft_thr_1_thr_sens2_vb_sc
				Cxx_pfinc_mcut_sens1
				Dft_thr_1_thr_sens_chr
				Cxx_mfnrsta_thr_sens1_vb_sc
				Cxx_mfnrsta_svkl_oc
				Cxx_mfnrsta_svkl_psn
				Cxx_mfnrsta_svkl_sge
				Tpac_inhibit_delay
				Tpac_integral_failure_delay_
				Dft_thr_1_servcoh_papdw
				Dft_thr_1_svkl_lih
				Dft_thr_1_servcoh_papup
				Cxx_mfnrsta_thr_sens1_oc
				Cxx_thr_pos_lim
				Cxx_thr_pos_dyn_lim
				Cxx_thr_mcut_thd_ctr
				Cxx_thr_mcut_svkl_frz_dly
				Cxx_thr_mcut_det_done
				Tpac_learn_limp_home_delay
				Dft_thr_1_svkl_oc
				Tpac_integral_failure_thresh_
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION Sondes_sys
			""
			/begin DEF_CHARACTERISTIC
				Cxx_lbdw_hot_pwm1_dly1
				Cxx_lbdw_scg_t
				Cxx_lbdw_no_oc_det_ctr
				Cxx_lbdw_sc_vb_v
				Cxx_lbdw_pump_crt_v_thd
				Cxx_lbdw_pump_crt_t
				Cxx_lbdw_osp_scg_v
				Cxx_lbdw_osp_sc_vb_v
				Cxx_lbdw_osp_oc_det_l_v
				Ctd_t_rat_lbup_rest
				Ctd_t_rat_lbup_sta
				Cxx_lbdw_osp_oc_det_h_v
				Cxx_lbdw_oc_h_v
				Cxx_lbup_sc_vb_det_v
				Ctb_t_lbup_hot_rest
				Cxx_lbdw_scg_v
				Cxx_lbdw_hot_pwm_per2
				Cxx_lbdw_hot_pwm_per1
				Cxx_lbdw_hot_pwm_dly_inc
				Cxx_lbdw_hot_cmd_dly2
				Cxx_lbdw_hot_cmd_dly1
				Cbx_lbdw
				Cbx_lbdw_osp_typ
				Cbx_lbdw_typ
				Cbx_lbup_dwpt_per_ena
				Cbx_lbup_hot_cho
				Cbx_lbup_osp_typ
				Cbx_lbup_typ
				Cxx_lbdw_hot_pwm1_dly2
				Cxx_lbup_max_vb_thd
				Cxx_lbup_rms_v
				Cxx_lbup_pump_crt_v_thd
				Cxx_lbup_scg_det_v
				Cxx_lbup_pump_crt_t
				Cxx_lbup_osp_scg_det_v
				Cxx_lbup_osp_sc_vb_det_v
				Cxx_lbup_osp_oc_det_l_v
				Cxx_lbup_osp_oc_det_h_v
				Cxx_lbup_oc_t
				Cxx_lbup_oc_det_l_v
				Cxx_lbup_oc_det_h_v
				Cxx_lbup_no_oc_det_ctr
				Ctb_t_lbup_hot_sta
				Cxx_lbup_min_vb_thd
				Cxx_lbup_hot_pwm1_dly2
				Cxx_lbup_hot_pwm1_dly1
				Cxx_lbup_hot_pwm_per2
				Cxx_lbup_hot_pwm_per1
				Cxx_lbup_hot_pwm_dly_inc
				Cxx_lbup_dft_pwm
				Cxx_lbup_cold_sta_rat
				Cxx_lbup_hot_cmd_dly1
				Cxx_lbup_hot_cmd_dly2
				Cxx_mfnrsta_lbdw_vb_sc
				Cxx_mfnrsta_lbup_hot_oc
				Cxx_mfnrsta_lbup_hot_scg
				Cxx_pfdec_lbdw_scg
				Lshd_dw_engine_running_delay_
				Cxx_mfnrsta_pow_lbdw
				Cxx_mfnrsta_lbdw_scg
				Cxx_mfnrsta_pow_lbup
				Tension_alim_capteur_maxi_
				Tension_alim_capteur_mini_
				Cxx_pfdec_lbup_hot_scg
				Cxx_pfdec_lbdw_oc
				Cxx_mfnrsta_lbup_hot_vb_sc
				Cxx_pfdec_lbdw_vb_sc
				Cxx_pfdec_lbup_oc
				Cxx_pfdec_lbup_scg
				Cxx_pfdec_lbup_vb_sc
				Cxx_mfnrsta_lbup_vb_sc
				Cxx_mfnrsta_lbup_scg
				Cxx_mfnrsta_lbup_oc
				Cxx_pfdec_lbdw_hot_scg
				Lshd_dw_current_voltage_maxi_
				Cxx_trs_thd
				Tension_alim_par_defaut
				Cxx_pfinc_lbup_vb_sc
				Cxx_pfinc_lbup_scg
				Cxx_pfinc_lbup_oc
				Cxx_pfinc_lbup_hot_scg
				Cxx_pfinc_lbdw_vb_sc
				Cxx_pfinc_lbdw_scg
				Cxx_pfinc_lbdw_oc
				Cxx_pfinc_lbdw_hot_scg
				Cxx_lbup_v_thd
				Lshd_up_current_slewrate_neg_
				Lshd_dw_current_slewrate_pos_
				Cxx_mfnrsta_lbdw_oc
				Lshd_dw_current_voltage_mini_
				Lshd_dw_off_diag_delay_
				Cxx_trs_thd_lpg
				Lshd_up_current_slewrate_pos_
				Lshd_up_current_voltage_maxi_
				Lshd_up_current_voltage_mini_
				Lshd_up_engine_running_delay_
				Lshd_up_off_diag_delay_
				Cxx_lbup_scg_t
				Cxx_mfnrsta_lbdw_hot_oc
				Cxx_mfnrsta_lbdw_hot_scg
				Cxx_mfnrsta_lbdw_hot_vb_sc
				Lshd_dw_current_slewrate_neg_
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION SDF_SC_sys
			""
			/begin DEF_CHARACTERISTIC
				Ctp_rams_tq_req_pos_err
				Cbx_rams_ena_diag_ma
				Ctp_rams_tq_req_neg_err
				Cbx_ffm1_rams
				Cbx_ffm2_rams
				Ctp_rams_esti_tqe_pos_err
				Ctp_rams_esti_tqe_neg_err
				Cxx_rams_esti_tq_fail_thd
				Dft_thr_0_rams_tq_req
				Dft_thr_3_rams_tq_ctl
				Dft_thr_1_rams_tq_req
				Dft_thr_1_rams_tq_ctl
				Cxx_rams_ena_diag_gear
				Cxx_rams_ena_diag_dly_3
				Dft_thr_0_rams_map_tq
				Cxx_rams_fail_dec
				Cxx_rams_ena_diag_dly_2
				Cxx_rams_ena_diag_tkof_tq
				Dft_thr_5_rams_tq_req
				Dft_thr_5_rams_tq_ctl
				Cxx_rams_ena_diag_tco_thd
				Dft_thr_1_rams_map_tq
				Dft_thr_5_rams_map_tq
				Cxx_rams_ena_diag_n_thd
				Cxx_pfinc_rams_tq_req
				Cxx_pfinc_rams_tq_ctl
				Cxx_pfinc_rams_map_tq
				Cxx_rams_fail_dec_dly
				Cxx_mfnrsta_rams_tq_req
				Cxx_pfdec_rams_tq_ctl
				Cxx_rams_ena_diag_dly_1
				Cxx_pfdec_rams_tq_req
				Cxx_mfnrsta_rams_map_tq
				Dft_thr_4_rams_map_tq
				Dft_thr_0_rams_tq_ctl
				Dft_thr_4_rams_tq_req
				Cxx_mfnrsta_rams_tq_ctl
				Dft_thr_2_rams_tq_ctl
				Dft_thr_2_rams_tq_req
				Dft_thr_2_rams_map_tq
				Cxx_pfdec_rams_map_tq
				Dft_thr_3_rams_map_tq
				Dft_thr_3_rams_tq_req
				Dft_thr_4_rams_tq_ctl
				Cxx_rams_tq_req_fail_thd
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION Etats_moteur_sys
			""
			/begin DEF_CHARACTERISTIC
				Cxx_igk_stal_eng_n_thd
				Cxx_aut_eng_n_thd
				Regime_min_durees_dents_
				Cxx_thd_syn_fail_per
				Time_nct
				Time_nca
				Cxx_set_stal_dly
				Cxx_stal_det_swlk_dly
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION Configuration_sys
			""
			/begin DEF_CHARACTERISTIC
				Cbx_ac_mdf1_cmd
				Cbx_ac_l_vc_eng_conf
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION Climatisation_sys
			""
			/begin DEF_CHARACTERISTIC
				Cxx_ac_pow_n_fac
				Cxx_ac_pow_prs_fac
				Cxx_ac_pow_prs_n_fac
				Cxx_ac_prs_fac
				Cxx_ac_prs_v_max
				Cxx_ac_mdf_vs_thd3
				Cxx_ac_prs_v_min
				Cxx_ac_req_dly
				Cxx_acr_eng_fac
				Cxx_l_prs_ac_dsb_prs_hys
				Cxx_l_prs_ac_dsb_prs_thd
				Cxx_ac_prs_ofs
				Cxx_ac_pow_min
				Cxx_ac_mdf_vs_thd4
				Cxx_ac_mdf_vs_thd2
				Cxx_ac_mdf_vs_thd1
				Cxx_ac_max_mdf_dly
				Cxx_h_prs_ac_dsb_dly
				Cxx_ac_acel_is_req_dly
				Cxx_ac_acel_is_l_prs_thd
				Cxx_ac_acel_is_h_prs_thd
				Cxx_ac_abst_nr_fail
				Cxx_h_prs_ac_dsb_prs_hys
				Cxx_h_prs_ac_dsb_prs_thd
				Cxx_ac_pow_max
				Cbx_ac_vld_conf
				Cxx_prmt_n_ac_dsb_hys
				Cxx_pfinc_acr_oc
				Cxx_mfnrsta_acr_oc
				Cxx_prs_ac_swi_dsb_n_thd
				Cxx_pfdec_ac_rcpt
				Cxx_mdf_ac_prs_thd3
				Cxx_pfdec_acr_scg
				Cxx_pfinc_acr_vb_sc
				Cxx_mfnrsta_ac_prs
				Cxx_mfnrsta_acr_scg
				Cxx_pfinc_acr_scg
				Cxx_mfnrsta_ac_rcpt
				Cxx_pfinc_ac_rcpt
				Cxx_prs_ac_swi_dsb_vs_thd
				Cxx_prmt_n_ac_dsb_thd
				Cxx_prmt_n_ac_dsb_dly
				Cxx_mdf_ac_prs_hys
				Cxx_mdf_ac_prs_thd1
				Cxx_mdf_ac_prs_thd2
				Cxx_pfdec_acr_vb_sc
				Cxx_n_ac_dsb_thd
				Cxx_pfdec_acr_oc
				Cxx_n_ac_dsb_hys
				Cxx_mfnrsta_acr_vb_sc
				Cbx_cold_loop_ac
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION Papillon_sys
			""
			/begin DEF_CHARACTERISTIC
				Cxx_fil_mdl_map_thr_adj
				Cxx_fil_map_thr_adj
				Cbx_thr_dyn_bch
				Cxx_h_trt_limit_sp
				Cxx_h_trt_rate_lim_thd
				Cxx_filt_output_ppt1_coef
				Cxx_filt_input_ppt1_coef
				Cxx_fil_n_thr_adj
				Cbx_thr_bch_auto
				Cxx_fil_fac_cor_thr_adj
				Cbx_thr_typ_select
				Cxx_fil_fac_thr_adj
				Tpac_throttle_open_thresh_
				Tpc_frequence_pwm_gain_
				Tpac_trt_accost
				Tpac_thrusts_search_manu_inh_
				Tpac_trt_mesures
				Tpac_throttle_pos_bkpt_
				Cxx_min_thd_trt2_ini
				Tpac_prop_gain_map
				Tpac_thrusts_search_delay
				Tpac_vel_smoothing_low_limit
				Tpac_vel_smoothing_up_limit
				Cxx_min_thd_trt1_ini
				Tpac_position_bkpt_map
				Cxx_max_thd_trt1_ini
				Tpac_velocity_smoothing_enable
				Tpac_velocity_limit_bkpt_4_
				Tpac_velocity_limit_map_
				Cxx_max_thd_trt2_ini
				Tpc_free_wheeling_delay_
				Tpac_ff_open_offset
				Tpac_ff_lh_low_gain
				Tpac_deriv_filt_input_gain_h_3
				Tpac_deriv_filt_input_gain_h_2
				Tpac_ff_open_gain
				Tpac_deriv_filt_input_gain_h_1
				Tpac_deriv_filt_input_gain_4_
				Tpac_deriv_filt_input_gain_3_
				Tpac_integral_limiter_bkpt_map
				Tpac_deriv_filt_input_gain_1_
				Tpac_ff_closed_offset
				Tpac_high_thrust_detect_dly
				Tpac_consigne_accost
				Tpac_battery_voltage_gain_map_
				Tpac_attenuation_gain_map_
				Rmc_throttle_pos_defaut_thresh
				Ssm_default_closed_throttle_pos_
				Tpac_dyn_test_bed_offset_map
				Tpac_integral_init_bf_map
				Tpac_deriv_filt_input_gain_2_
				Tpac_exit_thrusts_stab_dly
				Tpac_dyn_test_bed_pattern_number
				Tpac_dyn_test_bed_rel_ref_map
				Tpac_dyn_test_bed_type_ref_map
				Tpac_dyn_test_bed_mode
				Tpac_error_to_velocity_gain_
				Tpac_exit_accost_stab_dly
				Tpac_exit_thrusts_delay
				Tpac_dyn_test_bed_duration_map
				Tpac_ff_lh_high_gain
				Tpac_pidmou_mesure_inh
				Tpac_ff_hyst_manu_inh
				Tpac_feed_forward_hysteresis_
				Tpac_feed_forward_up_
				Tpac_feed_forward_low_
				Tpac_deriv_filt_output_gain_h
				Tpac_deriv_filt_output_gain
				Tpac_deriv_filt_input_gain_h_4
				Tpac_ff_closed_gain
				Tpac_integral_init_map
				Tpac_deriv_gain_map
				Tpac_limp_home_variation
				Tpac_integral_gain_map_
				Cxx_thr_chk_lh_l_sp
				Cxx_thr_chk_lh_h_sp
				Cxx_trt_high_frst_srch_sp
				Cxx_thr_chk_lh_ena_dly
				Cxx_thr_chk_lh_cmd_cut_dly
				Cxx_trt_lh_thd
				Cxx_trt_op_sp
				Cxx_trt_cl_sp
				Tpac_limp_home_area
				Cxx_thr_ctl_h_v_lim
				Diag_tpc_active_delay_
				Cxx_trt_thd
				Cxx_lih_thd_trt2_ini
				Cxx_lih_thd_trt1_ini
				Tpac_low_thrust_detect_dly
				Tpac_mcw_inh_test_control_volt_
				Tpac_norm_integral_bkpt
				Tpac_nul_torque_duty_cycle_
				Tpac_integral_limiter_neg_map
				Cxx_thr_mov_rat_lim
				Cxx_thr_chk_lh_stab_dly
				Ssm_default_limp_home_pos_
				Tpac_integral_limiter_map
				Ssm_default_throttle_position_
				Ssm_default_open_throttle_pos_
				Ssm_throt_pos_single_1_manu_enab
				Ssm_throt_pos_single_2_manu_enab
				Ssm_throttle_pos_normal_manu_inh
				Cxx_thr_l_trt_ofs
				Cxx_thr_ctl_l_v_lim
				Tpac_integral_limiter_mode
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION OBD_sys
			""
			/begin DEF_CHARACTERISTIC
				Cbx_fsys_checksum_pf
				Cbx_fsys_bkup_mem_vf
				Cbx_fsys_agb_pf
				Cbx_fsys_clu_mfo
				Cbx_fsys_air_pf
				Cbx_fsys_bkup_mem_mfo
				Cbx_fsys_clu_pf
				Cbx_fsys_alt_pf
				Cbx_fsys_clu_vf
				Cbx_fsys_alt_load_in_pf
				Cbx_fsys_air_vf
				Cbx_fsys_bkup_mem_pf
				Cbx_fsys_air_mfo
				Cbx_fsys_actr_rly_pf
				Cbx_fsys_agb_rcpt_mfo
				Cbx_mis_polu_inj_ecu_mfo
				Cbx_fsys_cp_mfo
				Cbx_mis_polu_igc_3_mfo
				Cbx_fsys_actr_rly_cut_pf
				Cbx_fsys_acr_pf
				Cbx_mis_polu_igc_4_pf
				Cbx_mis_polu_igc_4_vf
				Cbx_mis_polu_mis_cata_2_vf
				Cbx_mis_polu_inj_ecu_pf
				Cbx_fsys_agb_rcpt_vf
				Cbx_mis_polu_gas_pump_vf
				Cbx_mis_polu_fsys_vf
				Cbx_mis_polu_mis_cata_4_lpg_pf
				Cbx_mis_polu_mis_cata_4_lpg_mfo
				Cbx_mis_polu_mis_cata_3_vf
				Cbx_mis_polu_mis_cata_3_pf
				Cbx_mis_polu_mis_cata_3_mfo
				Cbx_mis_polu_mis_cata_3_lpg_vf
				Cbx_mis_polu_mis_cata_3_lpg_pf
				Cbx_mis_polu_mis_cata_3_lpg_mfo
				Cbx_mis_polu_gas_pump_mfo
				Cbx_mis_polu_gas_pump_pf
				Cbx_mis_polu_igc_3_vf
				Cbx_fsys_crk_nr_mfo
				Cbx_fsys_cp_pf
				Cbx_mis_polu_igc_1_mfo
				Cbx_mis_polu_igc_1_pf
				Cbx_mis_polu_igc_1_vf
				Cbx_mis_polu_igc_2_mfo
				Cbx_mis_polu_igc_2_pf
				Cbx_fsys_crk_mfo
				Cbx_mis_polu_igc_2_vf
				Cbx_mis_polu_inj1_pf
				Cbx_mis_polu_igc_3_pf
				Cbx_mis_polu_inj_ecu_vf
				Cbx_mis_polu_igc_4_mfo
				Cbx_fsys_cp_vf
				Cbx_fsys_crk_nr_pf
				Cbx_mis_polu_map_mfo
				Cbx_mis_polu_min_gas_lvl_vf
				Cbx_mis_polu_lbdw_hot_pf
				Cbx_mis_polu_min_gas_lvl_pf
				Cbx_mis_polu_min_gas_lvl_mfo
				Cbx_mis_polu_lbdw_hot_vf
				Cbx_mis_polu_mdf2_pf
				Cbx_mis_polu_mdf1_pf
				Cbx_mis_polu_mcut_sens1_pf
				Cbx_mis_polu_mastervac_pf
				Cbx_mis_polu_map_vf
				Cbx_mis_polu_lbdw_mfo
				Cbx_mis_polu_map_pf
				Cbx_mis_polu_inj1_mfo
				Cbx_mis_polu_lbdw_pump_crt_pf
				Cbx_mis_polu_fsys_pf
				Cbx_mis_polu_map_chr_pf
				Cbx_mis_polu_lbdw_vf
				Cbx_mis_polu_lbup_hot_mfo
				Cbx_mis_polu_lbup_hot_pf
				Cbx_mis_polu_lbup_hot_vf
				Cbx_mis_polu_lpg_rcpt_vf
				Cbx_mis_polu_lpg_rcpt_pf
				Cbx_mis_polu_lpg_rcpt_mfo
				Cbx_mis_polu_lbup_vf
				Cbx_mis_polu_lbup_pump_crt_pf
				Cbx_mis_polu_lbup_pf
				Cbx_mis_polu_lbup_mfo
				Cbx_mis_polu_lbdw_pf
				Cbx_mis_polu_mis_cata_1_mfo
				Cbx_mis_polu_mis_cata_2_mfo
				Cbx_fsys_ac_rcpt_pf
				Cbx_mis_polu_lbdw_hot_mfo
				Cbx_fsys_ac_prs_pf
				Cbx_mis_polu_inj1_vf
				Cbx_mis_polu_inj2_mfo
				Cbx_mis_polu_inj2_pf
				Cbx_mis_polu_inj2_vf
				Cbx_mis_polu_mis_cata_2_lpg_vf
				Cbx_mis_polu_mis_cata_2_lpg_pf
				Cbx_mis_polu_mis_cata_2_lpg_mfo
				Cbx_mis_polu_inj3_mfo
				Cbx_fsys_eng_whl_vf
				Cbx_mis_polu_mis_cata_1_pf
				Cbx_mis_polu_min_lpg_lvl_pf
				Cbx_mis_polu_mis_cata_1_lpg_vf
				Cbx_mis_polu_inj3_pf
				Cbx_mis_polu_inj3_vf
				Cbx_mis_polu_inj4_mfo
				Cbx_mis_polu_inj4_pf
				Cbx_mis_polu_mis_cata_1_lpg_pf
				Cbx_mis_polu_mis_cata_1_lpg_mfo
				Cbx_mis_polu_inj4_vf
				Cbx_mis_polu_ip_inj_cnt_pf
				Cbx_mis_polu_knk_mfo
				Cbx_mis_polu_knk_pf
				Cbx_mis_polu_knk_vf
				Cbx_mis_polu_mis_cata_2_pf
				Cbx_mis_polu_mis_cata_1_vf
				Cbx_mis_cata_vvt_int_ev_vf
				Cbx_mis_cata_vs_pf
				Cbx_fsys_lbdw_hot_pf
				Cbx_fsys_lbdw_hot_vf
				Cbx_mis_cata_vvt_intake_pf
				Cbx_mis_cata_vvt_intake_mfo
				Cbx_fsys_lbdw_mfo
				Cbx_mis_cata_vvt_int_pf
				Cbx_fsys_lbdw_hot_mfo
				Cbx_mis_cata_vvt_int_old_off_mfo
				Cbx_fsys_knk_vf
				Cbx_mis_cata_vvt_int_ev_pf
				Cbx_mis_cata_vvt_int_ev_mfo
				Cbx_mis_cata_vta_intake_vf
				Cbx_fsys_lbdw_pf
				Cbx_mis_cata_vta_intake_pf
				Cbx_mis_cata_vta_intake_mfo
				Cbx_fsys_inj2_pf
				Cbx_mis_cata_vvt_int_old_off_vf
				Cbx_fsys_ip_inj_cnt_pf
				Cbx_mis_polu_eng_whl_pf
				Cbx_mis_cata_wpmp_pf
				Cbx_mis_cata_wgc_vf
				Cbx_fsys_inj3_mfo
				Cbx_fsys_inj3_pf
				Cbx_fsys_inj3_vf
				Cbx_fsys_inj4_mfo
				Cbx_mis_cata_vvt_intake_vf
				Cbx_fsys_inj4_vf
				Cbx_mis_cata_vs_mfo
				Cbx_mis_cata_wgc_pf
				Cbx_mis_cata_wgc_mfo
				Cbx_mis_cata_wat_temp_pf
				Cbx_mis_cata_vvtc_toth_3_vf
				Cbx_mis_cata_vvtc_toth_3_mfo
				Cbx_fsys_knk_mfo
				Cbx_fsys_knk_pf
				Cbx_fsys_inj4_pf
				Cbx_mis_cata_sa_vf
				Cbx_mis_cata_vs_vf
				Cbx_mis_cata_spg_sys_pf
				Cbx_fsys_lbdw_vf
				Cbx_mis_cata_spg_sys_mfo
				Cbx_fsys_lbup_hot_mfo
				Cbx_fsys_lbup_hot_pf
				Cbx_fsys_lbup_hot_vf
				Cbx_mis_cata_spg_vf
				Cbx_mis_cata_spg_mfo
				Cbx_mis_cata_spi_cc_pf
				Cbx_mis_cata_sa_pf
				Cbx_mis_cata_sa_mfo
				Cbx_fsys_lbup_mfo
				Cbx_mis_cata_sa_ev_vf
				Cbx_fsys_lbup_pf
				Cbx_mis_cata_sa_ev_pf
				Cbx_fsys_lbup_pump_crt_pf
				Cbx_mis_cata_spg_pf
				Cbx_mis_cata_thr_cmd_pf
				Cbx_mis_cata_vb_pf
				Cbx_mis_cata_tlz_ad_b_vf
				Cbx_mis_cata_tlz_ad_b_pf
				Cbx_mis_cata_tlz_ad_b_mfo
				Cbx_mis_cata_tjy_ctl_pf
				Cbx_mis_cata_tia_vf
				Cbx_mis_cata_tia_pf
				Cbx_mis_cata_spg_sys_vf
				Cbx_mis_cata_thr_pf
				Cbx_mis_polu_ac_prs_pf
				Cbx_mis_cata_thpl_pf
				Cbx_fsys_lbdw_pump_crt_pf
				Cbx_mis_cata_tco_vf
				Cbx_mis_cata_tco_pf
				Cbx_mis_cata_tco_mfo
				Cbx_mis_cata_swlk_pf
				Cbx_mis_cata_svkl_pf
				Cbx_mis_cata_tia_mfo
				Cbx_mis_polu_crk_mfo
				Cbx_mis_polu_bkup_mem_vf
				Cbx_mis_polu_cru_pf
				Cbx_fsys_fsys_mfo
				Cbx_fsys_fsys_pf
				Cbx_mis_polu_crk_vf
				Cbx_mis_polu_crk_pf
				Cbx_mis_polu_crk_nr_vf
				Cbx_mis_polu_eng_temp_pf
				Cbx_mis_polu_crk_nr_mfo
				Cbx_mis_polu_eng_whl_mfo
				Cbx_mis_polu_cp_vf
				Cbx_mis_polu_cp_pf
				Cbx_mis_polu_cp_mfo
				Cbx_mis_polu_clu_vf
				Cbx_mis_polu_clu_pf
				Cbx_mis_polu_clu_mfo
				Cbx_fsys_inj2_vf
				Cbx_mis_polu_crk_nr_pf
				Cbx_fsys_eng_whl_mfo
				Cbx_mis_polu_fsys_lpg_vf
				Cbx_mis_polu_fsys_lpg_pf
				Cbx_fsys_crk_nr_vf
				Cbx_fsys_crk_pf
				Cbx_fsys_crk_vf
				Cbx_mis_polu_fsys_lpg_mfo
				Cbx_fsys_cru_pf
				Cbx_mis_polu_el_wind_rcpt_pf
				Cbx_fsys_eng_temp_pf
				Cbx_mis_polu_bkup_mem_pf
				Cbx_mis_polu_eng_whl_vf
				Cbx_mis_polu_mis_cata_4_lpg_vf
				Cbx_fsys_eng_whl_pf
				Cbx_mis_polu_mis_cata_vf
				Cbx_fsys_fsys_lpg_mfo
				Cbx_fsys_fsys_lpg_pf
				Cbx_fsys_fsys_lpg_vf
				Cbx_fsys_el_wind_rcpt_pf
				Cbx_mis_polu_agb_pf
				Cbx_mis_polu_checksum_pf
				Cbx_fsys_inj1_mfo
				Cbx_mis_polu_alt_pf
				Cbx_mis_polu_alt_load_in_pf
				Cbx_mis_polu_air_vf
				Cbx_mis_polu_air_pf
				Cbx_mis_polu_air_mfo
				Cbx_fsys_inj_ecu_pf
				Cbx_mis_polu_agb_rcpt_mfo
				Cbx_fsys_inj_ecu_mfo
				Cbx_mis_polu_actr_rly_pf
				Cbx_mis_polu_actr_rly_cut_pf
				Cbx_mis_polu_acr_pf
				Cbx_fsys_inj1_pf
				Cbx_fsys_inj1_vf
				Cbx_fsys_inj2_mfo
				Cbx_mis_polu_ac_rcpt_pf
				Cbx_mis_polu_agb_rcpt_vf
				Cbx_fsys_igc_2_pf
				Cbx_mis_polu_bkup_mem_mfo
				Cbx_fsys_fsys_vf
				Cbx_fsys_gas_pump_mfo
				Cbx_fsys_gas_pump_pf
				Cbx_fsys_gas_pump_vf
				Cbx_fsys_igc_1_mfo
				Cbx_fsys_igc_1_pf
				Cbx_fsys_inj_ecu_vf
				Cbx_fsys_igc_2_mfo
				Cbx_mis_polu_fsys_mfo
				Cbx_fsys_igc_2_vf
				Cbx_fsys_igc_3_mfo
				Cbx_fsys_igc_3_pf
				Cbx_fsys_igc_3_vf
				Cbx_fsys_igc_4_mfo
				Cbx_fsys_igc_4_pf
				Cbx_fsys_igc_4_vf
				Cbx_fsys_igc_1_vf
				Cbx_sa_ip_inj_cnt_pf
				Cbx_sa_min_gas_lvl_mfo
				Cbx_sa_lbdw_pf
				Cbx_sa_lbdw_mfo
				Cbx_sa_lbdw_hot_vf
				Cbx_sa_lbdw_hot_pf
				Cbx_sa_lbdw_hot_mfo
				Cbx_sa_knk_vf
				Cbx_sa_lbdw_vf
				Cbx_sa_knk_mfo
				Cbx_sa_lbup_hot_mfo
				Cbx_sa_inj4_vf
				Cbx_sa_inj4_pf
				Cbx_sa_inj4_mfo
				Cbx_sa_inj3_vf
				Cbx_sa_inj3_pf
				Cbx_sa_inj3_mfo
				Cbx_sa_inj2_vf
				Cbx_sa_knk_pf
				Cbx_sa_lpg_rcpt_pf
				Cbx_sa_crk_nr_mfo
				Cbx_sa_mdf1_pf
				Cbx_sa_mcut_sens1_pf
				Cbx_sa_mastervac_pf
				Cbx_sa_map_vf
				Cbx_sa_map_pf
				Cbx_sa_map_mfo
				Cbx_sa_lbdw_pump_crt_pf
				Cbx_sa_lpg_rcpt_vf
				Cbx_sa_inj1_vf
				Cbx_sa_lpg_rcpt_mfo
				Cbx_sa_lbup_vf
				Cbx_sa_lbup_pump_crt_pf
				Cbx_sa_lbup_pf
				Cbx_sa_lbup_mfo
				Cbx_sa_lbup_hot_vf
				Cbx_sa_lbup_hot_pf
				Cbx_sa_map_chr_pf
				Cbx_sa_eng_whl_mfo
				Cbx_sa_gas_pump_mfo
				Cbx_sa_fsys_vf
				Cbx_sa_fsys_pf
				Cbx_sa_fsys_mfo
				Cbx_sa_fsys_lpg_vf
				Cbx_sa_fsys_lpg_pf
				Cbx_sa_fsys_lpg_mfo
				Cbx_sa_inj2_pf
				Cbx_sa_eng_whl_pf
				Cbx_sa_igc_1_mfo
				Cbx_sa_eng_temp_pf
				Cbx_sa_el_wind_rcpt_pf
				Cbx_sa_cru_pf
				Cbx_sa_crk_vf
				Cbx_sa_crk_pf
				Cbx_sa_crk_nr_vf
				Cbx_mis_polu_mis_cata_mfo
				Cbx_sa_eng_whl_vf
				Cbx_sa_igc_3_vf
				Cbx_sa_min_gas_lvl_pf
				Cbx_sa_inj1_pf
				Cbx_sa_inj1_mfo
				Cbx_sa_inj_ecu_vf
				Cbx_sa_inj_ecu_pf
				Cbx_sa_inj_ecu_mfo
				Cbx_sa_igc_4_vf
				Cbx_sa_gas_pump_pf
				Cbx_sa_igc_4_mfo
				Cbx_sa_gas_pump_vf
				Cbx_sa_igc_3_pf
				Cbx_sa_igc_3_mfo
				Cbx_sa_igc_2_vf
				Cbx_sa_igc_2_pf
				Cbx_sa_igc_2_mfo
				Cbx_sa_igc_1_vf
				Cbx_sa_igc_1_pf
				Cbx_sa_inj2_mfo
				Cbx_sa_igc_4_pf
				Cbx_sa_mis_polu_2_mfo
				Cbx_sa_mdf2_pf
				Cbx_sa_mis_polu_3_vf
				Cbx_sa_mis_polu_3_pf
				Cbx_sa_mis_polu_3_mfo
				Cbx_sa_mis_polu_3_lpg_vf
				Cbx_sa_mis_polu_3_lpg_pf
				Cbx_sa_mis_polu_3_lpg_mfo
				Cbx_sa_mis_polu_4_lpg_pf
				Cbx_sa_mis_polu_2_pf
				Cbx_sa_mis_polu_4_lpg_vf
				Cbx_sa_mis_polu_2_lpg_vf
				Cbx_sa_mis_polu_2_lpg_pf
				Cbx_sa_mis_polu_2_lpg_mfo
				Cbx_sa_mis_polu_1_vf
				Cbx_sa_mis_polu_1_pf
				Cbx_sa_mis_polu_1_mfo
				Cbx_sa_mis_polu_1_lpg_vf
				Cbx_sa_mis_polu_2_vf
				Cbx_sa_mis_polu_lpg_pf
				Cbx_sa_obd_cata_vf
				Cbx_sa_obd_cata_pf
				Cbx_sa_obd_cata_mfo
				Cbx_sa_mvac_sys_pf
				Cbx_sa_mvac_pump_pf
				Cbx_sa_mis_polu_vf
				Cbx_sa_mis_polu_pf
				Cbx_sa_mis_polu_4_lpg_mfo
				Cbx_sa_mis_polu_lpg_vf
				Cbx_sa_mis_lih_pf
				Cbx_sa_mis_polu_lpg_mfo
				Cbx_sa_mis_polu_gas_vf
				Cbx_sa_mis_polu_gas_pf
				Cbx_sa_mis_polu_gas_mfo
				Cbx_sa_mis_polu_4_vf
				Cbx_sa_mis_polu_4_pf
				Cbx_sa_mis_polu_4_mfo
				Cbx_sa_mis_polu_mfo
				Cbx_sa_mis_cata_1_vf
				Cbx_sa_mis_cata_3_lpg_vf
				Cbx_sa_mis_cata_3_lpg_pf
				Cbx_sa_mis_cata_3_lpg_mfo
				Cbx_sa_mis_cata_2_vf
				Cbx_sa_mis_cata_2_pf
				Cbx_sa_mis_cata_2_mfo
				Cbx_sa_mis_cata_2_lpg_vf
				Cbx_sa_mis_polu_1_lpg_pf
				Cbx_sa_mis_cata_2_lpg_mfo
				Cbx_sa_mis_cata_3_vf
				Cbx_sa_mis_cata_1_pf
				Cbx_sa_mis_cata_1_mfo
				Cbx_sa_mis_cata_1_lpg_vf
				Cbx_sa_mis_cata_1_lpg_pf
				Cbx_sa_mis_cata_1_lpg_mfo
				Cbx_sa_min_lpg_lvl_pf
				Cbx_sa_min_gas_lvl_vf
				Cbx_sa_mis_cata_2_lpg_pf
				Cbx_sa_mis_cata_gas_pf
				Cbx_sa_crk_mfo
				Cbx_sa_mis_fast_pf
				Cbx_sa_mis_cata_vf
				Cbx_sa_mis_cata_pf
				Cbx_sa_mis_cata_mfo
				Cbx_sa_mis_cata_lpg_vf
				Cbx_sa_mis_cata_lpg_pf
				Cbx_sa_mis_cata_3_mfo
				Cbx_sa_mis_cata_gas_vf
				Cbx_sa_mis_cata_3_pf
				Cbx_sa_mis_cata_gas_mfo
				Cbx_sa_mis_cata_4_vf
				Cbx_sa_mis_cata_4_pf
				Cbx_sa_mis_cata_4_mfo
				Cbx_sa_mis_cata_4_lpg_vf
				Cbx_sa_mis_cata_4_lpg_pf
				Cbx_sa_mis_cata_4_lpg_mfo
				Cbx_sa_mis_polu_1_lpg_mfo
				Cbx_sa_mis_cata_lpg_mfo
				Cbx_mis_polu_mvac_pump_pf
				Cbx_mis_polu_sa_ev_mfo
				Cbx_mis_polu_obd_sa_mfo
				Cbx_mis_polu_obd_lamb_vf
				Cbx_mis_polu_obd_lamb_pf
				Cbx_mis_polu_obd_lamb_mfo
				Cbx_mis_polu_obd_cata_vf
				Cbx_mis_polu_obd_cata_pf
				Cbx_mis_polu_obd_sa_vf
				Cbx_mis_polu_mvac_sys_pf
				Cbx_mis_polu_oil_pf
				Cbx_mis_polu_mis_polu_vf
				Cbx_mis_polu_mis_polu_pf
				Cbx_mis_polu_mis_polu_mfo
				Cbx_mis_polu_mis_polu_lpg_vf
				Cbx_mis_polu_mis_polu_lpg_pf
				Cbx_mis_polu_mis_polu_lpg_mfo
				Cbx_mis_polu_mis_polu_gas_vf
				Cbx_mis_polu_obd_cata_mfo
				Cbx_mis_polu_pow_lbup_vf
				Cbx_sa_crk_nr_pf
				Cbx_mis_polu_reserve_3_pf
				Cbx_mis_polu_rams_pf
				Cbx_mis_polu_rams_pdl_vf
				Cbx_mis_polu_rams_pdl_pf
				Cbx_mis_polu_rams_pdl_mfo
				Cbx_mis_polu_pws_pf
				Cbx_mis_polu_obd_sa_pf
				Cbx_mis_polu_ptc_pf
				Cbx_mis_polu_mis_polu_4_vf
				Cbx_mis_polu_pow_lbup_pf
				Cbx_mis_polu_pow_lbup_mfo
				Cbx_mis_polu_pow_lbdw_vf
				Cbx_mis_polu_pow_lbdw_pf
				Cbx_mis_polu_pow_lbdw_mfo
				Cbx_mis_polu_pmh_pf
				Cbx_mis_polu_pdl_pf
				Cbx_mis_polu_ptc_rov_pf
				Cbx_mis_polu_mis_cata_lpg_vf
				Cbx_mis_polu_mis_polu_1_mfo
				Cbx_mis_polu_mis_polu_1_lpg_vf
				Cbx_mis_polu_mis_polu_1_lpg_pf
				Cbx_mis_polu_mis_polu_1_lpg_mfo
				Cbx_mis_polu_mis_lih_pf
				Cbx_mis_polu_mis_fast_pf
				Cbx_fsys_map_vf
				Cbx_mis_polu_mis_polu_gas_pf
				Cbx_mis_cata_sa_ev_mfo
				Cbx_mis_polu_mis_polu_2_lpg_mfo
				Cbx_mis_polu_mis_cata_lpg_pf
				Cbx_mis_polu_mis_cata_lpg_mfo
				Cbx_mis_polu_mis_cata_gas_vf
				Cbx_mis_polu_mis_cata_gas_pf
				Cbx_mis_polu_mis_cata_gas_mfo
				Cbx_mis_polu_mis_cata_4_vf
				Cbx_mis_polu_mis_cata_4_pf
				Cbx_mis_polu_mis_cata_pf
				Cbx_mis_polu_mis_polu_3_lpg_vf
				Cbx_mis_polu_sa_ev_pf
				Cbx_mis_polu_mis_polu_4_pf
				Cbx_mis_polu_mis_polu_4_mfo
				Cbx_mis_polu_mis_polu_4_lpg_vf
				Cbx_mis_polu_mis_polu_4_lpg_pf
				Cbx_mis_polu_mis_polu_4_lpg_mfo
				Cbx_mis_polu_mis_polu_3_vf
				Cbx_mis_polu_mis_polu_1_pf
				Cbx_mis_polu_mis_polu_3_mfo
				Cbx_mis_polu_mis_polu_1_vf
				Cbx_mis_polu_mis_polu_3_lpg_pf
				Cbx_mis_polu_mis_polu_3_lpg_mfo
				Cbx_mis_polu_mis_polu_2_vf
				Cbx_mis_polu_mis_polu_2_pf
				Cbx_mis_polu_mis_polu_2_mfo
				Cbx_mis_polu_mis_polu_2_lpg_vf
				Cbx_mis_polu_mis_polu_2_lpg_pf
				Cbx_mis_polu_mis_polu_gas_mfo
				Cbx_mis_polu_mis_polu_3_pf
				Cbx_mis_polu_wgc_pf
				Cbx_mis_polu_rmc_pf
				Cbx_sa_acr_pf
				Cbx_sa_ac_rcpt_pf
				Cbx_sa_ac_prs_pf
				Cbx_mod_bch_diag_sa
				Cbx_mod_bch_diag_lamb
				Cbx_mod_bch_diag_cata
				Cbx_sa_actr_rly_pf
				Cbx_mis_polu_wgc_vf
				Cbx_sa_agb_pf
				Cbx_mis_polu_wgc_mfo
				Cbx_mis_polu_wat_temp_pf
				Cbx_mis_polu_vvtc_toth_3_vf
				Cbx_mis_polu_vvtc_toth_3_mfo
				Cbx_mis_polu_vvt_intake_vf
				Cbx_mis_polu_vvt_intake_pf
				Cbx_mis_polu_vvt_intake_mfo
				Cbx_mis_polu_wpmp_pf
				Cbx_sa_bkup_mem_mfo
				Cbx_sa_cp_vf
				Cbx_sa_cp_pf
				Cbx_sa_cp_mfo
				Cbx_sa_clu_vf
				Cbx_sa_clu_pf
				Cbx_sa_clu_mfo
				Cbx_sa_checksum_pf
				Cbx_sa_actr_rly_cut_pf
				Cbx_sa_bkup_mem_pf
				Cbx_mis_polu_vvt_int_old_off_mfo
				Cbx_sa_alt_pf
				Cbx_sa_alt_load_in_pf
				Cbx_sa_air_vf
				Cbx_sa_air_pf
				Cbx_sa_air_mfo
				Cbx_sa_agb_rcpt_vf
				Cbx_sa_agb_rcpt_mfo
				Cbx_sa_bkup_mem_vf
				Cbx_mis_polu_spg_sys_pf
				Cbx_mis_polu_thpl_pf
				Cbx_mis_polu_tco_vf
				Cbx_mis_polu_tco_pf
				Cbx_mis_polu_tco_mfo
				Cbx_mis_polu_swlk_pf
				Cbx_mis_polu_svkl_pf
				Cbx_mis_polu_spi_cc_pf
				Cbx_mis_polu_vvt_int_pf
				Cbx_mis_polu_spg_sys_vf
				Cbx_mis_polu_tia_mfo
				Cbx_mis_polu_spg_sys_mfo
				Cbx_mis_polu_spg_pf
				Cbx_mis_polu_spg_mfo
				Cbx_mis_polu_sa_vf
				Cbx_mis_polu_sa_pf
				Cbx_mis_polu_sa_mfo
				Cbx_mis_polu_sa_ev_vf
				Cbx_mis_polu_spg_vf
				Cbx_mis_polu_vs_mfo
				Cbx_mis_polu_mis_cata_4_mfo
				Cbx_mis_polu_vvt_int_ev_vf
				Cbx_mis_polu_vvt_int_ev_pf
				Cbx_mis_polu_vvt_int_ev_mfo
				Cbx_mis_polu_vta_intake_vf
				Cbx_mis_polu_vta_intake_pf
				Cbx_mis_polu_vta_intake_mfo
				Cbx_mis_polu_thr_cmd_pf
				Cbx_mis_polu_vs_pf
				Cbx_mis_polu_thr_pf
				Cbx_mis_polu_vb_pf
				Cbx_mis_polu_tlz_ad_b_vf
				Cbx_mis_polu_tlz_ad_b_pf
				Cbx_mis_polu_tlz_ad_b_mfo
				Cbx_mis_polu_tjy_ctl_pf
				Cbx_mis_polu_tia_vf
				Cbx_mis_polu_tia_pf
				Cbx_mis_polu_vvt_int_old_off_vf
				Cbx_mis_polu_vs_vf
				Cbx_schd_mis_cata_lpg_mfo
				Cbx_lamb_crk_mfo
				Cbx_lamb_igc_1_mfo
				Cbx_lamb_igc_1_pf
				Cbx_lamb_igc_1_vf
				Cbx_lamb_igc_2_mfo
				Cbx_lamb_igc_2_pf
				Cbx_lamb_igc_2_vf
				Cbx_lamb_gas_pump_pf
				Cbx_lamb_igc_3_mfo
				Cbx_lamb_gas_pump_mfo
				Cbx_lamb_igc_3_pf
				Cbx_lamb_igc_3_vf
				Cbx_lamb_igc_4_mfo
				Cbx_lamb_igc_4_pf
				Cbx_lamb_igc_4_vf
				Cbx_lamb_inj_ecu_mfo
				Cbx_lamb_inj_ecu_pf
				Cbx_sa_obd_lamb_mfo
				Cbx_lamb_eng_whl_pf
				Cbx_mis_cata_crk_nr_vf
				Cbx_lamb_crk_nr_pf
				Cbx_lamb_crk_nr_vf
				Cbx_lamb_crk_pf
				Cbx_lamb_crk_vf
				Cbx_lamb_cru_pf
				Cbx_lamb_el_wind_rcpt_pf
				Cbx_lamb_gas_pump_vf
				Cbx_lamb_eng_whl_mfo
				Cbx_lamb_inj1_pf
				Cbx_lamb_eng_whl_vf
				Cbx_lamb_fsys_lpg_mfo
				Cbx_lamb_fsys_lpg_pf
				Cbx_lamb_fsys_lpg_vf
				Cbx_lamb_fsys_mfo
				Cbx_lamb_fsys_pf
				Cbx_lamb_fsys_vf
				Cbx_lamb_eng_temp_pf
				Cbx_lamb_lpg_rcpt_mfo
				Cbx_lamb_lbdw_pump_crt_pf
				Cbx_lamb_lbdw_vf
				Cbx_lamb_lbup_hot_mfo
				Cbx_lamb_lbup_hot_pf
				Cbx_lamb_lbup_hot_vf
				Cbx_lamb_lbup_mfo
				Cbx_lamb_lbup_pf
				Cbx_lamb_inj_ecu_vf
				Cbx_lamb_lbup_vf
				Cbx_lamb_lbdw_hot_vf
				Cbx_lamb_lpg_rcpt_pf
				Cbx_lamb_lpg_rcpt_vf
				Cbx_lamb_map_chr_pf
				Cbx_lamb_map_mfo
				Cbx_lamb_map_pf
				Cbx_lamb_map_vf
				Cbx_lamb_mastervac_pf
				Cbx_lamb_lbup_pump_crt_pf
				Cbx_lamb_inj4_pf
				Cbx_lamb_cp_vf
				Cbx_lamb_inj1_vf
				Cbx_lamb_inj2_mfo
				Cbx_lamb_inj2_pf
				Cbx_lamb_inj2_vf
				Cbx_lamb_inj3_mfo
				Cbx_lamb_inj3_pf
				Cbx_lamb_lbdw_pf
				Cbx_lamb_inj4_mfo
				Cbx_lamb_lbdw_mfo
				Cbx_lamb_inj4_vf
				Cbx_lamb_ip_inj_cnt_pf
				Cbx_lamb_knk_mfo
				Cbx_lamb_knk_pf
				Cbx_lamb_knk_vf
				Cbx_lamb_lbdw_hot_mfo
				Cbx_lamb_lbdw_hot_pf
				Cbx_lamb_inj1_mfo
				Cbx_lamb_inj3_vf
				Cbx_mis_cata_checksum_pf
				Cbx_lamb_crk_nr_mfo
				Cbx_fsys_vvt_int_ev_pf
				Cbx_fsys_vvt_int_ev_vf
				Cbx_fsys_vvt_int_old_off_mfo
				Cbx_fsys_vvt_int_old_off_vf
				Cbx_fsys_vvt_int_pf
				Cbx_fsys_vvt_intake_mfo
				Cbx_mis_cata_clu_pf
				Cbx_fsys_vvt_intake_pf
				Cbx_mis_cata_clu_vf
				Cbx_fsys_vvt_intake_vf
				Cbx_fsys_vvtc_toth_3_mfo
				Cbx_fsys_vvtc_toth_3_vf
				Cbx_fsys_wat_temp_pf
				Cbx_fsys_wgc_mfo
				Cbx_fsys_wgc_pf
				Cbx_fsys_wgc_vf
				Cbx_mis_cata_clu_mfo
				Cbx_mis_cata_crk_mfo
				Cbx_fsys_map_mfo
				Cbx_fsys_tlz_ad_b_mfo
				Cbx_fsys_tlz_ad_b_pf
				Cbx_fsys_tlz_ad_b_vf
				Cbx_fsys_vb_pf
				Cbx_fsys_vs_mfo
				Cbx_fsys_vs_pf
				Cbx_fsys_vvt_int_ev_mfo
				Cbx_mis_cata_crk_nr_mfo
				Cbx_mis_cata_bkup_mem_vf
				Cbx_fsys_vs_vf
				Cbx_mis_cata_cp_vf
				Cbx_fsys_vta_intake_mfo
				Cbx_fsys_vta_intake_pf
				Cbx_mis_cata_cp_pf
				Cbx_mis_cata_cp_mfo
				Cbx_fsys_vta_intake_vf
				Cbx_mis_cata_crk_nr_pf
				Cbx_lamb_checksum_pf
				Cbx_mis_cata_agb_rcpt_mfo
				Cbx_mis_cata_agb_pf
				Cbx_lamb_alt_pf
				Cbx_lamb_bkup_mem_mfo
				Cbx_mis_cata_actr_rly_pf
				Cbx_mis_cata_actr_rly_cut_pf
				Cbx_mis_cata_acr_pf
				Cbx_fsys_wpmp_pf
				Cbx_lamb_bkup_mem_vf
				Cbx_lamb_air_pf
				Cbx_lamb_clu_mfo
				Cbx_lamb_clu_pf
				Cbx_mis_cata_ac_rcpt_pf
				Cbx_mis_cata_ac_prs_pf
				Cbx_lamb_clu_vf
				Cbx_lamb_cp_mfo
				Cbx_lamb_cp_pf
				Cbx_lamb_bkup_mem_pf
				Cbx_mis_cata_alt_load_in_pf
				Cbx_lamb_mdf2_pf
				Cbx_lamb_ac_rcpt_pf
				Cbx_lamb_acr_pf
				Cbx_lamb_actr_rly_cut_pf
				Cbx_mis_cata_bkup_mem_pf
				Cbx_lamb_actr_rly_pf
				Cbx_mis_cata_bkup_mem_mfo
				Cbx_lamb_alt_load_in_pf
				Cbx_mis_cata_alt_pf
				Cbx_lamb_air_vf
				Cbx_mis_cata_air_vf
				Cbx_lamb_agb_rcpt_mfo
				Cbx_mis_cata_air_pf
				Cbx_mis_cata_air_mfo
				Cbx_mis_cata_agb_rcpt_vf
				Cbx_lamb_agb_rcpt_vf
				Cbx_lamb_air_mfo
				Cbx_lamb_ac_prs_pf
				Cbx_lamb_agb_pf
				Cbx_lamb_tjy_ctl_pf
				Cbx_lamb_mcut_sens1_pf
				Cbx_lamb_vta_intake_mfo
				Cbx_lamb_vs_vf
				Cbx_lamb_vs_pf
				Cbx_lamb_vs_mfo
				Cbx_lamb_vb_pf
				Cbx_lamb_tlz_ad_b_vf
				Cbx_lamb_vta_intake_vf
				Cbx_lamb_tlz_ad_b_mfo
				Cbx_lamb_vvt_int_ev_mfo
				Cbx_lamb_tia_vf
				Cbx_lamb_tia_pf
				Cbx_lamb_tia_mfo
				Cbx_lamb_thr_pf
				Cbx_lamb_obd_lamb_vf
				Cbx_lamb_obd_sa_mfo
				Cbx_lamb_obd_sa_pf
				Cbx_lamb_tlz_ad_b_pf
				Cbx_lamb_vvt_intake_vf
				Cbx_lamb_wgc_mfo
				Cbx_lamb_wat_temp_pf
				Cbx_lamb_vvtc_toth_3_vf
				Cbx_lamb_obd_cata_mfo
				Cbx_lamb_obd_cata_pf
				Cbx_lamb_obd_cata_vf
				Cbx_lamb_obd_lamb_mfo
				Cbx_lamb_vta_intake_pf
				Cbx_lamb_vvtc_toth_3_mfo
				Cbx_lamb_pdl_pf
				Cbx_lamb_vvt_intake_pf
				Cbx_lamb_vvt_intake_mfo
				Cbx_lamb_vvt_int_pf
				Cbx_lamb_vvt_int_old_off_vf
				Cbx_lamb_vvt_int_old_off_mfo
				Cbx_lamb_vvt_int_ev_vf
				Cbx_lamb_vvt_int_ev_pf
				Cbx_lamb_obd_lamb_pf
				Cbx_lamb_spi_cc_pf
				Cbx_lamb_sa_mfo
				Cbx_lamb_sa_pf
				Cbx_lamb_sa_vf
				Cbx_lamb_spg_mfo
				Cbx_lamb_spg_pf
				Cbx_lamb_spg_sys_mfo
				Cbx_lamb_spg_sys_pf
				Cbx_lamb_obd_sa_vf
				Cbx_lamb_spg_vf
				Cbx_lamb_sa_ev_mfo
				Cbx_lamb_svkl_pf
				Cbx_lamb_swlk_pf
				Cbx_lamb_tco_mfo
				Cbx_lamb_tco_pf
				Cbx_lamb_tco_vf
				Cbx_lamb_thpl_pf
				Cbx_lamb_thr_cmd_pf
				Cbx_lamb_spg_sys_vf
				Cbx_lamb_ptc_rov_pf
				Cbx_lamb_wgc_vf
				Cbx_lamb_pmh_pf
				Cbx_lamb_pow_lbdw_mfo
				Cbx_lamb_pow_lbdw_pf
				Cbx_lamb_pow_lbdw_vf
				Cbx_lamb_pow_lbup_mfo
				Cbx_lamb_pow_lbup_pf
				Cbx_lamb_sa_ev_vf
				Cbx_lamb_ptc_pf
				Cbx_lamb_sa_ev_pf
				Cbx_lamb_pws_pf
				Cbx_lamb_rams_pdl_mfo
				Cbx_lamb_rams_pdl_pf
				Cbx_lamb_rams_pdl_vf
				Cbx_lamb_rams_pf
				Cbx_lamb_reserve_3_pf
				Cbx_lamb_rmc_pf
				Cbx_lamb_oil_pf
				Cbx_lamb_pow_lbup_vf
				Cbx_lamb_mis_cata_gas_mfo
				Cbx_lamb_mis_cata_3_mfo
				Cbx_lamb_mis_cata_3_pf
				Cbx_lamb_mis_cata_3_vf
				Cbx_lamb_mis_cata_4_lpg_mfo
				Cbx_lamb_mis_cata_4_lpg_pf
				Cbx_lamb_mis_cata_4_lpg_vf
				Cbx_lamb_mis_cata_4_mfo
				Cbx_lamb_mis_cata_vf
				Cbx_lamb_mis_cata_4_vf
				Cbx_lamb_mis_cata_3_lpg_mfo
				Cbx_lamb_mis_cata_gas_pf
				Cbx_lamb_mis_cata_gas_vf
				Cbx_lamb_mis_cata_lpg_mfo
				Cbx_lamb_mis_cata_lpg_pf
				Cbx_lamb_mis_cata_lpg_vf
				Cbx_lamb_mis_cata_mfo
				Cbx_lamb_wgc_pf
				Cbx_lamb_mis_cata_4_pf
				Cbx_lamb_mis_cata_1_pf
				Cbx_fsys_tia_vf
				Cbx_lamb_min_gas_lvl_mfo
				Cbx_lamb_min_gas_lvl_pf
				Cbx_lamb_min_gas_lvl_vf
				Cbx_lamb_min_lpg_lvl_pf
				Cbx_lamb_mis_cata_1_lpg_mfo
				Cbx_lamb_mis_cata_1_lpg_pf
				Cbx_lamb_mis_cata_3_lpg_vf
				Cbx_lamb_mis_cata_1_mfo
				Cbx_lamb_mis_cata_3_lpg_pf
				Cbx_lamb_mis_cata_1_vf
				Cbx_lamb_mis_cata_2_lpg_mfo
				Cbx_lamb_mis_cata_2_lpg_pf
				Cbx_lamb_mis_cata_2_lpg_vf
				Cbx_lamb_mis_cata_2_mfo
				Cbx_lamb_mis_cata_2_pf
				Cbx_lamb_mis_cata_2_vf
				Cbx_lamb_mis_fast_pf
				Cbx_lamb_mis_cata_1_lpg_vf
				Cbx_lamb_mis_polu_lpg_pf
				Cbx_lamb_mis_polu_4_lpg_pf
				Cbx_lamb_mis_polu_4_lpg_vf
				Cbx_lamb_mis_polu_4_mfo
				Cbx_lamb_mis_polu_4_pf
				Cbx_lamb_mis_polu_4_vf
				Cbx_lamb_mis_polu_gas_mfo
				Cbx_lamb_mis_polu_gas_pf
				Cbx_lamb_mis_cata_pf
				Cbx_lamb_mis_polu_lpg_mfo
				Cbx_lamb_mis_polu_3_pf
				Cbx_lamb_mis_polu_lpg_vf
				Cbx_lamb_mis_polu_mfo
				Cbx_lamb_mis_polu_pf
				Cbx_lamb_mis_polu_vf
				Cbx_lamb_mvac_pump_pf
				Cbx_lamb_wpmp_pf
				Cbx_lamb_mdf1_pf
				Cbx_lamb_mis_polu_gas_vf
				Cbx_lamb_mis_polu_2_lpg_vf
				Cbx_lamb_mis_lih_pf
				Cbx_lamb_mis_polu_1_lpg_mfo
				Cbx_lamb_mis_polu_1_lpg_pf
				Cbx_lamb_mis_polu_1_lpg_vf
				Cbx_lamb_mis_polu_1_mfo
				Cbx_lamb_mis_polu_1_pf
				Cbx_lamb_mis_polu_1_vf
				Cbx_lamb_mis_polu_4_lpg_mfo
				Cbx_lamb_mis_polu_2_lpg_pf
				Cbx_lamb_mis_polu_3_vf
				Cbx_lamb_mis_polu_2_mfo
				Cbx_lamb_mis_polu_2_pf
				Cbx_lamb_mis_polu_2_vf
				Cbx_lamb_mis_polu_3_lpg_mfo
				Cbx_lamb_mis_polu_3_lpg_pf
				Cbx_lamb_mis_polu_3_lpg_vf
				Cbx_lamb_mis_polu_3_mfo
				Cbx_lamb_mvac_sys_pf
				Cbx_lamb_mis_polu_2_lpg_mfo
				Cbx_fsys_mis_polu_3_lpg_pf
				Cbx_mis_cata_mis_polu_gas_vf
				Cbx_mis_cata_mis_polu_4_pf
				Cbx_fsys_mis_polu_2_pf
				Cbx_mis_cata_mis_polu_4_mfo
				Cbx_fsys_mis_polu_2_vf
				Cbx_mis_cata_mis_polu_4_lpg_vf
				Cbx_mis_cata_mis_polu_4_lpg_pf
				Cbx_mis_cata_mis_polu_4_vf
				Cbx_fsys_mis_polu_3_lpg_mfo
				Cbx_fsys_mis_polu_2_lpg_vf
				Cbx_fsys_mis_polu_3_lpg_vf
				Cbx_fsys_mis_polu_3_mfo
				Cbx_fsys_mis_polu_3_pf
				Cbx_mis_cata_mis_polu_3_vf
				Cbx_mis_cata_mis_polu_3_pf
				Cbx_fsys_mis_polu_3_vf
				Cbx_mis_cata_mis_polu_3_mfo
				Cbx_mis_cata_mis_polu_4_lpg_mfo
				Cbx_fsys_mis_polu_1_lpg_vf
				Cbx_fsys_tjy_ctl_pf
				Cbx_fsys_mis_cata_lpg_vf
				Cbx_fsys_mis_cata_mfo
				Cbx_fsys_mis_cata_pf
				Cbx_fsys_mis_cata_vf
				Cbx_fsys_mis_fast_pf
				Cbx_fsys_mis_lih_pf
				Cbx_fsys_mis_polu_2_mfo
				Cbx_fsys_mis_polu_1_lpg_pf
				Cbx_fsys_mis_polu_4_lpg_mfo
				Cbx_fsys_mis_polu_1_mfo
				Cbx_fsys_mis_polu_1_pf
				Cbx_fsys_mis_polu_1_vf
				Cbx_fsys_mis_polu_2_lpg_mfo
				Cbx_mis_cata_mis_polu_gas_pf
				Cbx_mis_cata_mis_polu_gas_mfo
				Cbx_fsys_mis_polu_2_lpg_pf
				Cbx_fsys_mis_polu_1_lpg_mfo
				Cbx_mis_cata_mis_cata_mfo
				Cbx_mis_cata_mis_polu_1_lpg_vf
				Cbx_mis_cata_mis_polu_1_lpg_pf
				Cbx_mis_cata_mis_polu_1_lpg_mfo
				Cbx_mis_cata_mis_lih_pf
				Cbx_mis_cata_mis_fast_pf
				Cbx_fsys_mis_polu_lpg_pf
				Cbx_fsys_mis_polu_lpg_vf
				Cbx_mis_cata_mis_polu_3_lpg_vf
				Cbx_mis_cata_mis_cata_pf
				Cbx_mis_cata_mis_polu_1_vf
				Cbx_mis_cata_mis_cata_lpg_vf
				Cbx_fsys_mis_polu_mfo
				Cbx_fsys_mis_polu_pf
				Cbx_fsys_mis_polu_vf
				Cbx_mis_cata_mis_cata_lpg_pf
				Cbx_mis_cata_mis_cata_lpg_mfo
				Cbx_mis_cata_mis_cata_gas_vf
				Cbx_mis_cata_mis_cata_vf
				Cbx_fsys_mis_polu_4_vf
				Cbx_mis_cata_mis_polu_lpg_mfo
				Cbx_fsys_mis_polu_4_lpg_pf
				Cbx_fsys_mis_polu_4_lpg_vf
				Cbx_mis_cata_mis_polu_3_lpg_mfo
				Cbx_mis_cata_mis_polu_2_vf
				Cbx_mis_cata_mis_polu_2_pf
				Cbx_mis_cata_mis_polu_2_mfo
				Cbx_mis_cata_mis_polu_1_mfo
				Cbx_fsys_mis_polu_4_pf
				Cbx_mis_cata_mis_polu_1_pf
				Cbx_fsys_mis_polu_gas_mfo
				Cbx_fsys_mis_polu_gas_pf
				Cbx_fsys_mis_polu_gas_vf
				Cbx_fsys_mis_polu_lpg_mfo
				Cbx_mis_cata_mis_polu_2_lpg_vf
				Cbx_mis_cata_mis_polu_2_lpg_pf
				Cbx_mis_cata_mis_polu_2_lpg_mfo
				Cbx_mis_cata_mis_polu_3_lpg_pf
				Cbx_fsys_mis_polu_4_mfo
				Cbx_mis_cata_pow_lbdw_mfo
				Cbx_fsys_mis_cata_lpg_pf
				Cbx_mis_cata_ptc_rov_pf
				Cbx_mis_cata_ptc_pf
				Cbx_mis_cata_pow_lbup_vf
				Cbx_fsys_mis_cata_1_lpg_mfo
				Cbx_mis_cata_pow_lbup_pf
				Cbx_mis_cata_pow_lbup_mfo
				Cbx_fsys_min_gas_lvl_vf
				Cbx_mis_cata_pow_lbdw_pf
				Cbx_fsys_min_gas_lvl_pf
				Cbx_fsys_mis_cata_1_lpg_pf
				Cbx_fsys_mis_cata_1_lpg_vf
				Cbx_fsys_mis_cata_1_mfo
				Cbx_fsys_mis_cata_1_pf
				Cbx_fsys_mis_cata_1_vf
				Cbx_fsys_mis_cata_2_lpg_mfo
				Cbx_mis_cata_pmh_pf
				Cbx_mis_cata_pow_lbdw_vf
				Cbx_fsys_mcut_sens1_pf
				Cbx_fsys_lpg_rcpt_mfo
				Cbx_mis_cata_rmc_pf
				Cbx_mis_cata_reserve_3_pf
				Cbx_mis_cata_rams_pf
				Cbx_fsys_lpg_rcpt_pf
				Cbx_fsys_lpg_rcpt_vf
				Cbx_fsys_map_chr_pf
				Cbx_fsys_min_lpg_lvl_pf
				Cbx_fsys_mastervac_pf
				Cbx_mis_cata_obd_sa_vf
				Cbx_mis_cata_rams_pdl_vf
				Cbx_mis_cata_rams_pdl_pf
				Cbx_fsys_mdf1_pf
				Cbx_mis_cata_rams_pdl_mfo
				Cbx_mis_cata_pws_pf
				Cbx_fsys_mdf2_pf
				Cbx_fsys_min_gas_lvl_mfo
				Cbx_fsys_map_pf
				Cbx_fsys_mis_cata_4_pf
				Cbx_fsys_mis_cata_3_lpg_pf
				Cbx_fsys_mis_cata_3_lpg_vf
				Cbx_fsys_mis_cata_3_mfo
				Cbx_fsys_mis_cata_3_pf
				Cbx_fsys_mis_cata_3_vf
				Cbx_fsys_mis_cata_4_lpg_mfo
				Cbx_fsys_mis_cata_4_lpg_pf
				Cbx_mis_cata_pdl_pf
				Cbx_fsys_mis_cata_4_mfo
				Cbx_mis_cata_mis_polu_mfo
				Cbx_fsys_mis_cata_4_vf
				Cbx_fsys_mis_cata_gas_mfo
				Cbx_fsys_mis_cata_gas_pf
				Cbx_fsys_mis_cata_gas_vf
				Cbx_fsys_mis_cata_lpg_mfo
				Cbx_mis_cata_mis_polu_lpg_vf
				Cbx_mis_cata_mis_polu_lpg_pf
				Cbx_fsys_mis_cata_4_lpg_vf
				Cbx_fsys_mis_cata_2_pf
				Cbx_fsys_mvac_pump_pf
				Cbx_mis_cata_obd_sa_pf
				Cbx_mis_cata_obd_sa_mfo
				Cbx_mis_cata_obd_lamb_vf
				Cbx_fsys_mis_cata_2_lpg_pf
				Cbx_fsys_mis_cata_2_lpg_vf
				Cbx_mis_cata_obd_lamb_pf
				Cbx_fsys_mis_cata_3_lpg_mfo
				Cbx_fsys_mis_cata_2_mfo
				Cbx_fsys_mis_cata_2_vf
				Cbx_mis_cata_obd_cata_vf
				Cbx_mis_cata_obd_cata_pf
				Cbx_mis_cata_obd_cata_mfo
				Cbx_mis_cata_mvac_sys_pf
				Cbx_mis_cata_mvac_pump_pf
				Cbx_mis_cata_mis_polu_vf
				Cbx_mis_cata_mis_polu_pf
				Cbx_mis_cata_oil_pf
				Cbx_mis_cata_obd_lamb_mfo
				Cbx_mis_cata_inj3_mfo
				Cbx_mis_cata_mis_cata_gas_pf
				Cbx_mis_cata_inj4_pf
				Cbx_fsys_spg_vf
				Cbx_mis_cata_inj4_mfo
				Cbx_fsys_spi_cc_pf
				Cbx_fsys_svkl_pf
				Cbx_mis_cata_inj3_vf
				Cbx_mis_cata_ip_inj_cnt_pf
				Cbx_fsys_swlk_pf
				Cbx_mis_cata_knk_mfo
				Cbx_mis_cata_inj2_vf
				Cbx_mis_cata_inj2_pf
				Cbx_mis_cata_inj2_mfo
				Cbx_mis_cata_inj1_vf
				Cbx_mis_cata_inj1_pf
				Cbx_mis_cata_inj1_mfo
				Cbx_mis_cata_inj_ecu_vf
				Cbx_mis_cata_inj3_pf
				Cbx_mis_cata_lbdw_hot_vf
				Cbx_mis_cata_lbup_mfo
				Cbx_mis_cata_lbup_hot_vf
				Cbx_mis_cata_lbup_hot_pf
				Cbx_mis_cata_lbup_hot_mfo
				Cbx_mis_cata_lbdw_vf
				Cbx_fsys_spg_pf
				Cbx_mis_cata_lbdw_pump_crt_pf
				Cbx_mis_cata_inj4_vf
				Cbx_mis_cata_lbdw_mfo
				Cbx_mis_cata_igc_4_vf
				Cbx_mis_cata_lbdw_hot_pf
				Cbx_mis_cata_lbdw_hot_mfo
				Cbx_fsys_spg_sys_mfo
				Cbx_fsys_spg_sys_pf
				Cbx_fsys_spg_sys_vf
				Cbx_mis_cata_knk_vf
				Cbx_mis_cata_knk_pf
				Cbx_mis_cata_lbdw_pf
				Cbx_fsys_tco_pf
				Cbx_mis_cata_fsys_lpg_mfo
				Cbx_mis_cata_eng_whl_vf
				Cbx_mis_cata_eng_whl_pf
				Cbx_mis_cata_eng_whl_mfo
				Cbx_mis_cata_eng_temp_pf
				Cbx_mis_cata_el_wind_rcpt_pf
				Cbx_mis_cata_cru_pf
				Cbx_mis_cata_inj_ecu_pf
				Cbx_fsys_tco_mfo
				Cbx_mis_cata_fsys_mfo
				Cbx_fsys_tco_vf
				Cbx_fsys_thpl_pf
				Cbx_fsys_thr_cmd_pf
				Cbx_fsys_thr_pf
				Cbx_fsys_tia_mfo
				Cbx_fsys_tia_pf
				Cbx_mis_cata_crk_pf
				Cbx_mis_cata_crk_vf
				Cbx_mis_cata_igc_1_vf
				Cbx_mis_cata_lbup_vf
				Cbx_mis_cata_igc_4_pf
				Cbx_mis_cata_igc_4_mfo
				Cbx_mis_cata_igc_3_vf
				Cbx_mis_cata_igc_3_pf
				Cbx_mis_cata_igc_3_mfo
				Cbx_mis_cata_igc_2_vf
				Cbx_mis_cata_fsys_lpg_pf
				Cbx_mis_cata_igc_2_mfo
				Cbx_mis_cata_fsys_lpg_vf
				Cbx_mis_cata_igc_1_pf
				Cbx_mis_cata_igc_1_mfo
				Cbx_mis_cata_gas_pump_vf
				Cbx_mis_cata_gas_pump_pf
				Cbx_mis_cata_gas_pump_mfo
				Cbx_mis_cata_fsys_vf
				Cbx_mis_cata_fsys_pf
				Cbx_mis_cata_inj_ecu_mfo
				Cbx_mis_cata_igc_2_pf
				Cbx_mis_cata_mis_cata_2_lpg_vf
				Cbx_mis_cata_mis_cata_3_lpg_pf
				Cbx_mis_cata_mis_cata_3_lpg_mfo
				Cbx_fsys_obd_sa_vf
				Cbx_mis_cata_mis_cata_2_vf
				Cbx_mis_cata_mis_cata_2_pf
				Cbx_mis_cata_mis_cata_2_mfo
				Cbx_fsys_oil_pf
				Cbx_mis_cata_mis_cata_1_lpg_mfo
				Cbx_fsys_pmh_pf
				Cbx_mis_cata_mis_cata_3_lpg_vf
				Cbx_mis_cata_mis_cata_2_lpg_pf
				Cbx_mis_cata_mis_cata_2_lpg_mfo
				Cbx_mis_cata_mis_cata_1_vf
				Cbx_mis_cata_mis_cata_1_pf
				Cbx_mis_cata_mis_cata_1_mfo
				Cbx_mis_cata_mis_cata_1_lpg_vf
				Cbx_mis_cata_lbup_pf
				Cbx_fsys_pdl_pf
				Cbx_fsys_obd_cata_pf
				Cbx_fsys_lbup_vf
				Cbx_fsys_mvac_sys_pf
				Cbx_mis_cata_mis_cata_4_vf
				Cbx_mis_cata_mis_cata_4_pf
				Cbx_fsys_obd_cata_mfo
				Cbx_mis_cata_mis_cata_4_mfo
				Cbx_mis_cata_mis_cata_4_lpg_vf
				Cbx_fsys_obd_sa_pf
				Cbx_mis_cata_mis_cata_4_lpg_mfo
				Cbx_fsys_obd_sa_mfo
				Cbx_mis_cata_mis_cata_3_vf
				Cbx_mis_cata_mis_cata_3_pf
				Cbx_fsys_obd_cata_vf
				Cbx_mis_cata_mis_cata_3_mfo
				Cbx_fsys_obd_lamb_mfo
				Cbx_fsys_obd_lamb_pf
				Cbx_fsys_obd_lamb_vf
				Cbx_fsys_pow_lbdw_mfo
				Cbx_mis_cata_mis_cata_4_lpg_pf
				Cbx_mis_cata_map_pf
				Cbx_fsys_sa_ev_pf
				Cbx_fsys_sa_ev_vf
				Cbx_fsys_sa_mfo
				Cbx_fsys_sa_pf
				Cbx_fsys_sa_vf
				Cbx_mis_cata_mdf1_pf
				Cbx_mis_cata_mcut_sens1_pf
				Cbx_mis_cata_mis_cata_1_lpg_pf
				Cbx_mis_cata_map_vf
				Cbx_fsys_reserve_3_pf
				Cbx_mis_cata_map_mfo
				Cbx_mis_cata_map_chr_pf
				Cbx_fsys_spg_mfo
				Cbx_mis_cata_lpg_rcpt_vf
				Cbx_mis_cata_lpg_rcpt_pf
				Cbx_mis_cata_lpg_rcpt_mfo
				Cbx_mis_cata_mis_cata_gas_mfo
				Cbx_mis_cata_mastervac_pf
				Cbx_fsys_pow_lbup_vf
				Cbx_mis_cata_min_lpg_lvl_pf
				Cbx_fsys_pow_lbdw_pf
				Cbx_fsys_pow_lbdw_vf
				Cbx_mis_cata_min_gas_lvl_vf
				Cbx_mis_cata_min_gas_lvl_pf
				Cbx_mis_cata_min_gas_lvl_mfo
				Cbx_mis_cata_mdf2_pf
				Cbx_fsys_sa_ev_mfo
				Cbx_fsys_pow_lbup_pf
				Cbx_fsys_rmc_pf
				Cbx_fsys_ptc_pf
				Cbx_fsys_ptc_rov_pf
				Cbx_fsys_pws_pf
				Cbx_fsys_rams_pdl_mfo
				Cbx_fsys_rams_pdl_pf
				Cbx_fsys_rams_pdl_vf
				Cbx_fsys_rams_pf
				Cbx_mis_cata_lbup_pump_crt_pf
				Cbx_fsys_pow_lbup_mfo
				Cbx_schd_spg_sys_vf
				Cbx_schd_tia_vf
				Cbx_schd_tia_pf
				Cbx_schd_tia_mfo
				Cbx_schd_thr_pf
				Cbx_schd_thr_cmd_pf
				Cbx_schd_thpl_pf
				Cbx_schd_tco_vf
				Cbx_schd_tco_pf
				Cbx_schd_tco_mfo
				Cbx_schd_swlk_pf
				Cbx_schd_svkl_pf
				Cxx_dtc_thr_sens2_vb_sc
				Cbx_schd_spg_vf
				Cbx_schd_tlz_ad_b_pf
				Cbx_schd_spg_sys_pf
				Cbx_schd_spg_sys_mfo
				Cbx_schd_spg_pf
				Cbx_schd_spg_mfo
				Cbx_schd_sa_vf
				Cbx_schd_sa_pf
				Cbx_schd_sa_mfo
				Cbx_schd_sa_ev_vf
				Cbx_schd_sa_ev_pf
				Cbx_schd_sa_ev_mfo
				Cbx_schd_rmc_pf
				Cbx_schd_reserve_3_pf
				Cbx_schd_spi_cc_pf
				Cbx_schd_vvt_int_old_off_mfo
				Cxx_dtc_cru_on_off_chr
				Cbx_schd_wpmp_pf
				Cbx_schd_wgc_vf
				Cbx_schd_wgc_pf
				Cbx_schd_wgc_mfo
				Cbx_schd_wat_temp_pf
				Cbx_schd_vvtc_toth_3_vf
				Cxx_dtc_cru_brk_cnt2
				Cbx_schd_vvtc_toth_3_mfo
				Cbx_schd_vvt_intake_vf
				Cbx_schd_vvt_intake_pf
				Cbx_schd_vvt_intake_mfo
				Cbx_schd_tjy_ctl_pf
				Cbx_schd_vvt_int_old_off_vf
				Cbx_schd_tlz_ad_b_mfo
				Cbx_schd_vvt_int_ev_vf
				Cbx_schd_vvt_int_ev_pf
				Cbx_schd_vvt_int_ev_mfo
				Cbx_schd_vta_intake_vf
				Cbx_schd_vta_intake_pf
				Cbx_schd_vta_intake_mfo
				Cbx_schd_vs_vf
				Cbx_schd_vs_pf
				Cbx_schd_vs_mfo
				Cbx_schd_vb_pf
				Cbx_schd_tlz_ad_b_vf
				Cbx_schd_rams_pdl_pf
				Cbx_schd_vvt_int_pf
				Cbx_schd_mis_polu_3_mfo
				Cbx_schd_rams_pf
				Cbx_schd_mis_polu_lpg_pf
				Cbx_schd_mis_polu_lpg_mfo
				Cbx_schd_mis_polu_gas_vf
				Cbx_schd_mis_polu_gas_pf
				Cbx_schd_mis_polu_gas_mfo
				Cbx_schd_mis_polu_4_vf
				Cbx_schd_mis_polu_4_pf
				Cbx_schd_mis_polu_4_mfo
				Cbx_schd_mis_polu_4_lpg_vf
				Cbx_schd_mis_polu_4_lpg_pf
				Cbx_schd_mis_polu_4_lpg_mfo
				Cbx_schd_mis_polu_mfo
				Cbx_schd_mis_polu_3_pf
				Cbx_schd_mis_polu_pf
				Cbx_schd_mis_polu_3_lpg_vf
				Cbx_schd_mis_polu_3_lpg_pf
				Cbx_schd_mis_polu_3_lpg_mfo
				Cbx_schd_mis_polu_2_vf
				Cbx_schd_mis_polu_2_pf
				Cbx_schd_mis_polu_2_mfo
				Cbx_schd_mis_polu_2_lpg_vf
				Cbx_schd_mis_polu_2_lpg_pf
				Cbx_schd_mis_polu_2_lpg_mfo
				Cbx_schd_mis_polu_1_vf
				Cbx_schd_mis_polu_1_pf
				Cbx_schd_mis_polu_1_mfo
				Cbx_schd_mis_polu_3_vf
				Cbx_schd_obd_sa_vf
				Cxx_dtc_eng_temp
				Cbx_schd_rams_pdl_mfo
				Cbx_schd_pws_pf
				Cbx_schd_ptc_rov_pf
				Cbx_schd_ptc_pf
				Cbx_schd_pow_lbup_vf
				Cbx_schd_pow_lbup_pf
				Cbx_schd_pow_lbup_mfo
				Cbx_schd_pow_lbdw_vf
				Cbx_schd_pow_lbdw_pf
				Cbx_schd_pow_lbdw_mfo
				Cbx_schd_pmh_pf
				Cbx_schd_mis_polu_lpg_vf
				Cbx_schd_oil_pf
				Cbx_schd_rams_pdl_vf
				Cbx_schd_obd_sa_pf
				Cbx_schd_obd_sa_mfo
				Cbx_schd_obd_lamb_vf
				Cbx_schd_obd_lamb_pf
				Cbx_schd_obd_lamb_mfo
				Cbx_schd_obd_cata_vf
				Cbx_schd_obd_cata_pf
				Cbx_schd_obd_cata_mfo
				Cbx_schd_mvac_sys_pf
				Cbx_schd_mvac_pump_pf
				Cbx_schd_mod_bch
				Cbx_schd_mis_polu_vf
				Cbx_schd_pdl_pf
				Cxx_dtc_pdl_sens2_vb_sc
				Cxx_dtc_mis_polu_lpg
				Cxx_dtc_sa_ev
				Cxx_dtc_sa
				Cxx_dtc_rmc
				Cxx_dtc_rams_tq_ctl
				Cxx_dtc_rams_pdl
				Cxx_dtc_pws_thr_pdl1
				Cxx_dtc_pws_pdl2
				Cxx_dtc_pws_2
				Cxx_dtc_pws_1
				Cxx_dtc_ptc_rov
				Cxx_dtc_ptc
				Cxx_dtc_spg_sys
				Cxx_dtc_pow_lbdw
				Cxx_dtc_spi_cc
				Cxx_dtc_pdl_sens2_oc
				Cxx_dtc_pdl_sens1_vb_sc
				Cxx_dtc_pdl_sens1_oc
				Cxx_dtc_pdl_sens_chr
				Cxx_dtc_oil
				Cxx_dtc_obd_sa
				Cxx_dtc_obd_lamb
				Cxx_dtc_obd_cata
				Cxx_dtc_mvac_sys
				Cxx_dtc_mvac_pump_vb_sc
				Cxx_dtc_mvac_pump_scg
				Cxx_dtc_cru_whl_cmd
				Cxx_dtc_pow_lbup
				Cxx_dtc_wpmp
				Cxx_dtc_tia
				Cxx_dtc_thr_sens2_scg
				Cxx_dtc_tjy_ctl
				Cxx_dtc_tlz_ad_b
				Cxx_dtc_vb
				Cxx_dtc_vs
				Cxx_dtc_vta_intake
				Cxx_dtc_vvt_int_ev
				Cxx_dtc_vvt_int_old_off
				Cxx_dtc_vvt_intake
				Cxx_dtc_thr_sens1_vb_sc
				Cxx_dtc_vvtc_toth_3
				Cxx_dtc_spg
				Cxx_dtc_wgc
				Cxx_dtc_mis_polu_gas
				Cxx_dtc_thr_sens_chr
				Cxx_dtc_thr_cmd_vb_sc
				Cxx_dtc_thr_cmd_cpt
				Cxx_dtc_thpl
				Cxx_dtc_tco
				Cxx_dtc_swlk_mem
				Cxx_dtc_svkl_trt_srch
				Cxx_dtc_svkl_sge
				Cxx_dtc_svkl_psn
				Cxx_dtc_svkl_oc
				Cxx_dtc_svkl_lih
				Cxx_dtc_svkl_chk_springs
				Cxx_dtc_thr_sens1_oc
				Cxx_dtc_inj3
				Cxx_dtc_mvac_pump_oc
				Cxx_dtc_lbup_pump_crt
				Cxx_dtc_lbup_hot
				Cxx_dtc_lbup
				Cbx_tlz_ad_cor_val_req
				Cbx_tlz_ad_cor_fil_req
				Cbx_tlz_ad_b2_fil_req
				Cbx_tlz_ad_b1_fil_req
				Cxx_dtc_lbdw_pump_crt
				Cxx_dtc_lbdw_hot
				Cxx_dtc_lbdw
				Cxx_dtc_knk
				Cxx_dtc_map
				Cxx_dtc_inj4
				Cxx_dtc_map_chr
				Cxx_dtc_inj2
				Cxx_dtc_inj1
				Cxx_dtc_inj_ecu
				Cxx_dtc_igc_4
				Cxx_dtc_igc_3
				Cxx_dtc_igc_2
				Cxx_dtc_igc_1
				Cxx_dtc_gas_pump
				Cxx_dtc_fsys_lpg
				Cxx_dtc_fsys
				Cxx_dtc_eng_whl
				Cbx_schd_mis_polu_1_lpg_mfo
				Cxx_dtc_ip_inj_cnt
				Cxx_dtc_mis_cata_4
				Cxx_dtc_mis_polu_4_lpg
				Cxx_dtc_mis_polu_4
				Cxx_dtc_mis_polu_3_lpg
				Cxx_dtc_mis_polu_3
				Cxx_dtc_mis_polu_2_lpg
				Cxx_dtc_mis_polu_2
				Cxx_dtc_mis_polu_1_lpg
				Cxx_dtc_mis_polu_1
				Cxx_dtc_mis_polu
				Cxx_dtc_mis_lih
				Cxx_dtc_mis_fast
				Cxx_dtc_mis_cata_lpg
				Cxx_dtc_lpg_rcpt
				Cxx_dtc_mis_cata_4_lpg
				Cxx_dtc_el_wind_rcpt
				Cxx_dtc_mis_cata_3_lpg
				Cxx_dtc_mis_cata_3
				Cxx_dtc_mis_cata_2_lpg
				Cxx_dtc_mis_cata_2
				Cxx_dtc_mis_cata_1_lpg
				Cxx_dtc_mis_cata_1
				Cxx_dtc_mis_cata
				Cxx_dtc_min_lpg_lvl
				Cxx_dtc_min_gas_lvl
				Cxx_dtc_mdf2
				Cxx_dtc_mdf1
				Cxx_dtc_mcut_sens1
				Cxx_dtc_mis_cata_gas
				Cbx_sa_wgc_mfo
				Cbx_sa_vvt_int_ev_mfo
				Cbx_schd_air_pf
				Cbx_schd_air_mfo
				Cbx_schd_agb_rcpt_vf
				Cbx_schd_agb_rcpt_mfo
				Cbx_schd_agb_pf
				Cbx_schd_actr_rly_pf
				Cbx_schd_actr_rly_cut_pf
				Cbx_schd_acr_pf
				Cbx_schd_ac_rcpt_pf
				Cbx_schd_ac_prs_pf
				Cbx_sa_wpmp_pf
				Cbx_schd_alt_load_in_pf
				Cbx_sa_wgc_pf
				Cbx_schd_alt_pf
				Cbx_sa_wat_temp_pf
				Cbx_sa_vvtc_toth_3_vf
				Cbx_sa_vvtc_toth_3_pf
				Cbx_sa_vvtc_toth_3_mfo
				Cbx_sa_vvt_intake_vf
				Cbx_sa_vvt_intake_pf
				Cbx_sa_vvt_intake_mfo
				Cbx_sa_vvt_int_pf
				Cbx_sa_vvt_int_old_off_vf
				Cbx_sa_vvt_int_old_off_mfo
				Cbx_sa_vvt_int_ev_vf
				Cbx_schd_fsys_vf
				Cbx_sa_wgc_vf
				Cbx_schd_crk_nr_pf
				Cbx_schd_mis_polu_1_lpg_vf
				Cbx_schd_fsys_mfo
				Cbx_schd_fsys_lpg_vf
				Cbx_schd_fsys_lpg_pf
				Cbx_schd_fsys_lpg_mfo
				Cbx_schd_eng_whl_vf
				Cbx_schd_eng_whl_pf
				Cbx_schd_eng_whl_mfo
				Cbx_schd_eng_temp_pf
				Cbx_schd_el_wind_rcpt_pf
				Cbx_schd_cru_pf
				Cbx_schd_crk_vf
				Cbx_schd_air_vf
				Cbx_schd_crk_nr_vf
				Cbx_sa_vta_intake_vf
				Cbx_schd_crk_nr_mfo
				Cbx_schd_crk_mfo
				Cbx_schd_cp_vf
				Cbx_schd_cp_pf
				Cbx_schd_cp_mfo
				Cbx_schd_clu_vf
				Cbx_schd_clu_pf
				Cbx_schd_clu_mfo
				Cbx_schd_checksum_pf
				Cbx_schd_bkup_mem_vf
				Cbx_schd_bkup_mem_pf
				Cbx_schd_bkup_mem_mfo
				Cbx_schd_crk_pf
				Cbx_sa_pow_lbup_vf
				Cbx_sa_vvt_int_ev_pf
				Cbx_sa_sa_mfo
				Cbx_sa_sa_ev_vf
				Cbx_sa_sa_ev_pf
				Cbx_sa_sa_ev_mfo
				Cbx_sa_rmc_pf
				Cbx_sa_reserve_3_pf
				Cbx_sa_rams_pf
				Cbx_sa_rams_pdl_vf
				Cbx_sa_rams_pdl_pf
				Cbx_sa_rams_pdl_mfo
				Cbx_sa_pws_pf
				Cbx_sa_sa_vf
				Cbx_sa_ptc_pf
				Cbx_sa_spg_mfo
				Cbx_sa_pow_lbup_pf
				Cbx_sa_pow_lbup_mfo
				Cbx_sa_pow_lbdw_vf
				Cbx_sa_pow_lbdw_pf
				Cbx_sa_pow_lbdw_mfo
				Cbx_sa_pmh_pf
				Cbx_sa_pdl_pf
				Cbx_sa_oil_pf
				Cbx_sa_obd_sa_vf
				Cbx_sa_obd_sa_pf
				Cbx_sa_obd_sa_mfo
				Cbx_sa_obd_lamb_vf
				Cbx_sa_ptc_rov_pf
				Cbx_sa_thr_cmd_pf
				Cbx_sa_vta_intake_pf
				Cbx_sa_vta_intake_mfo
				Cbx_sa_vs_vf
				Cbx_sa_vs_pf
				Cbx_sa_vs_mfo
				Cbx_sa_vb_pf
				Cbx_sa_tlz_ad_b_vf
				Cbx_sa_tlz_ad_b_pf
				Cbx_sa_tlz_ad_b_mfo
				Cbx_sa_tjy_ctl_pf
				Cbx_sa_tia_vf
				Cbx_sa_tia_pf
				Cbx_sa_sa_pf
				Cbx_sa_thr_pf
				Cbx_schd_gas_pump_mfo
				Cbx_sa_thpl_pf
				Cbx_sa_tco_vf
				Cbx_sa_tco_pf
				Cbx_sa_tco_mfo
				Cbx_sa_swlk_pf
				Cbx_sa_svkl_pf
				Cbx_sa_spi_cc_pf
				Cbx_sa_spg_vf
				Cbx_sa_spg_sys_vf
				Cbx_sa_spg_sys_pf
				Cbx_sa_spg_sys_mfo
				Cbx_sa_spg_pf
				Cbx_sa_tia_mfo
				Cbx_schd_mis_cata_1_mfo
				Cxx_dtc_clu
				Cxx_dtc_bkup_mem
				Cxx_dtc_alt
				Cbx_schd_mis_cata_2_lpg_pf
				Cbx_schd_mis_cata_2_lpg_mfo
				Cxx_dtc_air
				Cxx_dtc_agb_rcpt
				Cxx_dtc_agb_gear
				Cxx_dtc_agb_conv_stt
				Cxx_dtc_actr_rly
				Cbx_schd_mis_cata_1_vf
				Cbx_schd_mdf2_pf
				Cbx_schd_mis_cata_1_pf
				Cbx_schd_mis_cata_2_mfo
				Cbx_schd_mis_cata_1_lpg_vf
				Cxx_dtc_ac_rcpt
				Cxx_dtc_ac_prs
				Cxx_air_wht_fmt_fac
				Cbx_schd_mis_cata_gas_pf
				Cbx_schd_mis_cata_1_lpg_pf
				Cbx_sa_obd_lamb_pf
				Cbx_schd_mis_cata_1_lpg_mfo
				Cbx_schd_min_lpg_lvl_pf
				Cbx_schd_min_gas_lvl_vf
				Cbx_schd_min_gas_lvl_pf
				Cbx_schd_fsys_pf
				Cxx_dtc_acr
				Cbx_schd_mis_cata_4_lpg_vf
				Cbx_schd_mis_lih_pf
				Cbx_schd_mis_fast_pf
				Cbx_schd_mis_cata_vf
				Cbx_schd_mis_cata_pf
				Cbx_schd_mis_cata_mfo
				Cbx_schd_mis_cata_lpg_vf
				Cbx_schd_mis_cata_lpg_pf
				Cxx_dtc_cru_brk_cnt1
				Cbx_schd_mis_cata_gas_vf
				Cxx_dtc_crk_nr
				Cbx_schd_mis_cata_gas_mfo
				Cbx_schd_mis_cata_4_vf
				Cxx_dtc_cp
				Cbx_schd_mis_cata_4_mfo
				Cbx_schd_mis_cata_2_lpg_vf
				Cbx_schd_mis_cata_4_lpg_pf
				Cxx_dtc_crk
				Cbx_schd_mis_cata_4_lpg_mfo
				Cbx_schd_mis_cata_3_vf
				Cbx_schd_mis_cata_3_pf
				Cbx_schd_mis_cata_3_mfo
				Cbx_schd_mis_cata_3_lpg_vf
				Cbx_schd_mis_cata_3_lpg_pf
				Cbx_schd_mis_cata_3_lpg_mfo
				Cbx_schd_mis_cata_2_vf
				Cbx_schd_mis_cata_2_pf
				Cbx_schd_mdf1_pf
				Cbx_schd_mis_cata_4_pf
				Cbx_schd_igc_4_pf
				Cbx_schd_min_gas_lvl_mfo
				Cbx_schd_inj3_vf
				Cbx_schd_inj3_pf
				Cbx_schd_inj3_mfo
				Cbx_schd_inj2_vf
				Cbx_schd_inj2_pf
				Cbx_schd_inj2_mfo
				Cbx_schd_inj1_vf
				Cbx_schd_inj1_pf
				Cbx_schd_inj1_mfo
				Cbx_schd_inj_ecu_vf
				Cbx_schd_inj_ecu_pf
				Cbx_schd_inj4_pf
				Cbx_schd_igc_4_vf
				Cbx_schd_inj4_vf
				Cbx_schd_igc_4_mfo
				Cbx_schd_igc_3_vf
				Cbx_schd_igc_3_pf
				Cbx_schd_igc_3_mfo
				Cbx_schd_igc_2_vf
				Cbx_schd_igc_2_pf
				Cbx_schd_igc_2_mfo
				Cbx_schd_igc_1_vf
				Cbx_schd_igc_1_pf
				Cbx_schd_igc_1_mfo
				Cbx_schd_gas_pump_vf
				Cbx_schd_gas_pump_pf
				Cbx_schd_inj_ecu_mfo
				Cbx_schd_lbup_hot_vf
				Cbx_schd_mcut_sens1_pf
				Cbx_schd_mastervac_pf
				Cbx_schd_map_vf
				Cbx_schd_map_pf
				Cbx_schd_map_mfo
				Cbx_schd_map_chr_pf
				Cbx_schd_lpg_rcpt_vf
				Cbx_schd_lpg_rcpt_pf
				Cbx_schd_lpg_rcpt_mfo
				Cbx_schd_lbup_vf
				Cbx_schd_lbup_pump_crt_pf
				Cbx_schd_inj4_mfo
				Cbx_schd_lbup_mfo
				Cbx_schd_lbdw_hot_vf
				Cbx_schd_ip_inj_cnt_pf
				Cbx_schd_knk_mfo
				Cbx_schd_knk_pf
				Cbx_schd_knk_vf
				Cbx_schd_lbup_pf
				Cbx_schd_lbdw_hot_pf
				Cbx_schd_mis_polu_1_lpg_pf
				Cbx_schd_lbdw_mfo
				Cbx_schd_lbdw_pf
				Cbx_schd_lbdw_pump_crt_pf
				Cbx_schd_lbdw_vf
				Cbx_schd_lbup_hot_mfo
				Cbx_schd_lbup_hot_pf
				Cbx_schd_lbdw_hot_mfo
				Cxx_pftv_inj1
				Cxx_mfnrsta_mis_cata_4_lpg
				Cxx_mfnrsta_mis_cata_gas
				Cxx_mfnrsta_mis_cata_lpg
				Cxx_pftv_igc_3
				Cxx_mfnrsta_mis_fast
				Cxx_pftv_lbup
				Cxx_pfdec_mis_polu_lpg
				Cxx_pftv_lbdw_hot
				Cxx_pftv_inj_ecu
				Cxx_pftv_inj3
				Cxx_mfnrsta_mis_cata_4
				Cxx_pftv_inj2
				Cxx_pftv_lpg_rcpt
				Cxx_pftv_lbdw
				Cxx_pftv_knk
				Cxx_pftv_inj4
				Cxx_pftv_igc_4
				Cxx_pftv_mis_cata_1
				Cxx_pftv_igc_2
				Cxx_mfnrsta_mis_cata_2
				Cxx_mfnrsta_mis_cata_1_lpg
				Cxx_mfnrsta_mis_cata_1
				Cxx_mfnrsta_mis_cata
				Cxx_pftv_mis_cata_2_lpg
				Cxx_mfnrsta_mis_lih
				Cxx_pftv_mis_cata_1_lpg
				Cxx_mfnrsta_mis_cata_3_lpg
				Cxx_mfnrsta_mis_cata_2_lpg
				Cxx_pfdec_mis_polu_4_lpg
				Cxx_pftv_min_gas_lvl
				Cxx_pftv_map
				Cxx_pftv_lbup_hot
				Cxx_pftv_mis_cata
				Cxx_mfnrsta_mis_cata_3
				Cxx_pftv_mis_cata_2
				Recurrence_misfire_deterministe_
				Cxx_pfinc_mis_cata_4_lpg
				Cxx_pfinc_mis_polu_3
				Cxx_pfinc_mis_polu_2_lpg
				Cxx_pfinc_mis_polu_2
				Cxx_pfinc_mis_polu_1_lpg
				Cxx_pfinc_mis_polu_1
				Cxx_pfinc_mis_cata_lpg
				Cxx_pfinc_mis_polu_4
				Cxx_pfinc_mis_cata_4
				Cxx_pfinc_mis_polu_4_lpg
				Cxx_pfinc_mis_cata_3_lpg
				Cxx_pfinc_mis_cata_3
				Cxx_pfinc_mis_cata_2_lpg
				Cxx_pfinc_mis_cata_2
				Cxx_pfinc_mis_cata_1_lpg
				Cxx_pfinc_mis_cata_1
				Cxx_mfnrsta_air
				Cxx_pfdec_mis_polu_4
				Cxx_pftv_air
				Cxx_pftv_gas_pump
				Cxx_pftv_fsys_lpg
				Cxx_pftv_fsys
				Cxx_pftv_eng_whl
				Cxx_pftv_crk_nr
				Cxx_pftv_crk
				Cxx_pftv_cp
				Cxx_pfinc_mis_polu_3_lpg
				Cxx_pftv_bkup_mem
				Cxx_pftv_igc_1
				Cxx_pftv_agb_rcpt
				Cxx_mis_diag_obd_dsb_t
				Cxx_pfinc_air
				Cxx_mis_rat_min_cyl_
				Cxx_pfinc_mis_polu_lpg
				Cxx_mfnrsta_fsys_lpg
				Cxx_pfinc_fsys_lpg
				Cxx_pftv_clu
				Cxx_pftv_mis_polu_1_lpg
				Cxx_pftv_mis_polu
				Cxx_pftv_rams_pdl
				Cxx_pftv_pow_lbup
				Cxx_pftv_pow_lbdw
				Cxx_pftv_obd_sa
				Cxx_pftv_obd_lamb
				Cxx_pftv_obd_cata
				Cxx_pftv_sa_ev
				Cxx_pftv_mis_polu_gas
				Cxx_pfdec_fsys_lpg
				Cxx_pftv_mis_polu_4
				Cxx_pfdec_mis_polu_3_lpg
				Cxx_lvl_diag_cata
				Cxx_pftv_mis_polu_3
				Cxx_pftv_mis_polu_2_lpg
				Mode_deterministe_
				Cxx_pftv_mis_polu_2
				Cxx_pftv_mis_polu_1
				Cxx_pftv_mis_polu_lpg
				Cxx_pftv_vta_intake
				Cxx_lvl_diag_lamb
				Cxx_lvl_diag_sa
				Cxx_pftv_wgc
				Cxx_pftv_vvtc_toth_3
				Cxx_pftv_vvt_intake
				Cxx_pftv_vvt_int_old_off
				Cxx_pftv_vvt_int_ev
				Cxx_pftv_sa
				Cxx_trz_ad_b_n_max
				Cxx_pftv_mis_polu_3_lpg
				Cxx_pftv_vs
				Cxx_pftv_tlz_ad_b
				Cxx_pftv_tia
				Cxx_pfdec_air
				Cxx_pftv_tco
				Cxx_pftv_spg_sys
				Cxx_pftv_spg
				Cxx_obd_fail_off_vld_dly
				Cxx_trz_ad_b_n_min
				Cxx_mfnrsta_mis_polu_2
				Cxx_mfnrsta_mis_polu_2_lpg
				Cxx_mfnrsta_oil_co
				Cxx_pfdec_mis_cata_1_lpg
				Cxx_pftv_mis_polu_4_lpg
				Cxx_pfdec_mis_cata_2
				Cxx_pfdec_mis_cata_2_lpg
				Cxx_pfdec_mis_cata_3
				Cxx_pfdec_mis_cata_3_lpg
				Cxx_mfnrsta_mis_polu_3
				Cxx_pfdec_mis_cata_4_lpg
				Cxx_pfdec_mis_cata_1
				Cxx_pfdec_mis_cata_lpg
				Cxx_mfnrsta_mis_polu_1_lpg
				Cxx_mfnrsta_mis_polu_1
				Cxx_mfnrsta_mis_polu
				Cxx_pfdec_mis_polu_1
				Cxx_pfdec_mis_polu_1_lpg
				Cxx_pfdec_mis_polu_2
				Cxx_pfdec_mis_polu_2_lpg
				Cxx_pfdec_mis_polu_3
				Cxx_pfdec_mis_cata_4
				Cxx_pftv_mis_cata_4
				Cxx_mfnrsta_oil_cc
				Cxx_mfnrsta_obd_sa
				Cxx_pftv_mis_cata_lpg
				Cxx_mfnrsta_obd_lamb
				Cxx_pftv_mis_cata_4_lpg
				Cxx_pftv_mis_cata_3_lpg
				Cxx_mfnrsta_obd_cata
				Cxx_pftv_mis_cata_3
				Cxx_mfnrsta_mvac_sys
				Cxx_mfnrsta_mvac_pump_vb_sc
				Cxx_mfnrsta_mvac_pump_scg
				Cxx_mfnrsta_mis_polu_lpg
				Cxx_mfnrsta_mis_polu_gas
				Cxx_mfnrsta_mis_polu_4_lpg
				Cxx_mfnrsta_mis_polu_4
				Cxx_mfnrsta_mis_polu_3_lpg
				Cxx_pftv_mis_cata_gas
				Cxx_mfnrsta_mvac_pump_oc
				Cbx_cata_igc_3_mfo
				Cbx_cata_inj2_pf
				Cbx_cata_knk_vf
				Cbx_cata_knk_pf
				Cbx_cata_knk_mfo
				Cbx_cata_igc_2_mfo
				Cbx_cata_igc_2_pf
				Cbx_cata_igc_2_vf
				Cbx_cata_ip_inj_cnt_pf
				Cbx_cata_lbdw_hot_mfo
				Cbx_cata_inj2_mfo
				Cbx_cata_igc_4_mfo
				Cbx_cata_igc_4_pf
				Cbx_cata_igc_4_vf
				Cbx_cata_inj_ecu_mfo
				Cbx_cata_inj_ecu_pf
				Cbx_cata_inj_ecu_vf
				Cbx_cata_inj1_mfo
				Cbx_cata_inj3_mfo
				Cbx_cata_inj1_vf
				Cbx_cata_inj4_vf
				Cbx_cata_inj2_vf
				Cbx_cata_inj3_pf
				Cbx_cata_igc_3_vf
				Cbx_cata_inj3_vf
				Cbx_cata_inj4_mfo
				Cbx_cata_inj4_pf
				Cbx_cata_igc_3_pf
				Cbx_cata_inj1_pf
				Cbx_cata_air_vf
				Cbx_cata_eng_temp_pf
				Cbx_cata_cp_pf
				Cbx_cata_cp_mfo
				Cbx_cata_clu_vf
				Cbx_cata_clu_pf
				Cbx_cata_clu_mfo
				Cbx_cata_checksum_pf
				Cbx_cata_bkup_mem_vf
				Cbx_cata_bkup_mem_pf
				Cbx_cata_bkup_mem_mfo
				Cbx_cata_crk_mfo
				Cbx_cata_alt_load_in_pf
				Cbx_cata_crk_nr_mfo
				Cbx_cata_air_pf
				Cbx_cata_air_mfo
				Cbx_cata_agb_rcpt_vf
				Cbx_cata_agb_rcpt_mfo
				Cbx_cata_agb_pf
				Cbx_cata_actr_rly_pf
				Cbx_cata_actr_rly_cut_pf
				Cbx_cata_acr_pf
				Cbx_cata_ac_rcpt_pf
				Cbx_cata_ac_prs_pf
				Cbx_cata_alt_pf
				Cbx_cata_eng_whl_pf
				Cbx_cata_igc_1_pf
				Cbx_cata_igc_1_mfo
				Cbx_cata_gas_pump_vf
				Cbx_cata_gas_pump_pf
				Cbx_cata_gas_pump_mfo
				Cbx_cata_fsys_vf
				Cbx_cata_fsys_pf
				Cbx_cata_fsys_mfo
				Cbx_cata_fsys_lpg_vf
				Cbx_cata_fsys_lpg_pf
				Cbx_cata_cp_vf
				Cbx_cata_eng_whl_vf
				Cbx_cata_igc_1_vf
				Cbx_cata_eng_whl_mfo
				Cbx_cata_el_wind_rcpt_pf
				Cbx_cata_mis_cata_1_lpg_pf
				Cbx_cata_lbdw_hot_pf
				Cbx_cata_diag_stg_bch_mod
				Cbx_cata_cru_pf
				Cbx_cata_crk_vf
				Cbx_cata_crk_pf
				Cbx_cata_crk_nr_vf
				Cbx_cata_crk_nr_pf
				Cbx_cata_fsys_lpg_mfo
				Cbx_cata_vvt_int_ev_vf
				Cbx_cata_vb_pf
				Cbx_cata_wgc_pf
				Cbx_cata_wgc_mfo
				Cbx_cata_wat_temp_pf
				Cbx_cata_vvtc_toth_3_vf
				Cbx_cata_vvtc_toth_3_pf
				Cbx_cata_vvtc_toth_3_mfo
				Cbx_cata_vvt_intake_vf
				Cbx_cata_vvt_intake_pf
				Cbx_cata_vvt_intake_mfo
				Cbx_cata_vvt_int_pf
				Cbx_cata_wpmp_pf
				Cbx_cata_vvt_int_old_off_mfo
				Cbx_cata_mis_polu_vf
				Cbx_cata_vvt_int_ev_pf
				Cbx_cata_vvt_int_ev_mfo
				Cbx_cata_vta_intake_vf
				Cbx_cata_vta_intake_pf
				Cbx_cata_vta_intake_mfo
				Cbx_cata_vs_vf
				Cbx_cata_vs_pf
				Cbx_cata_vs_mfo
				Cbx_cata_mvac_sys_pf
				Cbx_cata_obd_cata_mfo
				Cbx_cata_mis_polu_1_vf
				Cbx_cata_vvt_int_old_off_vf
				Cbx_cata_mis_polu_4_lpg_vf
				Cbx_cata_mis_polu_2_lpg_mfo
				Cbx_cata_mis_polu_2_lpg_pf
				Cbx_cata_mis_polu_2_lpg_vf
				Cbx_cata_mis_polu_2_mfo
				Cbx_cata_mis_polu_2_pf
				Cbx_cata_mis_polu_2_vf
				Cbx_cata_lbdw_hot_vf
				Cbx_cata_mis_polu_3_lpg_pf
				Cbx_cata_mis_polu_3_mfo
				Cbx_cata_mis_polu_3_pf
				Cbx_cata_mis_polu_3_vf
				Cbx_cata_wgc_vf
				Cbx_cata_mis_polu_4_lpg_pf
				Cbx_cata_tlz_ad_b_vf
				Cbx_cata_mis_polu_4_mfo
				Cbx_cata_mis_polu_4_pf
				Cbx_cata_mis_polu_4_vf
				Cbx_cata_mis_polu_gas_mfo
				Cbx_cata_mis_polu_gas_pf
				Cbx_cata_mis_polu_gas_vf
				Cbx_cata_mis_polu_lpg_mfo
				Cbx_cata_mis_polu_lpg_pf
				Cbx_cata_mis_polu_lpg_vf
				Cbx_cata_mis_polu_mfo
				Cbx_cata_mis_polu_pf
				Cbx_cata_mis_polu_4_lpg_mfo
				Cbx_cata_rams_pdl_vf
				Cbx_cata_obd_cata_pf
				Cbx_cata_spg_sys_mfo
				Cbx_cata_spg_pf
				Cbx_cata_spg_mfo
				Cbx_cata_sa_vf
				Cbx_cata_sa_pf
				Cbx_cata_sa_mfo
				Cbx_cata_sa_ev_vf
				Cbx_cata_sa_ev_pf
				Cbx_cata_sa_ev_mfo
				Cbx_cata_rmc_pf
				Cbx_cata_pdl_pf
				Cbx_cata_rams_pf
				Cbx_cata_spg_sys_pf
				Cbx_cata_rams_pdl_pf
				Cbx_cata_rams_pdl_mfo
				Cbx_cata_pws_pf
				Cbx_cata_ptc_rov_pf
				Cbx_cata_ptc_pf
				Cbx_cata_pow_lbup_vf
				Cbx_cata_pow_lbup_pf
				Cbx_cata_pow_lbdw_mfo
				Cbx_cata_pow_lbdw_pf
				Cbx_cata_pow_lbdw_vf
				Cbx_cata_pow_lbup_mfo
				Cbx_cata_reserve_3_pf
				Cbx_cata_tco_vf
				Cbx_cata_tlz_ad_b_pf
				Cbx_cata_obd_cata_vf
				Cbx_cata_obd_lamb_mfo
				Cbx_cata_obd_lamb_pf
				Cbx_cata_obd_lamb_vf
				Cbx_cata_tlz_ad_b_mfo
				Cbx_cata_tjy_ctl_pf
				Cbx_cata_tia_vf
				Cbx_cata_tia_pf
				Cbx_cata_tia_mfo
				Cbx_cata_thr_pf
				Cbx_cata_pmh_pf
				Cbx_cata_thpl_pf
				Cbx_cata_mis_polu_3_lpg_mfo
				Cbx_cata_tco_pf
				Cbx_cata_tco_mfo
				Cbx_cata_swlk_pf
				Cbx_cata_svkl_pf
				Cbx_cata_spi_cc_pf
				Cbx_cata_obd_sa_mfo
				Cbx_cata_spg_vf
				Cbx_cata_obd_sa_pf
				Cbx_cata_spg_sys_vf
				Cbx_cata_obd_sa_vf
				Cbx_cata_oil_pf
				Cbx_cata_thr_cmd_pf
				Cbx_cata_mis_cata_gas_pf
				Cbx_cata_mis_cata_3_pf
				Cbx_cata_mis_cata_3_vf
				Cbx_cata_mis_cata_4_lpg_mfo
				Cbx_cata_mis_cata_4_lpg_pf
				Cbx_cata_mis_cata_4_lpg_vf
				Cbx_cata_mis_cata_4_mfo
				Cbx_cata_mis_cata_4_pf
				Cbx_cata_mis_fast_pf
				Cbx_cata_mis_cata_gas_mfo
				Cbx_cata_mis_cata_3_lpg_pf
				Cbx_cata_mis_cata_gas_vf
				Cbx_cata_mis_cata_lpg_mfo
				Cbx_cata_mis_cata_lpg_pf
				Cbx_cata_mis_cata_lpg_vf
				Cbx_cata_mis_cata_mfo
				Cbx_cata_mis_cata_pf
				Cbx_cata_mis_cata_3_lpg_mfo
				Cbx_cata_mis_cata_4_vf
				Cbx_cata_mis_cata_2_lpg_mfo
				Cbx_cata_min_gas_lvl_vf
				Cbx_cata_min_gas_lvl_pf
				Cbx_cata_min_lpg_lvl_pf
				Cbx_cata_mvac_pump_pf
				Cbx_cata_mis_cata_1_lpg_mfo
				Cbx_cata_mis_cata_1_lpg_vf
				Cbx_cata_mis_cata_1_mfo
				Cbx_cata_mis_cata_3_mfo
				Cbx_cata_mis_cata_1_vf
				Cbx_cata_mis_cata_3_lpg_vf
				Cbx_cata_mis_cata_2_lpg_pf
				Cbx_cata_mis_cata_2_lpg_vf
				Cbx_cata_mis_cata_2_mfo
				Cbx_cata_mis_cata_2_pf
				Cbx_cata_mis_cata_2_vf
				Cbx_cata_mis_polu_3_lpg_vf
				Cbx_cata_mis_polu_1_pf
				Cbx_cata_mis_cata_vf
				Cbx_cata_mis_cata_1_pf
				Cbx_cata_lpg_rcpt_pf
				Cbx_cata_lbup_hot_mfo
				Cbx_cata_lbup_hot_pf
				Cbx_cata_lbup_hot_vf
				Cbx_cata_lbup_mfo
				Cbx_cata_lbdw_pump_crt_pf
				Cbx_cata_lbup_pf
				Cbx_cata_mis_polu_1_lpg_vf
				Cbx_cata_lbdw_pf
				Cbx_cata_mis_lih_pf
				Cbx_cata_lbup_vf
				Cbx_cata_lbdw_vf
				Cbx_cata_lpg_rcpt_mfo
				Cbx_cata_lbup_pump_crt_pf
				Cbx_cata_lpg_rcpt_vf
				Cbx_cata_mdf2_pf
				Cbx_cata_lbdw_mfo
				Cbx_cata_map_mfo
				Cbx_cata_map_pf
				Cbx_cata_map_vf
				Cbx_cata_mastervac_pf
				Cbx_cata_mcut_sens1_pf
				Cbx_cata_mdf1_pf
				Cbx_cata_mis_polu_1_lpg_mfo
				Cbx_cata_map_chr_pf
				Cbx_cata_mis_polu_1_mfo
				Cbx_cata_min_gas_lvl_mfo
				Cbx_cata_mis_polu_1_lpg_pf
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION LIS_sys
			""
			/begin DEF_CHARACTERISTIC
				Cxx_abs_abst_nr_fail
				Cxx_n_mux_emt_max
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION Injection_sys
			""
			/begin DEF_CHARACTERISTIC
				Cbx_ti_cl2_conf
				Cxx_gas_pump_sta_dly
				Cxx_cl_off_n_thd
				Cxx_aftr_inj_n_thd
				Cxx_pfinc_inj1_vb_sc
				Cxx_pfdec_inj2_oc
				Cxx_pfdec_inj1_vb_sc
				Cxx_pfdec_inj1_scg
				Cxx_pfdec_inj1_oc
				Cxx_pfinc_gas_pump_oc
				Cxx_pfinc_gas_pump_scg
				Cxx_pfdec_gas_pump_vb_sc
				Cxx_pfinc_inj4_oc
				Cxx_pfdec_gas_pump_scg
				Inhibe_reactualisation
				Inhibe_coup_post_inj_fin_cy_
				Cxx_pfdec_inj2_scg
				Cxx_pfinc_inj1_scg
				Cxx_pfinc_gas_pump_vb_sc
				Temps_avant_autorise_diagnostic
				Cxx_pfinc_inj4_scg
				Cxx_pfinc_inj2_oc
				Cxx_pfinc_inj2_scg
				Cxx_pfinc_inj3_oc
				Cxx_pfinc_inj3_vb_sc
				Cxx_pfinc_inj3_scg
				Cxx_mfnrsta_inj2_oc
				Cxx_pfinc_inj2_vb_sc
				Cxx_pfinc_inj4_vb_sc
				Cxx_pfdec_gas_pump_oc
				Cxx_pfinc_inj1_oc
				Cxx_mfnrsta_min_gas_lvl
				Cxx_mfnrsta_inj3_vb_sc
				Cxx_mfnrsta_inj3_scg
				Cxx_mfnrsta_inj3_oc
				Cxx_mfnrsta_inj2_vb_sc
				Cxx_mfnrsta_inj4_scg
				Cxx_mfnrsta_inj4_vb_sc
				Cxx_sta_gas_pump_n_thd
				Cxx_mfnrsta_inj1_scg
				Cxx_mfnrsta_inj1_oc
				Cxx_mfnrsta_gas_pump_vb_sc
				Cxx_mfnrsta_inj4_oc
				Cxx_mfnrsta_gas_pump_scg
				Cxx_mfnrsta_gas_pump_oc
				Cxx_mfnrsta_inj2_scg
				Cxx_pfdec_inj2_vb_sc
				Cxx_pfdec_inj3_oc
				Cxx_pfdec_inj3_scg
				Cxx_pfdec_inj3_vb_sc
				Cxx_pfdec_inj4_oc
				Cxx_mfnrsta_inj1_vb_sc
				Cxx_pfdec_inj4_scg
				Cxx_pfdec_inj4_vb_sc
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION P�dale_sys
			""
			/begin DEF_CHARACTERISTIC
				Cxx_acel_pdl_kd_out_thd
				Cxx_kd_rel_pdl_hys
				Cxx_acel_pdl_kd_in_thd
				Cxx_clc_ct_pdl_psn_hys
				Cxx_clc_ct_pdl_psn_thd
				Cxx_clc_pdl_max_psn_thd
				Cxx_kd_thr_hys
				Ssm_pedal_pos_single_1_manu_enab
				Cxx_thr_psn_fil_fac
				Ssm_pedal_pos_normal_manu_inh
				Rmc_pedal_pos_defaut_thresh
				Cxx_mux_pdl_frm_thd1
				Cxx_mux_pdl_frm_thd2
				Cxx_mux_pdl_h_thd
				Cxx_mux_pdl_psn_fac
				Ssm_pedal_pos_single_2_manu_enab
				Cxx_mux_pdl_psn_ofs
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION Anti-K_sys
			""
			/begin DEF_CHARACTERISTIC
				Cxx_knk_fil_fac
				Autorise_clq_num
				Cxx_knk_fail_nr
				Offset_asic_k
				Temps_config_asic
				Cxx_mfnrsta_knk
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION Airbag_sys
			""
			/begin DEF_CHARACTERISTIC
				Tmcrash
				Crash2ca
				Cbx_crsh_typ_phs_1
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION CTP_borne_DF_sys
			""
			/begin DEF_CHARACTERISTIC
				Cxx_h_alt_temp_ref
				Cxx_h_alt_temp_mv
				Cxx_alt_crt_esti_dly
				Cxx_alt_crt_fmt_fac
				Cxx_alt_crt_h_n
				Cxx_alt_crt_l_n
				Cxx_eng_alt_fac
				Cxx_alt_efy
				Cxx_l_alt_vb_ofs
				Cxx_alt_load_nok
				Cxx_alt_pwm_edg_max_dly
				Cxx_alt_pwm_fil_fac
				Cxx_alt_temp_tco_ofs
				Cxx_alt_crt_ofs
				Cxx_h_alt_vb_ofs
				Cxx_h_alt_v_temp_fac
				Cxx_alt_v_fil_fac
				Cxx_l_alt_v_temp_fac
				Cxx_l_alt_v_ref
				Cxx_l_alt_temp_ref
				Cxx_l_alt_temp_mv
				Cxx_l_alt_temp_min_v
				Cxx_l_alt_temp_max_grd
				Cxx_l_alt_temp_fac
				Cxx_l_alt_r_mv
				Cxx_l_alt_ind
				Cxx_l_alt_crt_nok
				Cxx_h_alt_v_ref
				Cxx_h_alt_temp_max_grd
				Cxx_alt_rat_fail_dly
				Cxx_h_alt_temp_min_v
				Cxx_h_alt_crt_nok
				Cxx_h_alt_ind
				Cbx_ptc_max_cut_ena_lim
				Cxx_h_alt_r_mv
				Cxx_h_alt_temp_fac
				Cxx_min_h_alt_pwm_per
				Cxx_min_l_alt_pwm_per
				Cxx_min_alt_pwm
				Cxx_n_l_alt_crt
				Cxx_n_h_alt_crt
				Cxx_tco_cor_vld_alt_typ
				Cxx_ptc_mem_inc
				Cxx_max_l_alt_pwm_per
				Cxx_max_alt_pwm
				Cxx_n_alt_rat
				Cxx_max_h_alt_pwm_per
				Cxx_ptc_mem_dly
				Cbx_df_in_fil_ena
				Cbx_alt_typ_tco_cor
				Cbx_alt_tco_cor_vld
				Cbx_alt_rat_mux_dsb
				Cbx_alt_pwm_per_on_ris_edg
				Cbx_alt_pwm_frst_lvl_act
				Cbx_alt_v_fil_ena
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION Bobines_sys
			""
			/begin DEF_CHARACTERISTIC
				Cbx_igc_2_3_diag_dsb
				Cbx_igc_1_4_diag_dsb
				Icd_adapt_factor_twin_phys_step
				Icd_adapt_factor_twin_phys_min
				Inc_panne_bob_a_c_2cc0
				Cxx_pfinc_igc_2_vb_sc
				Cxx_pfinc_igc_3_oc
				Cxx_pfinc_igc_3_vb_sc
				Inc_panne_bob_a_c_cc1
				Inc_panne_bob_b_d_2cc0
				Inc_panne_bob_b_d_cc1
				Cxx_pfinc_igc_4_oc
				Cxx_pfinc_igc_4_vb_sc
				Icd_adapt_factor_twin_phys_max
				Icd_dwell_limitation_delay_
				Icd_reg_bkpt
				Icd_pos_slope_2
				Icd_pos_slope_1
				Icd_water_temp_thresh
				Icd_max_energy_twin_phys
				Icd_map_bkpt
				Icd_adapt_offset_twin_phys_step
				Icd_energy_ratio_nom_
				Icd_boost_delay
				Icd_boost_transient_thresh
				Icd_boost_offset_map
				Icd_boost_manu_inh
				Icd_boost_load_thresh_low
				Icd_boost_load_thresh_high
				Icd_ratio_energy_map
				Icd_limit_adapt_tdwell
				Seuil_tension_inf_diag_bobine_
				Cxx_mfnrsta_igc_1_oc
				Cxx_mfnrsta_igc_3_oc
				Cxx_mfnrsta_igc_3_vb_sc
				Cxx_mfnrsta_igc_4_oc
				Cxx_mfnrsta_igc_4_vb_sc
				Regime_dwell_demarrage_hyst_bas_
				Regime_dwell_demarrage_hyst_haut
				Seuil_2_bobines_circ_ouvert_jumo
				Seuil_bobine_cc_bat
				Cxx_mfnrsta_igc_2_vb_sc
				Seuil_regime_diag_bobine_
				Cxx_mfnrsta_igc_2_oc
				Cxx_pfdec_igc_4_vb_sc
				Cxx_pfdec_igc_4_oc
				Cxx_pfdec_igc_3_vb_sc
				Cxx_pfdec_igc_3_oc
				Cxx_pfdec_igc_2_vb_sc
				Cxx_pfdec_igc_2_oc
				Cxx_pfdec_igc_1_vb_sc
				Cxx_pfdec_igc_1_oc
				Cxx_pfdec_igc
				Seuil_detection_bob_oc
				Dec_panne_bob_b_d_2cc0
				Cxx_mfnrsta_igc_1_vb_sc
				Cxx_pfinc_igc_2_oc
				Dec_panne_bob_b_d_cc1
				Dec_panne_bob_a_c_cc1
				Dec_panne_bob_a_c_2cc0
				Cxx_pfinc_igc_1_vb_sc
				Cxx_pfinc_igc_1_oc
				Cxx_pfinc_igc
				Table_dwell_dem_
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION Pression_sys
			""
			/begin DEF_CHARACTERISTIC
				Cxx_alti_map_fil_fac
				Cxx_alti_prs_dft_val
				Pres_admission_ad_conv_gain
				Pres_admission_ad_conv_offset
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION Purge_Canister_sys
			""
			/begin DEF_CHARACTERISTIC
				Cxx_cp_frq_1
				Cxx_cp_frq_2
				Cxx_cp_pwm_cor_max
				Cxx_cp_pwm_min_1
				Cxx_cp_flr_min_2
				Cxx_cp_pwm_min_2
				Cxx_cp_flr_min_1
				Cbx_lbup_conf
				Rco_max_purge_
				Cxx_pfinc_cp_scg
				Cxx_mfnrsta_cp_vb_sc
				Cxx_pfinc_cp_vb_sc
				Rco_min_purge_
				Cxx_pfdec_cp_scg
				Cxx_pfdec_cp_vb_sc
				Cxx_mfnrsta_cp_oc
				Cxx_mfnrsta_cp_scg
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION CAN_sys
			""
			/begin DEF_CHARACTERISTIC
				Can_rx_stmin
				Can_rx_block_size
				Cbx_ip_can_oil_cge_intv
				Cbx_fuel_conf
				Cxx_ip_abst_nr_fail
				Decm
				Decabs_acc
				Decabs_gpl
				Tmnp3
				Decabtdb
				Decabuch
				Decabs_clm
				Incabs_gpl
				Decabbva
				Decababs
				Decbof
				Decmute
				Tmcnx
				Cxx_pfinc_ip_inj_cnt
				Ucemux21
				Ucemux14
				Ucemux7
				Ucemux6
				Ucemux5
				Ucemux4
				Ucemux3
				Ucemux24
				Ucemux9
				Ucemux22
				Cxx_mfnrsta_cru_whl_cmd
				Ucemux20
				Ucemux2
				Ucemux19
				Incabbva
				Ucemux17
				Tmonitat
				Ucemux15
				Ucemux23
				Valeur_tempo_srv_reception_bva
				Cxx_mux_min_n
				Cxx_mux_ip_eng_c
				Decthres
				Batcdmux
				Valmax
				Valeur_tempo_srv_liaison_tdb
				Valeur_tempo_srv_reception_abs
				Ucemux8
				Valeur_tempo_srv_reception_acc
				Ucemux16
				Cxx_lpg_abst_nr_fail
				Valeur_tempo_srv_reception_clim
				Valeur_tempo_srv_reception_gpl
				Valeur_tempo_srv_reception_uch
				Refmesag
				Cxx_mfnrsta_ip_inj_cnt
				Nmaxtxko
				Cxx_pfdec_ip_inj_cnt
				Idbvabr
				Incbof
				Ucemux13
				Idtdb
				Ucemux18
				Ictdba2
				Idgplba
				Idabsct
				Incmute
				Idbvabl
				Iduch
				Idrbagcr
				Idaccba
				Idabsbr
				Idinjvl
				Idinjhg
				Idinjpl
				Idinjbr
				Idinjbl
				Idclimb
				Incabuch
				Ucemux12
				Ucemux11
				Ucemux10
				Ucemux1
				Incababs
				Incabacc
				Incabtdb
				Incabclm
				Cbx_can_emt_flow
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION Reco_Cylindre_sys
			""
			/begin DEF_CHARACTERISTIC
				Cxx_cylr_max_n_lpg
				Cxx_crk1_bas_toth_nr
				Cxx_cylr_max_n
				Cxx_cylr_is_neg_clu_stal
				Cxx_cylr_stab_t
				Cxx_cylr_trz_stab_dif
				Cfgphaac
				Cxx_cylr_cold_is_stab_t
				Cxx_off_syn_max_toth_nr
				Cxx_phs_mem_toth_nr
				Cbx_cylr_dyn_iga_off
				Cbx_cylr_bas_conf
				Cbx_cylr_is_run_gex_appl
				Cbx_cylr_run_ol
				Cbx_cylr_ena_re_phs
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION BVA_sys
			""
			/begin DEF_CHARACTERISTIC
				Cxx_agb_conv_trs_dly
				Cxx_mfnrsta_agb_rcpt
				Cxx_mfnrsta_agb_gear
				Cxx_mfnrsta_agb_conv_stt
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION Acquisitions_sys
			""
			/begin DEF_CHARACTERISTIC
				Cxx_el_csm_clc_neut_vb
				Cxx_l_thd_n_vs_test
				Ctp_tco_dif_max
				Cxx_gear_val_mux_fac
				Cxx_fail_ctr_vs_thd
				Cxx_gear_val_fil_fac3
				Cxx_gear_val_fil_fac2
				Cxx_gear_val_fil_fac1
				Cxx_gear_val_fac
				Cxx_h_thd_n_vs_test
				Ctb_tco_dif_max
				Cxx_fil_fac_vb
				Ctp_tco_mdl_tdc_nr
				Ctp_thpl_el_csm_vb
				Ctp_max_dif_clc_vs
				Cbx_vs_mux
				Ctb_tco_mdl
				Cxx_vs_fail_dsb
				Cxx_tco_mdl_max
				Cxx_thpl_pos_el_csm_thd
				Cxx_thpl_pos_el_csm_fac
				Cxx_thpl_neg_el_csm_thd
				Cxx_thpl_neg_el_csm_fac
				Pres_mastervac_min
				Cxx_thpl_vb_aftr_sta_dly
				Pres_mastervac_ad_conv_offset
				Cxx_vs_sum_cor_fac
				Pres_mastervac_ad_conv_gain
				Cxx_pfdec_tco_acq
				Cxx_pfdec_tco_chr
				Periode_signal_vitesse_3kmh
				Periode_mini_signal_vitesse_
				Cxx_tco_mon_dly
				Pres_mastervac_max
				Table_bkpt_temperature_eau
				Tension_batterie_lis_thresh_mini
				Tension_batterie_lis_thresh_maxi
				Tension_batterie_lis_thresh_hyst
				Temperature_eau_acqui_min_
				Temperature_eau_acqui_max_
				Cxx_pfdec_el_wind_rcpt
				Cxx_map_thd_vs_test
				Table_temperature_air
				Cxx_thpl_fil_vb_fac
				Table_bkpt_temperature_air
				Seuil_vit_min_diag_periode_
				Seuil_min_top_roulant_
				Cxx_vs_thd_vs_sens_vld
				Cxx_vs_thd_sens_fail_det
				Cxx_vs_t_sens_fail_det
				Table_temperature_eau
				Cxx_pfinc_wat_temp_low
				Cxx_pfinc_vs_mux
				Cxx_pfinc_vs_eal
				Cxx_pfinc_tia_low
				Cxx_pfinc_tia_high
				Cxx_pfinc_vs_parasite
				Cxx_mfnrsta_tco_acq
				Cxx_stop_eng_dly
				Cxx_max_dif_mfld_mv_prs
				Cxx_mfnrsta_el_wind_rcpt
				Cxx_vb_dft_val
				Cxx_pfdec_wat_temp_high
				Cxx_pfdec_wat_temp_low
				Cxx_mfnrsta_wat_temp_low
				Cxx_mfnrsta_wat_temp_high
				Cxx_mfnrsta_tco_chr
				Cxx_pfinc_el_wind_rcpt
				Cxx_pfinc_wat_temp_high
				Cxx_tco_chr_fil_dly
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin COMPU_METHOD Vxx_mis_stt_conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Vxx_mis_stt_table
		/end COMPU_METHOD
		/begin COMPU_VTAB Vxx_mis_stt_table
			""
			TAB_VERB
			3
			1 "OBD_DIAG_MSF_HORS_DIAGNOSTIC"
			2 "OBD_DIAG_MSF_STABILISATION"
			4 "OBD_DIAG_MSF_DIAGNOSTIC"
		/end COMPU_VTAB
		/begin COMPU_METHOD Vxx_cata_stt_conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Vxx_cata_stt_table
		/end COMPU_METHOD
		/begin COMPU_VTAB Vxx_cata_stt_table
			""
			TAB_VERB
			6
			1 "OBD_DIAG_CATA_HORS_DIAGNOSTIC"
			2 "OBD_DIAG_CATA_STAB_BCLE_FERMEE"
			4 "OBD_DIAG_CATA_STAB_BCLE_OUV_F"
			8 "OBD_DIAG_CATA_MESURE"
			16 "OBD_DIAG_CATA_DIAGNOSTIC"
			32 "OBD_DIAG_CATA_FIN"
		/end COMPU_VTAB
		/begin COMPU_METHOD Etat_sequence_obd__conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Etat_sequence_obd__table
		/end COMPU_METHOD
		/begin COMPU_VTAB Etat_sequence_obd__table
			""
			TAB_VERB
			4
			1 "DIAG_SEQ_ETAT_CATA"
			2 "DIAG_SEQ_ETAT_SONDES"
			4 "DIAG_SEQ_ETAT_SAI"
			8 "DIAG_SEQ_ETAT_SANS_REQUETE"
		/end COMPU_VTAB
		/begin COMPU_METHOD Ssm_throttle_pos_sensing_status__conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Ssm_throttle_pos_sensing_status__table
		/end COMPU_METHOD
		/begin COMPU_VTAB Ssm_throttle_pos_sensing_status__table
			""
			TAB_VERB
			4
			1 "SSM_THROTTLE_POS_NORMAL"
			2 "SSM_THROTTLE_POS_SINGLE_1"
			4 "SSM_THROTTLE_POS_SINGLE_2"
			8 "SSM_THROTTLE_POS_FAILURE"
		/end COMPU_VTAB
		/begin COMPU_METHOD Phase_redepart__conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Phase_redepart__table
		/end COMPU_METHOD
		/begin COMPU_VTAB Phase_redepart__table
			""
			TAB_VERB
			4
			1 "ETAT_CONTACT_ARRETE_REDEP"
			2 "ETAT_DEMARRAGE_INJECTION_REDEP"
			4 "ETAT_HORS_PHASE_DEMARRAGE_REDEP"
			8 "ETAT_POWER_LATCH_REDEP"
		/end COMPU_VTAB
		/begin COMPU_METHOD Etat_av_dyn__conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Etat_av_dyn__table
		/end COMPU_METHOD
		/begin COMPU_VTAB Etat_av_dyn__table
			""
			TAB_VERB
			4
			1 "VBX_STAB_DYN_IGA"
			2 "VBX_CART_DYN_IGA"
			4 "VBX_IS_DYN_IGA"
			8 "AV_DYN_HORS"
		/end COMPU_VTAB
		/begin COMPU_METHOD Vsx_iga_conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Vsx_iga_table
		/end COMPU_METHOD
		/begin COMPU_VTAB Vsx_iga_table
			""
			TAB_VERB
			3
			1 "VBX_STA_IGA_STT"
			2 "VBX_IS_IGA_STT"
			4 "VBX_CART_IGA_STT"
		/end COMPU_VTAB
		/begin COMPU_METHOD Etat_cond_rr__conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Etat_cond_rr__table
		/end COMPU_METHOD
		/begin COMPU_VTAB Etat_cond_rr__table
			""
			TAB_VERB
			3
			1 "RR_AVANT"
			2 "RR_ARRETE"
			4 "RR_ROULANT"
		/end COMPU_VTAB
		/begin COMPU_METHOD Vxx_knk_rel_tq_cor_stt_conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Vxx_knk_rel_tq_cor_stt_table
		/end COMPU_METHOD
		/begin COMPU_VTAB Vxx_knk_rel_tq_cor_stt_table
			""
			TAB_VERB
			5
			1 "ATTENTE_CORR_CLIQ"
			2 "DECREMENTATION_PRESSION"
			4 "DECREMENTATION_TEMPO_RETRAIT"
			8 "DECREMENTATION_TEMPO_REMISE"
			16 "INCREMENTATION_PRESSION"
		/end COMPU_VTAB
		/begin COMPU_METHOD Vsx_acc_conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Vsx_acc_table
		/end COMPU_METHOD
		/begin COMPU_VTAB Vsx_acc_table
			""
			TAB_VERB
			4
			0 "NSX_ACR_DCLU"
			1 "NSX_ACR_BFR_CLU"
			2 "NSX_ACR_CLU"
			3 "NSX_ACR_BFR_DCLU"
		/end COMPU_VTAB
		/begin COMPU_METHOD Vsx_eng_conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Vsx_eng_table
		/end COMPU_METHOD
		/begin COMPU_VTAB Vsx_eng_table
			""
			TAB_VERB
			4
			1 "NXX_STOP1_ENG"
			2 "NXX_STA_RUN_ENG"
			4 "NXX_AUT_RUN_ENG"
			8 "NXX_STAL_ENG"
		/end COMPU_VTAB
		/begin COMPU_METHOD Vsx_is_conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Vsx_is_table
		/end COMPU_METHOD
		/begin COMPU_VTAB Vsx_is_table
			""
			TAB_VERB
			3
			1 "RR_DEMARRAGE"
			2 "RR_CONDITIONS_DE_RR"
			4 "RR_HORS_RR"
		/end COMPU_VTAB
		/begin COMPU_METHOD Phase_moteur__conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Phase_moteur__table
		/end COMPU_METHOD
		/begin COMPU_VTAB Phase_moteur__table
			""
			TAB_VERB
			4
			1 "CONTACT_AVEC_POMPE_EE"
			2 "CONTACT_SANS_POMPE_EE"
			4 "CONTACT_MOTEUR_TOURNANT_EE"
			8 "POWER_LATCH_EE"
		/end COMPU_VTAB
		/begin COMPU_METHOD Vsx_mdf_cmd_conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Vsx_mdf_cmd_table
		/end COMPU_METHOD
		/begin COMPU_VTAB Vsx_mdf_cmd_table
			""
			TAB_VERB
			7
			1 "SURVEILLANCE_GMV1"
			2 "GMV1_MOT_ARRETE"
			4 "ARRET_GMV1"
			8 "GMV_MOT_TOURNANT"
			16 "COND_GMV_MOT_TOURNANT"
			32 "ANT_EMB_GMV1"
			64 "ANT_DEB_GMV1"
		/end COMPU_VTAB
		/begin COMPU_METHOD Phase_application_correction__conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Phase_application_correction__table
		/end COMPU_METHOD
		/begin COMPU_VTAB Phase_application_correction__table
			""
			TAB_VERB
			2
			1 "INHIBITION_CORRECTION"
			2 "ACTIVATION_CORRECTION"
		/end COMPU_VTAB
		/begin COMPU_METHOD Icd_state_conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Icd_state_table
		/end COMPU_METHOD
		/begin COMPU_VTAB Icd_state_table
			""
			TAB_VERB
			2
			1 "ICD_TWIN_FIXED"
			2 "ICD_TWIN_ADAPT"
		/end COMPU_VTAB
		/begin COMPU_METHOD Ssm_pedal_pos_sensing_status__conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Ssm_pedal_pos_sensing_status__table
		/end COMPU_METHOD
		/begin COMPU_VTAB Ssm_pedal_pos_sensing_status__table
			""
			TAB_VERB
			4
			1 "SSM_PEDAL_POS_NORMAL"
			2 "SSM_PEDAL_POS_SINGLE_1"
			4 "SSM_PEDAL_POS_SINGLE_2"
			8 "SSM_PEDAL_POS_FAILURE"
		/end COMPU_VTAB
		/begin COMPU_METHOD Etamotmx_conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Etamotmx_table
		/end COMPU_METHOD
		/begin COMPU_VTAB Etamotmx_table
			""
			TAB_VERB
			4
			0 "MOT_ARRET_INIT_MUX"
			1 "MOT_ARRET_CALE_MUX"
			2 "MOT_TOURN_AUTO_MUX"
			3 "MOT_TOURN_ENTR_MUX"
		/end COMPU_VTAB
		/begin COMPU_METHOD Vxx_cylr_ctl_phs_conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Vxx_cylr_ctl_phs_table
		/end COMPU_METHOD
		/begin COMPU_VTAB Vxx_cylr_ctl_phs_table
			""
			TAB_VERB
			9
			1 "ATTENTE_DETROMPAGE"
			2 "PREMIERE_ATTENTE"
			3 "PREMIERE_CALCULS"
			4 "DEUXIEME_ATTENTE"
			5 "DEUXIEME_CALCULS"
			6 "DETROMPAGE"
			7 "REPHASAGE_AAC"
			8 "APRES_STRATEGIE"
			9 "NON_DECISION"
		/end COMPU_VTAB
		/begin COMPU_METHOD Automate_transfert_micros_conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Automate_transfert_micros_table
		/end COMPU_METHOD
		/begin COMPU_VTAB Automate_transfert_micros_table
			""
			TAB_VERB
			5
			0 "ETAT_MICRO_WTDG_SYNCHRONE"
			2 "ETAT_MICRO_WTDG_IDENTIFIANT"
			4 "ETAT_MICRO_WTDG_DATA"
			6 "ETAT_MICRO_WTDG_CHECKSUM"
			8 "ETAT_MICRO_WTDG_BIDON"
		/end COMPU_VTAB
		/begin COMPU_METHOD Test_stat_etat__conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Test_stat_etat__table
		/end COMPU_METHOD
		/begin COMPU_VTAB Test_stat_etat__table
			""
			TAB_VERB
			12
			0 "TEST_STAT_INIT"
			1 "TEST_STAT_ACTIONNEURS"
			2 "TEST_STAT_DIVERS_1"
			3 "TEST_STAT_DIVERS_2"
			4 "TEST_STAT_HO2"
			5 "TEST_STAT_BOB_A_C"
			6 "TEST_STAT_BOB_B_D"
			7 "TEST_STAT_INJ_A"
			8 "TEST_STAT_INJ_B"
			9 "TEST_STAT_INJ_C"
			10 "TEST_STAT_INJ_D"
			11 "TEST_STAT_FIN"
		/end COMPU_VTAB
		/begin COMPU_METHOD Etat_requete_obd_conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Etat_requete_obd_table
		/end COMPU_METHOD
		/begin COMPU_VTAB Etat_requete_obd_table
			""
			TAB_VERB
			7
			1 "HORS_REQUETE"
			2 "REQUETE_RECUE"
			4 "REPONSE_OBD_INJECTION"
			8 "REPONSE_OBD_PASSERELLE"
			16 "ATTENTE_REPONSE_PASSERELLE"
			32 "REPONSE_OBD_MODE_9"
			64 "REPONSE_OBD_SRV_7"
		/end COMPU_VTAB
		/begin COMPU_METHOD Tpc_throttle_status__conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Tpc_throttle_status__table
		/end COMPU_METHOD
		/begin COMPU_VTAB Tpc_throttle_status__table
			""
			TAB_VERB
			3
			1 "TPC_NORMAL_THROT"
			2 "TPC_NO_THROT"
			4 "TPC_FREE_WHEELING"
		/end COMPU_VTAB
		/begin COMPU_METHOD Tpac_throttle_control_state_conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Tpac_throttle_control_state_table
		/end COMPU_METHOD
		/begin COMPU_VTAB Tpac_throttle_control_state_table
			""
			TAB_VERB
			9
			1 "TPAC_CONTROL"
			2 "TPAC_LEARN_LIMP_HOME"
			3 "TPAC_LOW_THRUST_SEARCH"
			4 "TPAC_HIGH_THRUST_SEARCH"
			5 "TPAC_EXIT_THRUSTS"
			6 "TPAC_CHECK_LIMP_HOME"
			7 "TPAC_MCW_INHIBIT_TEST"
			8 "TPAC_CHECK_SPRINGS"
			9 "TPAC_LIMP_HOME"
		/end COMPU_VTAB
		/begin COMPU_METHOD Avance_mini_conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Avance_mini_table
		/end COMPU_METHOD
		/begin COMPU_VTAB Avance_mini_table
			""
			TAB_VERB
			2
			1 "AVANCE_MINI_CORRECTION"
			2 "AVANCE_MINI_LISSAGE"
		/end COMPU_VTAB
		/begin COMPU_METHOD Vsx_cl_ti_conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Vsx_cl_ti_table
		/end COMPU_METHOD
		/begin COMPU_VTAB Vsx_cl_ti_table
			""
			TAB_VERB
			6
			1 "PHASE_INITIALISATION"
			2 "PHASE_PENTE_DOUCE_R"
			4 "PHASE_PENTE_DOUCE_P"
			8 "PHASE_PENTE_FORTE_R"
			16 "PHASE_PENTE_FORTE_P"
			32 "PHASE_BOUCLE_PAUVRE"
		/end COMPU_VTAB
		/begin COMPU_METHOD Etat_sous_automate_injection__conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Etat_sous_automate_injection__table
		/end COMPU_METHOD
		/begin COMPU_VTAB Etat_sous_automate_injection__table
			""
			TAB_VERB
			8
			1 "TRANSITION_INJ_A"
			2 "TEMPO_TRANSITION_INJ_A"
			4 "TRANSITION_INJ_B"
			8 "TEMPO_TRANSITION_INJ_B"
			16 "TRANSITION_INJ_C"
			32 "TEMPO_TRANSITION_INJ_C"
			64 "TRANSITION_INJ_D"
			128 "TEMPO_TRANSITION_INJ_D"
		/end COMPU_VTAB
		/begin COMPU_METHOD Etat_sous_automate_br__conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Etat_sous_automate_br__table
		/end COMPU_METHOD
		/begin COMPU_VTAB Etat_sous_automate_br__table
			""
			TAB_VERB
			3
			1 "PHASE_BOUCLE_FERME"
			2 "PHASE_BOUCLE_OUVERTE_RR"
			4 "PHASE_AV_BOUCLE_OUVERTE_RR"
		/end COMPU_VTAB
		/begin COMPU_METHOD Vsx_rich_cl_conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Vsx_rich_cl_table
		/end COMPU_METHOD
		/begin COMPU_VTAB Vsx_rich_cl_table
			""
			TAB_VERB
			5
			1 "PHASE_BOUCLE_OUVERTE"
			2 "PHASE_AVANT_BOUCLAGE"
			4 "PHASE_SOUS_AUTOMATE_BR"
			8 "PHASE_PLEINE_CHARGE"
			16 "PHASE_DEMARRAGE_BR"
		/end COMPU_VTAB
		/begin COMPU_METHOD Phase_coupure_surpression_conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Phase_coupure_surpression_table
		/end COMPU_METHOD
		/begin COMPU_VTAB Phase_coupure_surpression_table
			""
			TAB_VERB
			3
			1 "ATTENTE_SURPRESSION"
			2 "NON_COUPURE_SURPRESSION"
			4 "COUPURE_SURPRESSION"
		/end COMPU_VTAB
		/begin COMPU_METHOD Vsx_inj_conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Vsx_inj_table
		/end COMPU_METHOD
		/begin COMPU_VTAB Vsx_inj_table
			""
			TAB_VERB
			5
			1 "PRE_INJECTION"
			2 "PHASE_DEM_SFG"
			4 "HORS_PHASE_DEM_SFG"
			8 "PHASE_TRANS_SFG_SEQ"
			16 "HORS_PHASE_DEM_SEQ"
		/end COMPU_VTAB
		/begin COMPU_METHOD Etat_adaptation__conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Etat_adaptation__table
		/end COMPU_METHOD
		/begin COMPU_VTAB Etat_adaptation__table
			""
			TAB_VERB
			4
			1 "ETAT_HORS_ADAPTATION"
			2 "ETAT_CONDITION_ADAPTATION"
			4 "ETAT_APPRENTISSAGE"
			8 "ETAT_CALCUL_ADAPTATION"
		/end COMPU_VTAB
		/begin COMPU_METHOD Vsx_lpg_mod_conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Vsx_lpg_mod_table
		/end COMPU_METHOD
		/begin COMPU_VTAB Vsx_lpg_mod_table
			""
			TAB_VERB
			5
			1 "NSX_LPG_ENG_STOP_GAS"
			2 "NSX_LPG_ENG_STOP_GAS_LPG"
			4 "NSX_LPG_ENG_STOP_LPG_MOD"
			8 "GPL_FCT_ESS"
			16 "GPL_FCT_GPL"
		/end COMPU_VTAB
		/begin COMPU_METHOD Gpl_mode_injection_gpl_conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Gpl_mode_injection_gpl_table
		/end COMPU_METHOD
		/begin COMPU_VTAB Gpl_mode_injection_gpl_table
			""
			TAB_VERB
			5
			1 "NSX_LPG_LPG"
			2 "NSX_LPG_LPG_LIH"
			4 "NSX_LPG_BFR_LPG_GAS"
			8 "NSX_LPG_LPG_GAS_TRS"
			32 "MODE_A_DETERMINER_GPL"
		/end COMPU_VTAB
		/begin COMPU_METHOD Gpl_mode_injection_ess_conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Gpl_mode_injection_ess_table
		/end COMPU_METHOD
		/begin COMPU_VTAB Gpl_mode_injection_ess_table
			""
			TAB_VERB
			5
			1 "NSX_LPG_GAS"
			2 "NSX_LPG_GAS_LIH_LPG_CDN_ESS"
			4 "NSX_LPG_BFR_GAS_LPG"
			8 "NSX_LPG_GAS_LPG_TRS"
			16 "NSX_LPG_GAS_LIH"
		/end COMPU_VTAB
		/begin COMPU_METHOD Vsx_gest_coup_pomp_conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Vsx_gest_coup_pomp_table
		/end COMPU_METHOD
		/begin COMPU_VTAB Vsx_gest_coup_pomp_table
			""
			TAB_VERB
			5
			1 "NSX_ATT_COUP"
			2 "NSX_ATT_COUP_1024"
			4 "NSX_PRES_RAMP"
			8 "NSX_POMP_COUP"
			16 "NSX_ATT_COND_POMP"
		/end COMPU_VTAB
		/begin COMPU_METHOD Vsx_lpg_coup_aut_conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Vsx_lpg_coup_aut_table
		/end COMPU_METHOD
		/begin COMPU_VTAB Vsx_lpg_coup_aut_table
			""
			TAB_VERB
			6
			1 "NSX_LPG_DEC_HC"
			2 "NSX_LPG_DEC_COUP_A"
			4 "NSX_LPG_DEC_COUP_B"
			8 "NSX_LPG_DEC_COUP_C"
			16 "NSX_LPG_DEC_COUP_D"
			32 "NSX_LPG_FIN"
		/end COMPU_VTAB
		/begin COMPU_METHOD Etat_amorcage_rampe_gaz_conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Etat_amorcage_rampe_gaz_table
		/end COMPU_METHOD
		/begin COMPU_VTAB Etat_amorcage_rampe_gaz_table
			""
			TAB_VERB
			5
			0 "ATTENTE_AMORCAGE_RAMPE_GAZ"
			1 "INIT_AMORCAGE_RAMPE_GAZ"
			2 "AMORCAGE_RAMPE_GAZ"
			4 "AMORCAGE_RAMPE_GAZ_TERMINE"
			8 "FIN_AMORCAGE_RAMPE_GAZ"
		/end COMPU_VTAB
		/begin COMPU_METHOD Vsx_wpmp_conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Vsx_wpmp_table
		/end COMPU_METHOD
		/begin COMPU_VTAB Vsx_wpmp_table
			""
			TAB_VERB
			3
			1 "NXX_WPMP_STOP"
			2 "NXX_WPMP_SPY"
			4 "NXX_WPMP_STOP_ENG"
		/end COMPU_VTAB
		/begin COMPU_METHOD Vsx_lpg_eng_run_mod_conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Vsx_lpg_eng_run_mod_table
		/end COMPU_METHOD
		/begin COMPU_VTAB Vsx_lpg_eng_run_mod_table
			""
			TAB_VERB
			8
			0 "NSX_LPG_LPG_MOD"
			1 "NSX_LPG_GAS_LIH_LPG_DFT"
			2 "NSX_LPG_LPG_GAS_TRS_MOD"
			3 "NSX_LPG_GAS_LIH_LPG_CDN"
			4 "NSX_LPG_LPG_LIH_MOD"
			5 "NSX_LPG_GAS_LPG_TRS_MOD"
			6 "NSX_LPG_GAS_LIH_LPG_LVL"
			7 "NSX_LPG_GAS_MOD"
		/end COMPU_VTAB
		/begin COMPU_METHOD Vsx_lpg_mod_req_conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Vsx_lpg_mod_req_table
		/end COMPU_METHOD
		/begin COMPU_VTAB Vsx_lpg_mod_req_table
			""
			TAB_VERB
			3
			0 "NSX_LPG_GAS_MOD_REQ"
			1 "NSX_LPG_ACT_MOD_REQ"
			3 "NSX_LPG_LPG_MOD_REQ"
		/end COMPU_VTAB
		/begin COMPU_METHOD Vxx_air_pump_phs_conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Vxx_air_pump_phs_table
		/end COMPU_METHOD
		/begin COMPU_VTAB Vxx_air_pump_phs_table
			""
			TAB_VERB
			6
			1 "COND_POMPE_AIR"
			2 "AVANT_POMPE_AIR"
			4 "ACTIV_POMPE_AIR"
			8 "MAINT_POMPE_AIR"
			16 "DESACT_POMPE_AIR"
			32 "TRAIT_POMPE_AIR_FIN"
		/end COMPU_VTAB
		/begin COMPU_METHOD Tpac_check_springs_state_conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Tpac_check_springs_state_table
		/end COMPU_METHOD
		/begin COMPU_VTAB Tpac_check_springs_state_table
			""
			TAB_VERB
			5
			1 "COUPURE_DRV"
			2 "ATTENTE_CHECK_SPRINGS"
			4 "CHECK_LH_HAUT"
			8 "CHECK_LH_BAS"
			16 "FIN_STRATEGIE_CHECK_SPRINGS"
		/end COMPU_VTAB
		/begin COMPU_METHOD Etat_papmot_mode_banc_conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Etat_papmot_mode_banc_table
		/end COMPU_METHOD
		/begin COMPU_VTAB Etat_papmot_mode_banc_table
			""
			TAB_VERB
			2
			1 "PAPMOT_IDLE"
			2 "PAPMOT_INCR_IDX"
		/end COMPU_VTAB
		/begin COMPU_METHOD Vsx_slow_tq_lh_sp_conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Vsx_slow_tq_lh_sp_table
		/end COMPU_METHOD
		/begin COMPU_VTAB Vsx_slow_tq_lh_sp_table
			""
			TAB_VERB
			4
			1 "INIT_CYL_ACTIFS"
			2 "DEUX_CYL_ACTIFS"
			4 "TROIS_CYL_ACTIFS"
			8 "QUATRE_CYL_ACTIFS"
		/end COMPU_VTAB
		/begin COMPU_METHOD Vxx_cata_wup_phs_conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Vxx_cata_wup_phs_table
		/end COMPU_METHOD
		/begin COMPU_VTAB Vxx_cata_wup_phs_table
			""
			TAB_VERB
			8
			1 "PMEA_RELEVE_TEMPERATURE_EAU"
			2 "PMEA_RECHAUFFAGE_CATALYSEUR"
			4 "PMEA_AMORCAGE_CATALYSEUR_IAE"
			8 "PMEA_AMORCAGE_PAUVRE_CATALYSEUR"
			16 "PMEA_AMORCAGE_CATALYSEUR_REPART"
			32 "PMEA_RECHAUFFAGE_HABITACLE"
			64 "PMEA_MISE_EN_ACTION_TERMINE"
			128 "PMEA_DEPOLLUTION"
		/end COMPU_VTAB
		/begin COMPU_METHOD Vsx_mis_lih_cyl_chk_conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Vsx_mis_lih_cyl_chk_table
		/end COMPU_METHOD
		/begin COMPU_VTAB Vsx_mis_lih_cyl_chk_table
			""
			TAB_VERB
			6
			1 "NSX_SF1_ATT"
			2 "NSX_SF1_DETROMP"
			3 "NSX_SF1_CUT"
			4 "NSX_SF1_PAIRE"
			5 "NSX_SF1_BIEN_PHS"
			6 "NSX_SF1_MAL_PHS"
		/end COMPU_VTAB
		/begin COMPU_METHOD Vsx_mis_lih_stt_conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Vsx_mis_lih_stt_table
		/end COMPU_METHOD
		/begin COMPU_VTAB Vsx_mis_lih_stt_table
			""
			TAB_VERB
			6
			0 "NSX_OB_MDMSF_INACTIF"
			1 "NSX_OB_MDMSF_INIT"
			2 "NSX_OB_MDMSF_ATT1"
			3 "NSX_OB_MDMSF_ATT2"
			4 "NSX_OB_MDMSF_CYL_OK"
			5 "NSX_OB_MDMSF_CYL_CUT"
		/end COMPU_VTAB
		/begin COMPU_METHOD Etat_diag_bobine_a_c_conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Etat_diag_bobine_a_c_table
		/end COMPU_METHOD
		/begin COMPU_VTAB Etat_diag_bobine_a_c_table
			""
			TAB_VERB
			5
			1 "BOB_A_C_DEBUT_DIAG"
			2 "BOB_A_C_PROG_1ER_POINT"
			4 "BOB_A_C_PROG_2ND_POINT"
			8 "BOB_A_C_DIAG_2ND_POINT"
			16 "BOB_A_C_DIAG_FINI"
		/end COMPU_VTAB
		/begin COMPU_METHOD Etat_diag_bobine_b_d_conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Etat_diag_bobine_b_d_table
		/end COMPU_METHOD
		/begin COMPU_VTAB Etat_diag_bobine_b_d_table
			""
			TAB_VERB
			5
			1 "BOB_B_D_DEBUT_DIAG"
			2 "BOB_B_D_PROG_1ER_POINT"
			4 "BOB_B_D_PROG_2ND_POINT"
			8 "BOB_B_D_DIAG_2ND_POINT"
			16 "BOB_B_D_DIAG_FINI"
		/end COMPU_VTAB
		/begin COMPU_METHOD Vsx_cp_conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Vsx_cp_table
		/end COMPU_METHOD
		/begin COMPU_VTAB Vsx_cp_table
			""
			TAB_VERB
			4
			1 "HORS_PURGE"
			2 "PURGE_ADAPTATIVE"
			4 "PURGE_NOMINALE"
			8 "PURGE_NON_BOUCLE"
		/end COMPU_VTAB
		/begin COMPU_METHOD Vsx_fsys_stt_conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Vsx_fsys_stt_table
		/end COMPU_METHOD
		/begin COMPU_VTAB Vsx_fsys_stt_table
			""
			TAB_VERB
			2
			1 "OBD_DIAG_FSM_HORS_DIAGNOSTIC"
			4 "OBD_DIAG_FSM_DIAGNOSTIC"
		/end COMPU_VTAB
		/begin COMPU_METHOD Vxx_lbup_stt_conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Vxx_lbup_stt_table
		/end COMPU_METHOD
		/begin COMPU_VTAB Vxx_lbup_stt_table
			""
			TAB_VERB
			5
			1 "ETAT_OBD_SONDES_HORS_DIAGNOSTIC"
			2 "ETAT_OBD_SONDES_STABILISATION"
			4 "ETAT_OBD_SONDES_MESURES"
			8 "ETAT_OBD_SONDES_DIAGNOSTIC"
			16 "ETAT_OBD_SONDES_FIN_DE_DIAG"
		/end COMPU_VTAB
		/begin COMPU_METHOD Vsx_aj_fil_conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Vsx_aj_fil_table
		/end COMPU_METHOD
		/begin COMPU_VTAB Vsx_aj_fil_table
			""
			TAB_VERB
			6
			1 "NXX_AJ_FIL1"
			2 "NXX_AJ_FIL2"
			4 "NXX_AJ_FIL3"
			8 "NXX_AJ_FIL4"
			16 "NXX_AJ_FIL5"
			32 "NXX_AJ_FIL6"
		/end COMPU_VTAB
		/begin COMPU_METHOD Vsx_cyl_cut_conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Vsx_cyl_cut_table
		/end COMPU_METHOD
		/begin COMPU_VTAB Vsx_cyl_cut_table
			""
			TAB_VERB
			5
			0 "NSX_CYL_CUT_INACTIF"
			1 "NSX_CYL_CUT_ATT"
			2 "NSX_CYL_CUT_DMD_VERIF"
			3 "NSX_CYL_CUT_VERIF_NOK"
			4 "NSX_CYL_CUT_VERIF_OK"
		/end COMPU_VTAB
		/begin COMPU_METHOD Vxx_sa_stt_conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Vxx_sa_stt_table
		/end COMPU_METHOD
		/begin COMPU_VTAB Vxx_sa_stt_table
			""
			TAB_VERB
			5
			1 "OBD_DIAG_SA_HORS_DIAGNOSTIC"
			2 "OBD_DIAG_SA_STABILISATION"
			4 "OBD_DIAG_SA_MESURES"
			8 "OBD_DIAG_SA_DIAGNOSTIC"
			16 "OBD_DIAG_SA_FIN_DIAGNOSTIC"
		/end COMPU_VTAB
		/begin COMPU_METHOD Vsx_cru_sl_whl_cmd_stt_conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Vsx_cru_sl_whl_cmd_stt_table
		/end COMPU_METHOD
		/begin COMPU_VTAB Vsx_cru_sl_whl_cmd_stt_table
			""
			TAB_VERB
			7
			1 "NSX_CRU_SL_OPEN"
			2 "NSX_CRU_SL_RLS"
			4 "NSX_CRU_SL_RESU"
			8 "NSX_CRU_SL_SUSP"
			16 "NSX_CRU_SL_DECL"
			32 "NSX_CRU_SL_ACEL"
			128 "NSX_CRU_SL_WHL_NOK"
		/end COMPU_VTAB
		/begin COMPU_METHOD Vsx_cru_stt_conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Vsx_cru_stt_table
		/end COMPU_METHOD
		/begin COMPU_VTAB Vsx_cru_stt_table
			""
			TAB_VERB
			4
			1 "NSX_DSB_CRU"
			2 "NSX_WAIT_CRU"
			4 "NSX_ACT_CRU"
			8 "NSX_SUSP_CRU"
		/end COMPU_VTAB
		/begin COMPU_METHOD Vsx_sl_stt_conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Vsx_sl_stt_table
		/end COMPU_METHOD
		/begin COMPU_VTAB Vsx_sl_stt_table
			""
			TAB_VERB
			5
			1 "NSX_DSB_SL"
			2 "NSX_WAIT_SL"
			4 "NSX_ACT_SL"
			8 "NSX_SUSP_SL"
			16 "NSX_OVS_SL"
		/end COMPU_VTAB
		/begin COMPU_METHOD Vsx_warn_stt_conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Vsx_warn_stt_table
		/end COMPU_METHOD
		/begin COMPU_VTAB Vsx_warn_stt_table
			""
			TAB_VERB
			7
			1 "WARN_CRU_SL_INACTIVE"
			2 "WARN_CRU_EFFECTIVE"
			4 "WARN_CRU_INEFFECTIVE"
			8 "WARN_DRIVE_MASTER"
			16 "WARN_SL_OVERSPEED"
			32 "WARN_SL_EFFECTIVE"
			64 "WARN_SL_INEFFECTIVE"
		/end COMPU_VTAB
		/begin COMPU_METHOD Vsx_cl_ti_lean_conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Vsx_cl_ti_lean_table
		/end COMPU_METHOD
		/begin COMPU_VTAB Vsx_cl_ti_lean_table
			""
			TAB_VERB
			5
			1 "PHASE_INITIALISATION_BP"
			2 "PHASE_BP_PENTE_DOUCE_R"
			4 "PHASE_BP_PENTE_DOUCE_P"
			8 "PHASE_BP_PENTE_FORTE_R"
			16 "PHASE_BP_PENTE_FORTE_P"
		/end COMPU_VTAB
		/begin COMPU_METHOD Phase_diag_pmvac_conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Phase_diag_pmvac_table
		/end COMPU_METHOD
		/begin COMPU_VTAB Phase_diag_pmvac_table
			""
			TAB_VERB
			5
			0 "DIAG_PMVAC_INIT"
			1 "DIAG_PMVAC_TEMP_DEM"
			2 "DIAG_PMVAC_ATT_INCO"
			3 "DIAG_PMVAC_INCO_TEMP"
			4 "DIAG_PMVAC_INCO_CONF"
		/end COMPU_VTAB
		/begin COMPU_METHOD Vsx_mvac_pump_conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Vsx_mvac_pump_table
		/end COMPU_METHOD
		/begin COMPU_VTAB Vsx_mvac_pump_table
			""
			TAB_VERB
			4
			0 "PUMP_DSB"
			1 "PUMP_OFF_WAIT"
			2 "PUMP_ON"
			3 "PUMP_OFF_PROT"
		/end COMPU_VTAB
		/begin COMPU_METHOD Phvl_conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Phvl_table
		/end COMPU_METHOD
		/begin COMPU_VTAB Phvl_table
			""
			TAB_VERB
			6
			0 "VER_INIT"
			16 "VER_APPRENTISSAGE_SKEY"
			32 "VER_CHALLENGE_SIGNATURE"
			48 "VER_SEQUENCE_CLEAR"
			64 "VER_STUFFING"
			80 "VER_POWER_LATCH"
		/end COMPU_VTAB
		/begin COMPU_METHOD Vsx_cru_sl_on_off_conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Vsx_cru_sl_on_off_table
		/end COMPU_METHOD
		/begin COMPU_VTAB Vsx_cru_sl_on_off_table
			""
			TAB_VERB
			3
			0 "NSX_CRU_SL_OFF"
			1 "NSX_SL"
			2 "NSX_CRU"
		/end COMPU_VTAB
		/begin COMPU_METHOD Vsx_cru_sl_on_off_raw_conv
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Vsx_cru_sl_on_off_raw_table
		/end COMPU_METHOD
		/begin COMPU_VTAB Vsx_cru_sl_on_off_raw_table
			""
			TAB_VERB
			4
			0 "NSX_CRU_SL_OFF_RAW"
			1 "NSX_SL_RAW"
			2 "NSX_CRU_RAW"
			3 "NSX_CRU_SL_NOK_RAW"
		/end COMPU_VTAB
	/end MODULE
/end PROJECT
"