			262140
			ECU_ADDRESS 0xFFFF7EEA
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lbup_hot_dly_ctr
			"Vxx_lbup_hot_dly_ctr"
			UWORD
			F_1_p0_53
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7EEC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lbup_hot_rest
			"Vxx_lbup_hot_rest"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7EC7
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lbup_hot_stt_t
			"Vxx_lbup_hot_stt_t"
			UBYTE
			F_0v512_p0_121
			2
			2
			0
			130.56
			ECU_ADDRESS 0xFFFF7EC8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lbup_hot_t
			"Vxx_lbup_hot_t"
			UWORD
			F_0v128_p0_75
			2
			2
			0
			8388.48
			ECU_ADDRESS 0xFFFF7EEE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lbup_in_ctr
			"Vxx_lbup_in_ctr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7DA5
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lbup_jerk_nr
			"Vxx_lbup_jerk_nr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7DA6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lbup_maf_mem
			"Vxx_lbup_maf_mem"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7DA7
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lbup_maf_mv
			"Vxx_lbup_maf_mv"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7E18
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lbup_maf_mv_rtn
			"Vxx_lbup_maf_mv_rtn"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF8924
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lbup_maf_prop_per
			"Vxx_lbup_maf_prop_per"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7E1A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lbup_max_ofs_rich
			"Vxx_lbup_max_ofs_rich"
			SBYTE
			Id_0x00
			2
			2
			-128
			127
			ECU_ADDRESS 0xFFFF7D78
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lbup_min_ofs_lean
			"Vxx_lbup_min_ofs_lean"
			SBYTE
			Id_0x00
			2
			2
			-128
			127
			ECU_ADDRESS 0xFFFF7D79
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lbup_mv_ofs_diag
			"Vxx_lbup_mv_ofs_diag"
			SBYTE
			Id_0x00
			2
			2
			-128
			127
			ECU_ADDRESS 0xFFFF7D7A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lbup_no_oc_det_ctr
			"Vxx_lbup_no_oc_det_ctr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7EC9
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lbup_no_scg_t
			"Vxx_lbup_no_scg_t"
			UBYTE
			F_64_p0_145
			2
			2
			0
			16320
			ECU_ADDRESS 0xFFFF7ECA
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lbup_oc_t
			"Vxx_lbup_oc_t"
			UBYTE
			F_64_p0_145
			2
			2
			0
			16320
			ECU_ADDRESS 0xFFFF7ECB
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lbup_ofs_mes_t
			"Vxx_lbup_ofs_mes_t"
			UBYTE
			F_512_p0_104
			2
			2
			0
			130560
			ECU_ADDRESS 0xFFFF7DA8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lbup_per_ctr
			"Vxx_lbup_per_ctr"
			UWORD
			F_8_p0_56
			2
			2
			0
			524280
			ECU_ADDRESS 0xFFFF7E1C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lbup_per_dly_acq
			"Vxx_lbup_per_dly_acq"
			UWORD
			F_8_p0_56
			2
			2
			0
			524280
			ECU_ADDRESS 0xFFFF7E1E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lbup_per_dly_tot
			"Vxx_lbup_per_dly_tot"
			UWORD
			F_8_p0_56
			2
			2
			0
			524280
			ECU_ADDRESS 0xFFFF7E20
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lbup_per_mv
			"Vxx_lbup_per_mv"
			UBYTE
			F_16_p0_10
			2
			2
			0
			4080
			ECU_ADDRESS 0xFFFF7DA9
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lbup_per_mv_max
			"Vxx_lbup_per_mv_max"
			UBYTE
			F_16_p0_10
			2
			2
			0
			4080
			ECU_ADDRESS 0xFFFF7DAA
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lbup_per_mv_max_rtn
			"Vxx_lbup_per_mv_max_rtn"
			UBYTE
			F_16_p0_10
			2
			2
			0
			4080
			ECU_ADDRESS 0xFFFF8927
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lbup_per_nr
			"Vxx_lbup_per_nr"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7E22
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lbup_per_nr_tot
			"Vxx_lbup_per_nr_tot"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7E24
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lbup_per_out_mes
			"Vxx_lbup_per_out_mes"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7DAB
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lbup_per_tot_mv
			"Vxx_lbup_per_tot_mv"
			UBYTE
			F_16_p0_10
			2
			2
			0
			4080
			ECU_ADDRESS 0xFFFF7DAC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lbup_per_tot_mv_rtn
			"Vxx_lbup_per_tot_mv_rtn"
			UBYTE
			F_16_p0_10
			2
			2
			0
			4080
			ECU_ADDRESS 0xFFFF892A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lbup_pump_crt_dly
			"Vxx_lbup_pump_crt_dly"
			UBYTE
			F_0v512_p0_121
			2
			2
			0
			130.56
			ECU_ADDRESS 0xFFFF7ECC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lbup_pump_crt_t
			"Vxx_lbup_pump_crt_t"
			UBYTE
			F_0v512_p0_121
			2
			2
			0
			130.56
			ECU_ADDRESS 0xFFFF7ECD
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lbup_pwm_ctr
			"Vxx_lbup_pwm_ctr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7ECE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lbup_ref_cmd
			"Vxx_lbup_ref_cmd"
			UBYTE
			F_1_p0_207
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7ECF
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lbup_ref_pwm
			"Vxx_lbup_ref_pwm"
			UBYTE
			F_0v390625_p0_4
			2
			2
			0
			99.609375
			ECU_ADDRESS 0xFFFF7ED0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lbup_scg_t
			"Vxx_lbup_scg_t"
			UBYTE
			F_64_p0_145
			2
			2
			0
			16320
			ECU_ADDRESS 0xFFFF7ED1
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lbup_stab_dly
			"Vxx_lbup_stab_dly"
			UBYTE
			F_512_p0_104
			2
			2
			0
			130560
			ECU_ADDRESS 0xFFFF7DAD
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lbup_stt
			"Vxx_lbup_stt"
			UBYTE
			Vxx_lbup_stt_conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF7DAE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lbup_trs_dly
			"Vxx_lbup_trs_dly"
			UBYTE
			F_8_p0_56
			2
			2
			0
			2040
			ECU_ADDRESS 0xFFFF7ED2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lbup_v
			"Vxx_lbup_v"
			UBYTE
			F_9v76_p0_45
			2
			2
			0
			2488.8
			ECU_ADDRESS 0xFFFF7ED3
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lean_rich_trs_mv_dly
			"Vxx_lean_rich_trs_mv_dly"
			UBYTE
			F_8_p0_56
			2
			2
			0
			2040
			ECU_ADDRESS 0xFFFF7DAF
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lft_trt_ad
			"Vxx_lft_trt_ad"
			UWORD
			F_0v04376_p0_180
			2
			2
			0
			2867.8116
			ECU_ADDRESS 0xFFFF77D8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lgl_dly_diag_cata
			"Vxx_lgl_dly_diag_cata"
			UWORD
			F_512_p0_104
			2
			2
			0
			33553920
			ECU_ADDRESS 0xFFFF7E26
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lgl_dly_diag_lamb
			"Vxx_lgl_dly_diag_lamb"
			UWORD
			F_512_p0_104
			2
			2
			0
			33553920
			ECU_ADDRESS 0xFFFF7E28
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lih_efy_sp
			"Vxx_lih_efy_sp"
			UWORD
			F_0v0015258_p0_48
			2
			2
			0
			99.993303
			ECU_ADDRESS 0xFFFF83F2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lih_iga_cor
			"Vxx_lih_iga_cor"
			UBYTE
			F_0v375_p0_29
			2
			2
			0
			95.625
			ECU_ADDRESS 0xFFFF6DC0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lih_iga_cor_max_t
			"Vxx_lih_iga_cor_max_t"
			UBYTE
			F_0v512_p0_121
			2
			2
			0
			130.56
			ECU_ADDRESS 0xFFFF6DC1
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lih_inj_act_nr
			"Vxx_lih_inj_act_nr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8341
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lih_inj_cut_nr
			"Vxx_lih_inj_cut_nr"
			UBYTE
			F_1_p0_9
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8342
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lih_psn
			"Vxx_lih_psn"
			UWORD
			F_0v097656_p0_5
			2
			2
			0
			6399.88596
			ECU_ADDRESS 0xFFFF775C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lih_psn1
			"Vxx_lih_psn1"
			UWORD
			F_0v097656_p0_5
			2
			2
			0
			6399.88596
			ECU_ADDRESS 0xFFFF8648
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lih_psn2
			"Vxx_lih_psn2"
			UWORD
			F_0v097656_p0_5
			2
			2
			0
			6399.88596
			ECU_ADDRESS 0xFFFF864A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lim_mux_fast_tq_sp
			"Vxx_lim_mux_fast_tq_sp"
			UWORD
			F_0v0078125_m100_35
			2
			2
			-100
			411.9921875
			ECU_ADDRESS 0xFFFF83F4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lim_mux_slow_tq_sp
			"Vxx_lim_mux_slow_tq_sp"
			UWORD
			F_0v0078125_m100_35
			2
			2
			-100
			411.9921875
			ECU_ADDRESS 0xFFFF83F6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lim_pred_map
			"Vxx_lim_pred_map"
			UWORD
			F_3v7_p103_37
			2
			2
			103
			242582.5
			ECU_ADDRESS 0xFFFF8034
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lim_slow_tq_sp
			"Vxx_lim_slow_tq_sp"
			UWORD
			F_0v0078125_m100_35
			2
			2
			-100
			411.9921875
			ECU_ADDRESS 0xFFFF83F8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lk_off_mem
			"Vxx_lk_off_mem"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF88C9
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_loss_syn_ctr
			"Vxx_loss_syn_ctr"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF86B8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lpg_abst_ctr
			"Vxx_lpg_abst_ctr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7339
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lpg_abst_mem
			"Vxx_lpg_abst_mem"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF88C7
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lpg_ad_fac
			"Vxx_lpg_ad_fac"
			UWORD
			F_0v0015258789_m50_64
			2
			2
			-50
			49.99847412
			ECU_ADDRESS 0xFFFF7994
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lpg_aftr_sta_dly
			"Vxx_lpg_aftr_sta_dly"
			UWORD
			F_0v032_p0_99
			2
			2
			0
			2097.12
			ECU_ADDRESS 0xFFFF7996
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lpg_aftr_sta_ini_dly
			"Vxx_lpg_aftr_sta_ini_dly"
			UWORD
			F_0v032_p0_99
			2
			2
			0
			2097.12
			ECU_ADDRESS 0xFFFF7998
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lpg_aper_dly
			"Vxx_lpg_aper_dly"
			UWORD
			F_1v024_p0_119
			2
			2
			0
			67107.84
			ECU_ADDRESS 0xFFFF799A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lpg_cl_lean_diag_dly
			"Vxx_lpg_cl_lean_diag_dly"
			UBYTE
			F_0v128_p0_75
			2
			2
			0
			32.64
			ECU_ADDRESS 0xFFFF7976
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lpg_cmd_lght_req
			"Vxx_lpg_cmd_lght_req"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF733A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lpg_cor_iga
			"Vxx_lpg_cor_iga"
			UBYTE
			F_0v375_m23v625_6
			2
			2
			-23.625
			72
			ECU_ADDRESS 0xFFFF6DC2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lpg_cor_otl_iga
			"Vxx_lpg_cor_otl_iga"
			UBYTE
			F_0v375_m23v625_6
			2
			2
			-23.625
			72
			ECU_ADDRESS 0xFFFF7A2A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lpg_cyl1_cor_fac
			"Vxx_lpg_cyl1_cor_fac"
			UBYTE
			F_0v78125_m100_388
			2
			2
			-100
			99.21875
			ECU_ADDRESS 0xFFFF7978
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lpg_cyl1_gas_trs_cor
			"Vxx_lpg_cyl1_gas_trs_cor"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7AD9
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lpg_cyl1_trs_fac
			"Vxx_lpg_cyl1_trs_fac"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7979
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lpg_cyl2_cor_fac
			"Vxx_lpg_cyl2_cor_fac"
			UBYTE
			F_0v78125_m100_388
			2
			2
			-100
			99.21875
			ECU_ADDRESS 0xFFFF797A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lpg_cyl2_gas_trs_cor
			"Vxx_lpg_cyl2_gas_trs_cor"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7ADA
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lpg_cyl2_trs_fac
			"Vxx_lpg_cyl2_trs_fac"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF797B
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lpg_cyl3_cor_fac
			"Vxx_lpg_cyl3_cor_fac"
			UBYTE
			F_0v78125_m100_388
			2
			2
			-100
			99.21875
			ECU_ADDRESS 0xFFFF797C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lpg_cyl3_gas_trs_cor
			"Vxx_lpg_cyl3_gas_trs_cor"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7ADB
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lpg_cyl3_trs_fac
			"Vxx_lpg_cyl3_trs_fac"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF797D
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lpg_cyl4_cor_fac
			"Vxx_lpg_cyl4_cor_fac"
			UBYTE
			F_0v78125_m100_388
			2
			2
			-100
			99.21875
			ECU_ADDRESS 0xFFFF797E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lpg_cyl4_gas_trs_cor
			"Vxx_lpg_cyl4_gas_trs_cor"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7ADC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lpg_cyl4_trs_fac
			"Vxx_lpg_cyl4_trs_fac"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF797F
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lpg_cyl_nr_flow_cor
			"Vxx_lpg_cyl_nr_flow_cor"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7977
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lpg_ecu_stt
			"Vxx_lpg_ecu_stt"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF733B
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lpg_efv_ti
			"Vxx_lpg_efv_ti"
			UWORD
			F_4_p0_149
			2
			2
			0
			262140
			ECU_ADDRESS 0xFFFF799C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lpg_fl_lean_diag_dly
			"Vxx_lpg_fl_lean_diag_dly"
			UBYTE
			F_0v128_p0_75
			2
			2
			0
			32.64
			ECU_ADDRESS 0xFFFF7980
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lpg_flow
			"Vxx_lpg_flow"
			UWORD
			F_2_p0_389
			2
			2
			0
			131070
			ECU_ADDRESS 0xFFFF799E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lpg_flow_cor_can
			"Vxx_lpg_flow_cor_can"
			UBYTE
			F_0v78125_m100_388
			2
			2
			-100
			99.21875
			ECU_ADDRESS 0xFFFF7981
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lpg_flow_req
			"Vxx_lpg_flow_req"
			UWORD
			F_2_p0_389
			2
			2
			0
			131070
			ECU_ADDRESS 0xFFFF79A0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lpg_gas_dly
			"Vxx_lpg_gas_dly"
			UWORD
			F_0v032_p0_99
			2
			2
			0
			2097.12
			ECU_ADDRESS 0xFFFF79A2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lpg_gas_lpg_dly
			"Vxx_lpg_gas_lpg_dly"
			UWORD
			F_0v032_p0_99
			2
			2
			0
			2097.12
			ECU_ADDRESS 0xFFFF79A4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lpg_gas_pump_cut_dly
			"Vxx_lpg_gas_pump_cut_dly"
			UWORD
			F_1v024_p0_119
			2
			2
			0
			67107.84
			ECU_ADDRESS 0xFFFF79A6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lpg_gas_pump_ini_dly
			"Vxx_lpg_gas_pump_ini_dly"
			UWORD
			F_0v032_p0_99
			2
			2
			0
			2097.12
			ECU_ADDRESS 0xFFFF79A8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lpg_gas_trs_cor_dec
			"Vxx_lpg_gas_trs_cor_dec"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7982
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lpg_gas_trs_cor_inc
			"Vxx_lpg_gas_trs_cor_inc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7983
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lpg_gas_trs_cor_ini
			"Vxx_lpg_gas_trs_cor_ini"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7984
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lpg_inc_ad_cor
			"Vxx_lpg_inc_ad_cor"
			UWORD
			F_0v0015258789_m50_80
			2
			2
			-50
			49.99847412
			ECU_ADDRESS 0xFFFF79AA
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lpg_inj_avl_nr
			"Vxx_lpg_inj_avl_nr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7985
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lpg_inj_cut_dly
			"Vxx_lpg_inj_cut_dly"
			UBYTE
			F_8_p0_56
			2
			2
			0
			2040
			ECU_ADDRESS 0xFFFF7986
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lpg_inj_cut_nr
			"Vxx_lpg_inj_cut_nr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7ADD
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lpg_lght_req
			"Vxx_lpg_lght_req"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF733C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lpg_mv_ad_fac
			"Vxx_lpg_mv_ad_fac"
			UWORD
			F_0v0015258789_m50_80
			2
			2
			-50
			49.99847412
			ECU_ADDRESS 0xFFFF79AC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lpg_nr_lpg_stal
			"Vxx_lpg_nr_lpg_stal"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8921
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lpg_prs
			"Vxx_lpg_prs"
			UWORD
			F_5_p0_230
			2
			2
			0
			327675
			ECU_ADDRESS 0xFFFF739A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lpg_prs_diag_dly
			"Vxx_lpg_prs_diag_dly"
			UBYTE
			F_128_p0_125
			2
			2
			0
			32640
			ECU_ADDRESS 0xFFFF7987
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lpg_stall_dly
			"Vxx_lpg_stall_dly"
			UBYTE
			F_0v128_p0_75
			2
			2
			0
			32.64
			ECU_ADDRESS 0xFFFF7988
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lpg_temp
			"Vxx_lpg_temp"
			UBYTE
			F_1_m40_40
			2
			2
			-40
			215
			ECU_ADDRESS 0xFFFF733D
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lpg_trs_cor_min
			"Vxx_lpg_trs_cor_min"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7989
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lpg_trs_cor_stop
			"Vxx_lpg_trs_cor_stop"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF798A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lpg_typ
			"Vxx_lpg_typ"
			UBYTE
			F_0v390625_p0_4
			2
			2
			0
			99.609375
			ECU_ADDRESS 0xFFFF798B
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lpg_wup_cor_fac
			"Vxx_lpg_wup_cor_fac"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF798C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lpg_wup_cyc_nr
			"Vxx_lpg_wup_cyc_nr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF798D
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lpg_zon_1_ad_cor
			"Vxx_lpg_zon_1_ad_cor"
			UWORD
			F_0v0015258789_m50_64
			2
			2
			-50
			49.99847412
			ECU_ADDRESS 0xFFFF862A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lpg_zon_2_ad_cor
			"Vxx_lpg_zon_2_ad_cor"
			UWORD
			F_0v0015258789_m50_64
			2
			2
			-50
			49.99847412
			ECU_ADDRESS 0xFFFF862C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lpg_zon_3_ad_cor
			"Vxx_lpg_zon_3_ad_cor"
			UWORD
			F_0v0015258789_m50_64
			2
			2
			-50
			49.99847412
			ECU_ADDRESS 0xFFFF862E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lpg_zon_4_ad_cor
			"Vxx_lpg_zon_4_ad_cor"
			UWORD
			F_0v0015258789_m50_64
			2
			2
			-50
			49.99847412
			ECU_ADDRESS 0xFFFF8630
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_lpg_zon_5_ad_cor
			"Vxx_lpg_zon_5_ad_cor"
			UWORD
			F_0v0015258789_m50_64
			2
			2
			-50
			49.99847412
			ECU_ADDRESS 0xFFFF8632
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_maf_fil
			"Vxx_maf_fil"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7E2A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_maf_t
			"Vxx_maf_t"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7DB0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_maf_tdc
			"Vxx_maf_tdc"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7E2C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_maf_tq_mux
			"Vxx_maf_tq_mux"
			UWORD
			F_0v015258_p0_390
			2
			2
			0
			999.93303
			ECU_ADDRESS 0xFFFF83FA
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_map
			"Vxx_map"
			UWORD
			F_3v7_p103_37
			2
			2
			103
			242582.5
			ECU_ADDRESS 0xFFFF805E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_map16
			"Vxx_map16"
			UWORD
			F_0v0578_p103_348
			2
			2
			103
			3890.923
			ECU_ADDRESS 0xFFFF8062
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_map2
			"Vxx_map2"
			UWORD
			F_3v7_p103_37
			2
			2
			103
			242582.5
			ECU_ADDRESS 0xFFFF7B6C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_map_fil_fac
			"Vxx_map_fil_fac"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8053
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_map_fil_sa
			"Vxx_map_fil_sa"
			UWORD
			F_0v0578_p103_348
			2
			2
			103
			3890.923
			ECU_ADDRESS 0xFFFF7E2E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_map_fil_val
			"Vxx_map_fil_val"
			UWORD
			F_0v0578_p103_348
			2
			2
			103
			3890.923
			ECU_ADDRESS 0xFFFF7E30
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_map_fl_ocl
			"Vxx_map_fl_ocl"
			UWORD
			F_3v7_p103_37
			2
			2
			103
			242582.5
			ECU_ADDRESS 0xFFFF7B6A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_map_mem1
			"Vxx_map_mem1"
			UWORD
			F_3v7_p103_37
			2
			2
			103
			242582.5
			ECU_ADDRESS 0xFFFF7BC2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_map_mem2
			"Vxx_map_mem2"
			UWORD
			F_3v7_p103_37
			2
			2
			103
			242582.5
			ECU_ADDRESS 0xFFFF7BC4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_map_mem3
			"Vxx_map_mem3"
			UWORD
			F_3v7_p103_37
			2
			2
			103
			242582.5
			ECU_ADDRESS 0xFFFF7BC6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_map_mem4
			"Vxx_map_mem4"
			UWORD
			F_3v7_p103_37
			2
			2
			103
			242582.5
			ECU_ADDRESS 0xFFFF7BC8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_map_mvac_dp_inc
			"Vxx_map_mvac_dp_inc"
			UWORD
			F_0v014453125_p0_391
			2
			2
			0
			947.1855469
			ECU_ADDRESS 0xFFFF7910
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_map_prev
			"Vxx_map_prev"
			UWORD
			F_3v7_p103_37
			2
			2
			103
			242582.5
			ECU_ADDRESS 0xFFFF8060
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_map_rat
			"Vxx_map_rat"
			UBYTE
			F_0v390625_p0_4
			2
			2
			0
			99.609375
			ECU_ADDRESS 0xFFFF77AB
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_map_ref
			"Vxx_map_ref"
			UWORD
			F_3v7_p103_37
			2
			2
			103
			242582.5
			ECU_ADDRESS 0xFFFF83FC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_map_slop
			"Vxx_map_slop"
			SWORD
			F_3v7_p0_21
			2
			2
			-121241.6
			121237.9
			ECU_ADDRESS 0xFFFF84BE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_map_thd_inj_cut
			"Vxx_map_thd_inj_cut"
			UWORD
			F_3v7_p103_37
			2
			2
			103
			242582.5
			ECU_ADDRESS 0xFFFF84DE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_max_avl_tqe
			"Vxx_max_avl_tqe"
			UWORD
			F_0v0078125_m100_35
			2
			2
			-100
			411.9921875
			ECU_ADDRESS 0xFFFF83FE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_max_avl_tqe1
			"Vxx_max_avl_tqe1"
			UWORD
			F_0v0078125_m100_35
			2
			2
			-100
			411.9921875
			ECU_ADDRESS 0xFFFF8400
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_max_iga
			"Vxx_max_iga"
			UBYTE
			F_0v375_m23v625_6
			2
			2
			-23.625
			72
			ECU_ADDRESS 0xFFFF7A2B
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_max_is_i
			"Vxx_max_is_i"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7A0C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_max_map_inj_cut
			"Vxx_max_map_inj_cut"
			UWORD
			F_3v7_p103_37
			2
			2
			103
			242582.5
			ECU_ADDRESS 0xFFFF84E0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_max_n_ovn
			"Vxx_max_n_ovn"
			UBYTE
			F_32_p0_46
			2
			2
			0
			8160
			ECU_ADDRESS 0xFFFF80FA
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_max_otl_iga_mv_tqi
			"Vxx_max_otl_iga_mv_tqi"
			UWORD
			F_8_p0_116
			2
			2
			0
			524280
			ECU_ADDRESS 0xFFFF8402
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_max_spg_prs
			"Vxx_max_spg_prs"
			UWORD
			F_3v7_p103_37
			2
			2
			103
			242582.5
			ECU_ADDRESS 0xFFFF84E2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_max_ti_b_0
			"Vxx_max_ti_b_0"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF868D
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_max_ti_b_1
			"Vxx_max_ti_b_1"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF868E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_max_ti_b_2
			"Vxx_max_ti_b_2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF868F
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_max_ti_b_3
			"Vxx_max_ti_b_3"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8690
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_max_ti_b_4
			"Vxx_max_ti_b_4"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8691
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_max_tqe
			"Vxx_max_tqe"
			UBYTE
			F_2_m100_36
			2
			2
			-100
			410
			ECU_ADDRESS 0xFFFF81EA
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_max_tqi
			"Vxx_max_tqi"
			UWORD
			F_0v0078125_m100_35
			2
			2
			-100
			411.9921875
			ECU_ADDRESS 0xFFFF8404
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mcut_sge_voltage
			"Vxx_mcut_sge_voltage"
			SWORD
			F_0v625_p0_258
			2
			2
			-20480
			20479.375
			ECU_ADDRESS 0xFFFF76EA
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mdf1_is_cor_appl_dly
			"Vxx_mdf1_is_cor_appl_dly"
			UBYTE
			F_16_p0_10
			2
			2
			0
			4080
			ECU_ADDRESS 0xFFFF79CD
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mdl_dly_eng_maf
			"Vxx_mdl_dly_eng_maf"
			UWORD
			F_0v0152588_p0_362
			2
			2
			0
			999.985458
			ECU_ADDRESS 0xFFFF7A46
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mdl_eng_maf
			"Vxx_mdl_eng_maf"
			UWORD
			F_0v0152588_p0_362
			2
			2
			0
			999.985458
			ECU_ADDRESS 0xFFFF7A48
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mdl_eng_maf_prec
			"Vxx_mdl_eng_maf_prec"
			UWORD
			F_0v0000152588_p0_27
			2
			2
			0
			0.9999847412
			ECU_ADDRESS 0xFFFF7A4A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mdl_map
			"Vxx_mdl_map"
			UWORD
			F_3v7_p103_37
			2
			2
			103
			242582.5
			ECU_ADDRESS 0xFFFF8064
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mdl_map_spg_rat
			"Vxx_mdl_map_spg_rat"
			UWORD
			F_15v2587890625_p0_68
			2
			2
			0
			999984.7412
			ECU_ADDRESS 0xFFFF8036
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mdl_thr_maf
			"Vxx_mdl_thr_maf"
			UWORD
			F_0v0000152588_p0_27
			2
			2
			0
			0.9999847412
			ECU_ADDRESS 0xFFFF7A4C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mdl_thr_maf_cor
			"Vxx_mdl_thr_maf_cor"
			UWORD
			F_0v0000152588_p0_27
			2
			2
			0
			0.9999847412
			ECU_ADDRESS 0xFFFF7A4E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mem_rest_cor
			"Vxx_mem_rest_cor"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8650
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mem_rest_tco
			"Vxx_mem_rest_tco"
			UBYTE
			F_0v625_m40_25
			2
			2
			-40
			119.375
			ECU_ADDRESS 0xFFFF8651
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mem_whl_mov_sgn
			"Vxx_mem_whl_mov_sgn"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF77C3
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mes2_vb
			"Vxx_mes2_vb"
			UBYTE
			F_0v03125_p5_392
			2
			2
			5
			12.96875
			ECU_ADDRESS 0xFFFF6DE5
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mes_lbdw_v
			"Vxx_mes_lbdw_v"
			UWORD
			F_9v76_p0_45
			2
			2
			0
			639621.6
			ECU_ADDRESS 0xFFFF7EF0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mes_lbup_v
			"Vxx_mes_lbup_v"
			UWORD
			F_9v76_p0_45
			2
			2
			0
			639621.6
			ECU_ADDRESS 0xFFFF7EF2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mes_map
			"Vxx_mes_map"
			UWORD
			F_3v7_p103_37
			2
			2
			103
			242582.5
			ECU_ADDRESS 0xFFFF8066
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mes_map_max
			"Vxx_mes_map_max"
			UWORD
			F_3v7_p103_37
			2
			2
			103
			242582.5
			ECU_ADDRESS 0xFFFF7E32
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mes_map_min
			"Vxx_mes_map_min"
			UWORD
			F_3v7_p103_37
			2
			2
			103
			242582.5
			ECU_ADDRESS 0xFFFF7E34
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mes_spg
			"Vxx_mes_spg"
			UWORD
			F_3v7_p103_37
			2
			2
			103
			242582.5
			ECU_ADDRESS 0xFFFF84E4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mes_tco
			"Vxx_mes_tco"
			UBYTE
			F_0v625_m40_25
			2
			2
			-40
			119.375
			ECU_ADDRESS 0xFFFF858C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mes_tia
			"Vxx_mes_tia"
			UBYTE
			F_0v625_m40_25
			2
			2
			-40
			119.375
			ECU_ADDRESS 0xFFFF6D0E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mes_vb
			"Vxx_mes_vb"
			UBYTE
			F_0v032_p8_130
			2
			2
			8
			16.16
			ECU_ADDRESS 0xFFFF6DE4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mes_vs
			"Vxx_mes_vs"
			UBYTE
			F_1_p0_58
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8291
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mfld_dly
			"Vxx_mfld_dly"
			UWORD
			F_0v00152588_p0_107
			2
			2
			0
			99.9985458
			ECU_ADDRESS 0xFFFF8406
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mfld_dly_fil_fac
			"Vxx_mfld_dly_fil_fac"
			UWORD
			F_0v000015259_p0_216
			2
			2
			0
			0.999998565
			ECU_ADDRESS 0xFFFF7810
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mfld_fil_fac
			"Vxx_mfld_fil_fac"
			UWORD
			F_0v0078125_p0_213
			2
			2
			0
			511.9921875
			ECU_ADDRESS 0xFFFF8038
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mfld_in_fil_fac
			"Vxx_mfld_in_fil_fac"
			UWORD
			F_0v001526_p0_42
			2
			2
			0
			100.00641
			ECU_ADDRESS 0xFFFF8408
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mfld_out_fil_fac
			"Vxx_mfld_out_fil_fac"
			UWORD
			F_0v0015258_p0_48
			2
			2
			0
			99.993303
			ECU_ADDRESS 0xFFFF840A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mil_on_km
			"Vxx_mil_on_km"
			UWORD
			F_1_p0_393
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF86A0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mil_on_km_1
			"Vxx_mil_on_km_1"
			UWORD
			F_0v2844141_p0_394
			2
			2
			0
			18639.07804
			ECU_ADDRESS 0xFFFF86A2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_min_abf_iga
			"Vxx_min_abf_iga"
			UBYTE
			F_0v375_m23v625_6
			2
			2
			-23.625
			72
			ECU_ADDRESS 0xFFFF7A2C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_min_alt_crt_v
			"Vxx_min_alt_crt_v"
			UWORD
			F_0v023583984_p0_196
			2
			2
			0
			1545.576391
			ECU_ADDRESS 0xFFFF6D54
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_min_avl_tqe
			"Vxx_min_avl_tqe"
			UWORD
			F_0v0078125_m100_35
			2
			2
			-100
			411.9921875
			ECU_ADDRESS 0xFFFF840C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_min_avl_tqe1
			"Vxx_min_avl_tqe1"
			UWORD
			F_0v0078125_m100_35
			2
			2
			-100
			411.9921875
			ECU_ADDRESS 0xFFFF840E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_min_fil_inj_avl_tqe
			"Vxx_min_fil_inj_avl_tqe"
			UWORD
			F_0v0078125_m100_35
			2
			2
			-100
			411.9921875
			ECU_ADDRESS 0xFFFF8410
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_min_gas_dly
			"Vxx_min_gas_dly"
			UBYTE
			F_512_p0_104
			2
			2
			0
			130560
			ECU_ADDRESS 0xFFFF733E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_min_gas_fmt
			"Vxx_min_gas_fmt"
			UWORD
			F_0v000015259_p0_216
			2
			2
			0
			0.999998565
			ECU_ADDRESS 0xFFFF8412
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_min_gas_lvl_dly
			"Vxx_min_gas_lvl_dly"
			UBYTE
			F_512_p0_104
			2
			2
			0
			130560
			ECU_ADDRESS 0xFFFF733F
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_min_iga_dsb_t
			"Vxx_min_iga_dsb_t"
			UBYTE
			F_128_p0_125
			2
			2
			0
			32640
			ECU_ADDRESS 0xFFFF7A2D
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_min_is_i
			"Vxx_min_is_i"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7A0E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_min_lpg_lvl_dly
			"Vxx_min_lpg_lvl_dly"
			UBYTE
			F_512_p0_104
			2
			2
			0
			130560
			ECU_ADDRESS 0xFFFF7340
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_min_map_maf
			"Vxx_min_map_maf"
			UWORD
			F_3v7_p0_21
			2
			2
			0
			242479.5
			ECU_ADDRESS 0xFFFF803A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_min_map_spg_rat
			"Vxx_min_map_spg_rat"
			UWORD
			F_7v629394_p0_395
			2
			2
			0
			499992.3358
			ECU_ADDRESS 0xFFFF803C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_min_mv_tqi
			"Vxx_min_mv_tqi"
			UWORD
			F_0v007813_p0_81
			2
			2
			0
			512.024955
			ECU_ADDRESS 0xFFFF8414
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_min_pwm
			"Vxx_min_pwm"
			SLONG
			Id_0x00
			2
			2
			-2147483648
			2147483647
			ECU_ADDRESS 0xFFFF7A14
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_min_ti_b_0
			"Vxx_min_ti_b_0"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8688
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_min_ti_b_1
			"Vxx_min_ti_b_1"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8689
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_min_ti_b_2
			"Vxx_min_ti_b_2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF868A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_min_ti_b_3
			"Vxx_min_ti_b_3"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF868B
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_min_ti_b_4
			"Vxx_min_ti_b_4"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF868C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_min_vb_is_ofs
			"Vxx_min_vb_is_ofs"
			UBYTE
			F_16_p0_83
			2
			2
			0
			4080
			ECU_ADDRESS 0xFFFF80FB
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mis_16_tdc_ctr
			"Vxx_mis_16_tdc_ctr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7DB1
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mis_cart_iga_dif
			"Vxx_mis_cart_iga_dif"
			SBYTE
			F_0v375_p0_29
			2
			2
			-48
			47.625
			ECU_ADDRESS 0xFFFF6D92
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mis_cart_iga_dif1
			"Vxx_mis_cart_iga_dif1"
			SBYTE
			F_0v375_p0_29
			2
			2
			-48
			47.625
			ECU_ADDRESS 0xFFFF6D93
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mis_cart_iga_dif2
			"Vxx_mis_cart_iga_dif2"
			SBYTE
			F_0v375_p0_29
			2
			2
			-48
			47.625
			ECU_ADDRESS 0xFFFF6D94
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mis_cata_min_fuel_nr
			"Vxx_mis_cata_min_fuel_nr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF86D9
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mis_cata_mis_ctr
			"Vxx_mis_cata_mis_ctr"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7E36
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mis_cata_tdc_ctr
			"Vxx_mis_cata_tdc_ctr"
			UWORD
			F_1_p0_53
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7E38
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mis_cata_tdc_nr_tot
			"Vxx_mis_cata_tdc_nr_tot"
			ULONG
			Id_0x00
			2
			2
			0
			4294967295
			ECU_ADDRESS 0xFFFF7D70
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mis_cata_tdc_nr_tot_lsb
			"Vxx_mis_cata_tdc_nr_tot_lsb"
			UWORD
			F_1_p0_9
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF88AE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mis_cata_tdc_nr_tot_msb
			"Vxx_mis_cata_tdc_nr_tot_msb"
			UWORD
			F_65536_p0_396
			2
			2
			0
			4294901760
			ECU_ADDRESS 0xFFFF88AC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mis_cata_tdc_prmt
			"Vxx_mis_cata_tdc_prmt"
			ULONG
			F_1_p0_53
			2
			2
			0
			4294967295
			ECU_ADDRESS 0xFFFF7D74
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mis_cata_tdc_prmt_lsb
			"Vxx_mis_cata_tdc_prmt_lsb"
			UWORD
			F_1_p0_53
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF88B2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mis_cata_tdc_prmt_msb
			"Vxx_mis_cata_tdc_prmt_msb"
			UWORD
			F_65536_p0_397
			2
			2
			0
			4294901760
			ECU_ADDRESS 0xFFFF88B0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mis_cyl1_tdc_ctr
			"Vxx_mis_cyl1_tdc_ctr"
			UWORD
			F_1_p0_53
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7E3A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mis_cyl2_tdc_ctr
			"Vxx_mis_cyl2_tdc_ctr"
			UWORD
			F_1_p0_53
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7E3C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mis_cyl3_tdc_ctr
			"Vxx_mis_cyl3_tdc_ctr"
			UWORD
			F_1_p0_53
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7E3E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mis_cyl4_tdc_ctr
			"Vxx_mis_cyl4_tdc_ctr"
			UWORD
			F_1_p0_53
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7E40
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mis_cyl_fail_nr
			"Vxx_mis_cyl_fail_nr"
			UBYTE
			F_1_p0_9
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7DB2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mis_eal_frz
			"Vxx_mis_eal_frz"
			UBYTE
			F_0v3921569_p0_340
			2
			2
			0
			100.0000095
			ECU_ADDRESS 0xFFFF7DB3
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mis_eol_mod_mis_ctr
			"Vxx_mis_eol_mod_mis_ctr"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7E42
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mis_eol_mod_prop
			"Vxx_mis_eol_mod_prop"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7DB4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mis_eol_mod_tdc_ctr
			"Vxx_mis_eol_mod_tdc_ctr"
			UWORD
			F_1_p0_53
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7E44
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mis_fast_mis_ctr
			"Vxx_mis_fast_mis_ctr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7DB5
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mis_fast_tdc_ctr
			"Vxx_mis_fast_tdc_ctr"
			UBYTE
			F_1_p0_53
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7DB6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mis_is_iga_dif
			"Vxx_mis_is_iga_dif"
			SBYTE
			F_0v375_p0_29
			2
			2
			-48
			47.625
			ECU_ADDRESS 0xFFFF6D95
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mis_is_iga_dif1
			"Vxx_mis_is_iga_dif1"
			SBYTE
			F_0v375_p0_29
			2
			2
			-48
			47.625
			ECU_ADDRESS 0xFFFF6D96
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mis_is_iga_dif2
			"Vxx_mis_is_iga_dif2"
			SBYTE
			F_0v375_p0_29
			2
			2
			-48
			47.625
			ECU_ADDRESS 0xFFFF6D97
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mis_km_dly
			"Vxx_mis_km_dly"
			ULONG
			F_0v2777778_p0_359
			2
			2
			0
			1193046566
			ECU_ADDRESS 0xFFFF7E80
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mis_l_n_tdc_ctr
			"Vxx_mis_l_n_tdc_ctr"
			UWORD
			F_1_p0_53
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7E46
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mis_lih_mis_ctr
			"Vxx_mis_lih_mis_ctr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7DB7
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mis_lih_out_mis_ctr
			"Vxx_mis_lih_out_mis_ctr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7DB8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mis_lih_re_phs_ctr
			"Vxx_mis_lih_re_phs_ctr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7DB9
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mis_lih_tdc_ctr
			"Vxx_mis_lih_tdc_ctr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7DBA
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mis_n_frz
			"Vxx_mis_n_frz"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7E48
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mis_n_max_thd_1_2
			"Vxx_mis_n_max_thd_1_2"
			UWORD
			F_1_p0_14
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF88EC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mis_n_max_thd_1_n
			"Vxx_mis_n_max_thd_1_n"
			UWORD
			F_1_p0_14
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7E4A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mis_nr_cyl1
			"Vxx_mis_nr_cyl1"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7E4C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mis_nr_cyl2
			"Vxx_mis_nr_cyl2"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7E4E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mis_nr_cyl3
			"Vxx_mis_nr_cyl3"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7E50
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mis_nr_cyl4
			"Vxx_mis_nr_cyl4"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7E52
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mis_obd_diag_stop
			"Vxx_mis_obd_diag_stop"
			UBYTE
			F_8_p0_56
			2
			2
			0
			2040
			ECU_ADDRESS 0xFFFF7DBB
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mis_polu_mis_ctr
			"Vxx_mis_polu_mis_ctr"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7E54
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mis_polu_tdc_ctr
			"Vxx_mis_polu_tdc_ctr"
			UWORD
			F_1_p0_53
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7E56
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mis_polu_tot_ctr
			"Vxx_mis_polu_tot_ctr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7DBC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mis_polu_win_ctr
			"Vxx_mis_polu_win_ctr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7DBD
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mis_stab_tdc_ctr
			"Vxx_mis_stab_tdc_ctr"
			UBYTE
			F_1_p0_53
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7DBE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mis_stt
			"Vxx_mis_stt"
			UBYTE
			Vxx_mis_stt_conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF7DBF
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mis_tlz_cor
			"Vxx_mis_tlz_cor"
			SWORD
			F_0v1_p0_22
			2
			2
			-3276.8
			3276.7
			ECU_ADDRESS 0xFFFF7DCA
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mis_tlz_dif
			"Vxx_mis_tlz_dif"
			UWORD
			F_0v1_p0_22
			2
			2
			0
			6553.5
			ECU_ADDRESS 0xFFFF7E58
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mis_tlz_fil_mes
			"Vxx_mis_tlz_fil_mes"
			SWORD
			F_0v1_p0_22
			2
			2
			-3276.8
			3276.7
			ECU_ADDRESS 0xFFFF7DCC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mis_tlz_val_cor
			"Vxx_mis_tlz_val_cor"
			SWORD
			F_0v1_p0_22
			2
			2
			-3276.8
			3276.7
			ECU_ADDRESS 0xFFFF7DD6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mmv_n_dif_drv
			"Vxx_mmv_n_dif_drv"
			UWORD
			F_1_m8192_66
			2
			2
			-8192
			57343
			ECU_ADDRESS 0xFFFF82A0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_msr_tq_sp
			"Vxx_msr_tq_sp"
			UBYTE
			F_2_m100_36
			2
			2
			-100
			410
			ECU_ADDRESS 0xFFFF7341
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mux_ac_cge_dsb_agb
			"Vxx_mux_ac_cge_dsb_agb"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF73D2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mux_ac_mdf_req
			"Vxx_mux_ac_mdf_req"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF73E7
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mux_ac_pow
			"Vxx_mux_ac_pow"
			UBYTE
			F_25_p0_398
			2
			2
			0
			6375
			ECU_ADDRESS 0xFFFF7342
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mux_ac_req_lk
			"Vxx_mux_ac_req_lk"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF73E8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mux_acc_cmd_stt
			"Vxx_mux_acc_cmd_stt"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF81EB
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mux_acc_stt
			"Vxx_mux_acc_stt"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF73C6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mux_acc_swi
			"Vxx_mux_acc_swi"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF81EC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mux_agb_gear
			"Vxx_mux_agb_gear"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF73D3
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mux_agb_min_is_sp_req
			"Vxx_mux_agb_min_is_sp_req"
			UBYTE
			F_8_p0_210
			2
			2
			0
			2040
			ECU_ADDRESS 0xFFFF73D4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mux_agb_psn
			"Vxx_mux_agb_psn"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF73D5
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mux_agb_sta_stt
			"Vxx_mux_agb_sta_stt"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF73D6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mux_agb_tbn_n
			"Vxx_mux_agb_tbn_n"
			UBYTE
			F_16_p0_83
			2
			2
			0
			4080
			ECU_ADDRESS 0xFFFF73D7
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mux_agb_toil
			"Vxx_mux_agb_toil"
			UBYTE
			F_1_m40_40
			2
			2
			-40
			215
			ECU_ADDRESS 0xFFFF73D8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mux_agb_tq_red
			"Vxx_mux_agb_tq_red"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF73D9
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mux_agb_tq_sp
			"Vxx_mux_agb_tq_sp"
			UBYTE
			F_2_m100_36
			2
			2
			-100
			410
			ECU_ADDRESS 0xFFFF73DA
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mux_agb_tq_sp_lim
			"Vxx_mux_agb_tq_sp_lim"
			UBYTE
			F_2_m100_36
			2
			2
			-100
			410
			ECU_ADDRESS 0xFFFF73DB
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mux_alt_rat
			"Vxx_mux_alt_rat"
			UBYTE
			F_0v393701_p0_156
			2
			2
			0
			100.393755
			ECU_ADDRESS 0xFFFF73E9
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mux_aod_vs
			"Vxx_mux_aod_vs"
			UBYTE
			F_4_p0_344
			2
			2
			0
			1020
			ECU_ADDRESS 0xFFFF73B4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mux_asr_ctr
			"Vxx_mux_asr_ctr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF73B5
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mux_asr_msr_typ
			"Vxx_mux_asr_msr_typ"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF73B6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mux_clu_swi
			"Vxx_mux_clu_swi"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF81EF
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mux_cru_sl_stt
			"Vxx_mux_cru_sl_stt"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF81F0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mux_cru_sl_stt_ip
			"Vxx_mux_cru_sl_stt_ip"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF81F1
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mux_cru_sl_vs_sp
			"Vxx_mux_cru_sl_vs_sp"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF81F2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mux_csm_agb_tq
			"Vxx_mux_csm_agb_tq"
			UBYTE
			F_0v5_p0_28
			2
			2
			0
			127.5
			ECU_ADDRESS 0xFFFF73DC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mux_diag_min_lpg_lvl
			"Vxx_mux_diag_min_lpg_lvl"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF73FC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mux_dspl_vs
			"Vxx_mux_dspl_vs"
			UWORD
			F_0v01_p0_62
			2
			2
			0
			655.35
			ECU_ADDRESS 0xFFFF7416
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mux_esti_driv_tq
			"Vxx_mux_esti_driv_tq"
			UBYTE
			F_2_m100_36
			2
			2
			-100
			410
			ECU_ADDRESS 0xFFFF7343
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mux_esti_tqe
			"Vxx_mux_esti_tqe"
			UBYTE
			F_2_m100_36
			2
			2
			-100
			410
			ECU_ADDRESS 0xFFFF7344
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mux_fast_asr_tq_sp
			"Vxx_mux_fast_asr_tq_sp"
			UBYTE
			F_2_m100_36
			2
			2
			-100
			410
			ECU_ADDRESS 0xFFFF73B7
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mux_fast_tq_sp
			"Vxx_mux_fast_tq_sp"
			UWORD
			F_0v0078125_m100_35
			2
			2
			-100
			411.9921875
			ECU_ADDRESS 0xFFFF8416
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mux_gas_lvl_diag
			"Vxx_mux_gas_lvl_diag"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7414
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mux_is_n_sp
			"Vxx_mux_is_n_sp"
			UBYTE
			F_8_p0_210
			2
			2
			0
			2040
			ECU_ADDRESS 0xFFFF7345
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mux_km
			"Vxx_mux_km"
			ULONG
			F_1_p0_393
			2
			2
			0
			4294967295
			ECU_ADDRESS 0xFFFF7418
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mux_lpg_prs
			"Vxx_mux_lpg_prs"
			UWORD
			F_5_p0_230
			2
			2
			0
			327675
			ECU_ADDRESS 0xFFFF73FE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mux_lpg_temp
			"Vxx_mux_lpg_temp"
			UBYTE
			F_1_m40_40
			2
			2
			-40
			215
			ECU_ADDRESS 0xFFFF73FD
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mux_lpg_typ
			"Vxx_mux_lpg_typ"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7346
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mux_map
			"Vxx_mux_map"
			UWORD
			F_3v7_p103_37
			2
			2
			103
			242582.5
			ECU_ADDRESS 0xFFFF739C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mux_mdf_cmd
			"Vxx_mux_mdf_cmd"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF792C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mux_mil_agb_req
			"Vxx_mux_mil_agb_req"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF73DD
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mux_mil_req
			"Vxx_mux_mil_req"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7347
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mux_msr_tq_sp
			"Vxx_mux_msr_tq_sp"
			UBYTE
			F_2_m100_36
			2
			2
			-100
			410
			ECU_ADDRESS 0xFFFF73B8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mux_n
			"Vxx_mux_n"
			UWORD
			F_0v125_p0_30
			2
			2
			0
			8191.875
			ECU_ADDRESS 0xFFFF739E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mux_open_brk_swi
			"Vxx_mux_open_brk_swi"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF81F3
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mux_pdl_psn
			"Vxx_mux_pdl_psn"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF81F4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mux_pdl_psn1
			"Vxx_mux_pdl_psn1"
			UBYTE
			F_1_p0_9
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7348
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mux_ptc_cmd
			"Vxx_mux_ptc_cmd"
			UBYTE
			F_1_p0_9
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7349
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mux_ptc_max_pow_val
			"Vxx_mux_ptc_max_pow_val"
			UBYTE
			F_25_p0_398
			2
			2
			0
			6375
			ECU_ADDRESS 0xFFFF734A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mux_ptc_pow
			"Vxx_mux_ptc_pow"
			UBYTE
			F_100_p0_70
			2
			2
			0
			25500
			ECU_ADDRESS 0xFFFF7433
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mux_pwst_prs_dly
			"Vxx_mux_pwst_prs_dly"
			UBYTE
			F_16_p0_10
			2
			2
			0
			4080
			ECU_ADDRESS 0xFFFF77C4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mux_raw_whl_angl
			"Vxx_mux_raw_whl_angl"
			UWORD
			F_0v04376_p0_399
			2
			2
			0
			2867.8116
			ECU_ADDRESS 0xFFFF73BA
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mux_slow_asr_tq_sp
			"Vxx_mux_slow_asr_tq_sp"
			UBYTE
			F_2_m100_36
			2
			2
			-100
			410
			ECU_ADDRESS 0xFFFF73B9
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mux_slow_tq_sp
			"Vxx_mux_slow_tq_sp"
			UWORD
			F_0v0078125_m100_35
			2
			2
			-100
			411.9921875
			ECU_ADDRESS 0xFFFF8418
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mux_tco
			"Vxx_mux_tco"
			UBYTE
			F_1_m40_40
			2
			2
			-40
			215
			ECU_ADDRESS 0xFFFF734B
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mux_test_mil_dly
			"Vxx_mux_test_mil_dly"
			UBYTE
			F_0v128_p0_75
			2
			2
			0
			32.64
			ECU_ADDRESS 0xFFFF734C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mux_tia
			"Vxx_mux_tia"
			UBYTE
			F_1_m40_40
			2
			2
			-40
			215
			ECU_ADDRESS 0xFFFF734D
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mux_tot_tq_loss
			"Vxx_mux_tot_tq_loss"
			UBYTE
			F_2_m100_36
			2
			2
			-100
			410
			ECU_ADDRESS 0xFFFF734E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mux_tq_abst_agb
			"Vxx_mux_tq_abst_agb"
			UBYTE
			F_2_m100_36
			2
			2
			-100
			410
			ECU_ADDRESS 0xFFFF734F
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mux_tq_req_sf
			"Vxx_mux_tq_req_sf"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7350
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mux_vs
			"Vxx_mux_vs"
			UWORD
			F_0v01_p0_62
			2
			2
			0
			655.35
			ECU_ADDRESS 0xFFFF73BC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mv_ad_lsm_ctr
			"Vxx_mv_ad_lsm_ctr"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF8686
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mv_cl_fac_ad_dly
			"Vxx_mv_cl_fac_ad_dly"
			UBYTE
			F_128_p0_125
			2
			2
			0
			32640
			ECU_ADDRESS 0xFFFF7ADE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mv_cl_ti_fac
			"Vxx_mv_cl_ti_fac"
			UWORD
			F_0v001526_p0_42
			2
			2
			0
			100.00641
			ECU_ADDRESS 0xFFFF7B6E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mv_cl_ti_fac_cp_dly
			"Vxx_mv_cl_ti_fac_cp_dly"
			UBYTE
			F_64_p0_145
			2
			2
			0
			16320
			ECU_ADDRESS 0xFFFF80B4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mv_knk
			"Vxx_mv_knk"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF74EA
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mv_ti_ad_fac
			"Vxx_mv_ti_ad_fac"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8684
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mv_ti_ad_ofs
			"Vxx_mv_ti_ad_ofs"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8685
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mv_ti_ofs2_cor
			"Vxx_mv_ti_ofs2_cor"
			SWORD
			Id_0x00
			2
			2
			-32768
			32767
			ECU_ADDRESS 0xFFFF7B08
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mv_vb
			"Vxx_mv_vb"
			UWORD
			F_0v000125_p8_7
			2
			2
			8
			16.191875
			ECU_ADDRESS 0xFFFF8128
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mvac_dp
			"Vxx_mvac_dp"
			UWORD
			F_0v014453125_p0_391
			2
			2
			0
			947.1855469
			ECU_ADDRESS 0xFFFF7912
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mvac_dp_diag_dly
			"Vxx_mvac_dp_diag_dly"
			UBYTE
			F_32_p0_122
			2
			2
			0
			8160
			ECU_ADDRESS 0xFFFF7909
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mvac_dp_diag_sta_dly
			"Vxx_mvac_dp_diag_sta_dly"
			UBYTE
			F_32_p0_122
			2
			2
			0
			8160
			ECU_ADDRESS 0xFFFF790A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mvac_dp_inc_dly
			"Vxx_mvac_dp_inc_dly"
			UBYTE
			F_32_p0_122
			2
			2
			0
			8160
			ECU_ADDRESS 0xFFFF790B
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mvac_dp_prev
			"Vxx_mvac_dp_prev"
			UWORD
			F_0v014453125_p0_391
			2
			2
			0
			947.1855469
			ECU_ADDRESS 0xFFFF7914
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mvac_pump_aftr_run_t
			"Vxx_mvac_pump_aftr_run_t"
			UBYTE
			F_128_p0_125
			2
			2
			0
			32640
			ECU_ADDRESS 0xFFFF790C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mvac_pump_max_run_t
			"Vxx_mvac_pump_max_run_t"
			UBYTE
			F_128_p0_125
			2
			2
			0
			32640
			ECU_ADDRESS 0xFFFF790D
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mvac_pump_prot_dly
			"Vxx_mvac_pump_prot_dly"
			UWORD
			F_32_p0_122
			2
			2
			0
			2097120
			ECU_ADDRESS 0xFFFF7916
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mvac_pump_run_dly
			"Vxx_mvac_pump_run_dly"
			UWORD
			F_32_p0_122
			2
			2
			0
			2097120
			ECU_ADDRESS 0xFFFF7918
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mvac_pump_run_t
			"Vxx_mvac_pump_run_t"
			UBYTE
			F_128_p0_125
			2
			2
			0
			32640
			ECU_ADDRESS 0xFFFF88B7
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mvac_pump_run_t_tmp
			"Vxx_mvac_pump_run_t_tmp"
			UBYTE
			F_32_p0_122
			2
			2
			0
			8160
			ECU_ADDRESS 0xFFFF790E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_mvac_pump_run_tot_t
			"Vxx_mvac_pump_run_tot_t"
			UWORD
			F_32_p0_400
			2
			2
			0
			2097120
			ECU_ADDRESS 0xFFFF88B4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_n01
			"Vxx_n01"
			UWORD
			F_1_p0_14
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF812C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_n0125
			"Vxx_n0125"
			UWORD
			F_0v125_p0_30
			2
			2
			0
			8191.875
			ECU_ADDRESS 0xFFFF812E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_n01_avdyn_prec
			"Vxx_n01_avdyn_prec"
			UWORD
			F_1_p0_14
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF78D4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_n32
			"Vxx_n32"
			UBYTE
			F_32_p0_46
			2
			2
			0
			8160
			ECU_ADDRESS 0xFFFF80FC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_n_cylr_mem
			"Vxx_n_cylr_mem"
			UBYTE
			F_32_p0_46
			2
			2
			0
			8160
			ECU_ADDRESS 0xFFFF6BD7
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_n_drv_puls
			"Vxx_n_drv_puls"
			SBYTE
			F_19_p0_221
			2
			2
			-2432
			2413
			ECU_ADDRESS 0xFFFF8323
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_n_grd
			"Vxx_n_grd"
			SBYTE
			F_19_p0_95
			2
			2
			-2432
			2413
			ECU_ADDRESS 0xFFFF7FBD
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_n_kd_rich_fac
			"Vxx_n_kd_rich_fac"
			UWORD
			F_0v00260417_p0v667_32
			2
			2
			0.667
			171.331281
			ECU_ADDRESS 0xFFFF7B70
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_n_mmv
			"Vxx_n_mmv"
			UWORD
			F_1_p0_14
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF812A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_n_tkof_inrt
			"Vxx_n_tkof_inrt"
			UBYTE
			F_0v01_p0_223
			2
			2
			0
			2.55
			ECU_ADDRESS 0xFFFF77FB
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_n_upd_ok
			"Vxx_n_upd_ok"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF80E8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_no_deci_cylr_ctr
			"Vxx_no_deci_cylr_ctr"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF867E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_no_deci_id_is_ctr
			"Vxx_no_deci_id_is_ctr"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF8680
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_no_n_upd_emt_ctr
			"Vxx_no_n_upd_emt_ctr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7351
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_nom_eng_max_n
			"Vxx_nom_eng_max_n"
			UWORD
			F_1_p0_14
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF8130
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_nr_cyl
			"Vxx_nr_cyl"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7352
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_obd_data_a
			"Vxx_obd_data_a"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7615
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_obd_data_b
			"Vxx_obd_data_b"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7616
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_obd_data_c
			"Vxx_obd_data_c"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7617
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_obd_data_d
			"Vxx_obd_data_d"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7618
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_obd_eal
			"Vxx_obd_eal"
			UBYTE
			F_0v3921569_p0_340
			2
			2
			0
			100.0000095
			ECU_ADDRESS 0xFFFF7DC0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_obd_fail_code
			"Vxx_obd_fail_code"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF861C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_obd_mv_cl_ti_fac
			"Vxx_obd_mv_cl_ti_fac"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7B72
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ocl_max_dly
			"Vxx_ocl_max_dly"
			UBYTE
			F_4v096_p0_12
			2
			2
			0
			1044.48
			ECU_ADDRESS 0xFFFF7ADF
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_oil_temp_sta_t
			"Vxx_oil_temp_sta_t"
			UBYTE
			F_4v096_p0_12
			2
			2
			0
			1044.48
			ECU_ADDRESS 0xFFFF80FD
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ol_spg_pwm
			"Vxx_ol_spg_pwm"
			UBYTE
			F_0v390625_p0_4
			2
			2
			0
			99.609375
			ECU_ADDRESS 0xFFFF84B7
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ol_ti_fac
			"Vxx_ol_ti_fac"
			UWORD
			F_0v00260417_p0v667_32
			2
			2
			0.667
			171.331281
			ECU_ADDRESS 0xFFFF7B74
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_otl_iga
			"Vxx_otl_iga"
			UBYTE
			F_0v375_m23v625_6
			2
			2
			-23.625
			72
			ECU_ADDRESS 0xFFFF7A2E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_otl_iga_mv_tqi
			"Vxx_otl_iga_mv_tqi"
			UWORD
			F_8_p0_116
			2
			2
			0
			524280
			ECU_ADDRESS 0xFFFF841A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_otl_iga_tco_cor
			"Vxx_otl_iga_tco_cor"
			UBYTE
			F_0v375_p0_29
			2
			2
			0
			95.625
			ECU_ADDRESS 0xFFFF7A2F
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ovt_tqi_fac
			"Vxx_ovt_tqi_fac"
			UWORD
			F_0v0078125_p0_15
			2
			2
			0
			511.9921875
			ECU_ADDRESS 0xFFFF841C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pdl_mes_clc_fil_fac
			"Vxx_pdl_mes_clc_fil_fac"
			UBYTE
			F_0v3906_p0_133
			2
			2
			0
			99.603
			ECU_ADDRESS 0xFFFF81F5
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pdl_psn
			"Vxx_pdl_psn"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7353
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pdl_psn_fil_mes_v1
			"Vxx_pdl_psn_fil_mes_v1"
			UWORD
			F_0v09765_p0_3
			2
			2
			0
			6399.49275
			ECU_ADDRESS 0xFFFF775E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pdl_psn_fil_mes_v2_v1
			"Vxx_pdl_psn_fil_mes_v2_v1"
			UWORD
			F_0v09765_p0_3
			2
			2
			0
			6399.49275
			ECU_ADDRESS 0xFFFF7760
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pdl_psn_mes_v1
			"Vxx_pdl_psn_mes_v1"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7762
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pdl_psn_mes_v2
			"Vxx_pdl_psn_mes_v2"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7764
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pdl_psn_rat
			"Vxx_pdl_psn_rat"
			UBYTE
			F_0v390625_p0_4
			2
			2
			0
			99.609375
			ECU_ADDRESS 0xFFFF7FC2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pdl_psn_rat10
			"Vxx_pdl_psn_rat10"
			UWORD
			F_0v09765625_p0_71
			2
			2
			0
			6399.902344
			ECU_ADDRESS 0xFFFF801A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pdl_psn_rat_acq
			"Vxx_pdl_psn_rat_acq"
			UBYTE
			F_0v390625_p0_4
			2
			2
			0
			99.609375
			ECU_ADDRESS 0xFFFF76B2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pdl_psn_rat_acq10
			"Vxx_pdl_psn_rat_acq10"
			UWORD
			F_0v09765625_p0_71
			2
			2
			0
			6399.902344
			ECU_ADDRESS 0xFFFF7766
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pdl_psn_rat_acq10_temp
			"Vxx_pdl_psn_rat_acq10_temp"
			UWORD
			F_0v09765625_p0_71
			2
			2
			0
			6399.902344
			ECU_ADDRESS 0xFFFF7768
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pdl_psn_rat_acq10_v1
			"Vxx_pdl_psn_rat_acq10_v1"
			UWORD
			F_0v09765625_p0_71
			2
			2
			0
			6399.902344
			ECU_ADDRESS 0xFFFF776A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pdl_psn_rat_acq10_v2
			"Vxx_pdl_psn_rat_acq10_v2"
			UWORD
			F_0v09765625_p0_71
			2
			2
			0
			6399.902344
			ECU_ADDRESS 0xFFFF776C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pdl_psn_rat_raw_1
			"Vxx_pdl_psn_rat_raw_1"
			UWORD
			F_0v09765625_p0_71
			2
			2
			0
			6399.902344
			ECU_ADDRESS 0xFFFF776E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pdl_psn_rat_raw_2
			"Vxx_pdl_psn_rat_raw_2"
			UWORD
			F_0v09765625_p0_71
			2
			2
			0
			6399.902344
			ECU_ADDRESS 0xFFFF7770
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pdl_rel_psn
			"Vxx_pdl_rel_psn"
			UBYTE
			F_0v390625_p0_4
			2
			2
			0
			99.609375
			ECU_ADDRESS 0xFFFF7FC3
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pdl_rel_psn10
			"Vxx_pdl_rel_psn10"
			UWORD
			F_0v09765625_p0_71
			2
			2
			0
			6399.902344
			ECU_ADDRESS 0xFFFF801C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pdl_sens_shift_diag_dly
			"Vxx_pdl_sens_shift_diag_dly"
			UBYTE
			F_16_p0_10
			2
			2
			0
			4080
			ECU_ADDRESS 0xFFFF76B3
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_per_drv
			"Vxx_per_drv"
			SWORD
			Id_0x00
			2
			2
			-32768
			32767
			ECU_ADDRESS 0xFFFF7FC6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_perf_ac_dsb_dly
			"Vxx_perf_ac_dsb_dly"
			UBYTE
			F_128_p0_125
			2
			2
			0
			32640
			ECU_ADDRESS 0xFFFF7460
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_ac_prs
			"Vxx_pfctr_ac_prs"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF86DE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_ac_rcpt
			"Vxx_pfctr_ac_rcpt"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF86DF
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_acr_oc
			"Vxx_pfctr_acr_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF86E0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_acr_scg
			"Vxx_pfctr_acr_scg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF86E1
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_acr_vb_sc
			"Vxx_pfctr_acr_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF86E2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_actr_rly
			"Vxx_pfctr_actr_rly"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF86E3
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_actr_rly_cut
			"Vxx_pfctr_actr_rly_cut"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF86E4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_agb_conv_stt
			"Vxx_pfctr_agb_conv_stt"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF86E5
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_agb_gear
			"Vxx_pfctr_agb_gear"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF86E6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_agb_rcpt
			"Vxx_pfctr_agb_rcpt"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF86E7
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_agb_tq_nok
			"Vxx_pfctr_agb_tq_nok"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF86E8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_air
			"Vxx_pfctr_air"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF86E9
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_alt_ecu
			"Vxx_pfctr_alt_ecu"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF86EA
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_alt_load_in
			"Vxx_pfctr_alt_load_in"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF86EC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_alt_mux
			"Vxx_pfctr_alt_mux"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF86EB
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_bkup_mem
			"Vxx_pfctr_bkup_mem"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF86ED
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_checksum
			"Vxx_pfctr_checksum"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF86EE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_clu
			"Vxx_pfctr_clu"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF86EF
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_cp_oc
			"Vxx_pfctr_cp_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF86F0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_cp_scg
			"Vxx_pfctr_cp_scg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF86F1
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_cp_vb_sc
			"Vxx_pfctr_cp_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF86F2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_crk
			"Vxx_pfctr_crk"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF86F3
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_crk_nr
			"Vxx_pfctr_crk_nr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF86F4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_cru_brk_cnt1
			"Vxx_pfctr_cru_brk_cnt1"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF86F5
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_cru_brk_cnt2
			"Vxx_pfctr_cru_brk_cnt2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF86F6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_cru_on_off_chr
			"Vxx_pfctr_cru_on_off_chr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF86F7
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_cru_whl_cmd
			"Vxx_pfctr_cru_whl_cmd"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF86F8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_el_wind_rcpt
			"Vxx_pfctr_el_wind_rcpt"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF86F9
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_eng_temp_oc
			"Vxx_pfctr_eng_temp_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF86FA
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_eng_temp_scg
			"Vxx_pfctr_eng_temp_scg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF86FB
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_eng_temp_vb_sc
			"Vxx_pfctr_eng_temp_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF86FC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_eng_whl
			"Vxx_pfctr_eng_whl"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF86FD
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_fsys
			"Vxx_pfctr_fsys"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF86FE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_fsys_lpg
			"Vxx_pfctr_fsys_lpg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF86FF
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_gas_pump_oc
			"Vxx_pfctr_gas_pump_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8700
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_gas_pump_scg
			"Vxx_pfctr_gas_pump_scg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8701
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_gas_pump_vb_sc
			"Vxx_pfctr_gas_pump_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8702
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_igc_1_oc
			"Vxx_pfctr_igc_1_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8703
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_igc_1_vb_sc
			"Vxx_pfctr_igc_1_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8704
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_igc_2_oc
			"Vxx_pfctr_igc_2_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8705
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_igc_2_vb_sc
			"Vxx_pfctr_igc_2_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8706
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_igc_3_oc
			"Vxx_pfctr_igc_3_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8707
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_igc_3_vb_sc
			"Vxx_pfctr_igc_3_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8708
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_igc_4_oc
			"Vxx_pfctr_igc_4_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8709
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_igc_4_vb_sc
			"Vxx_pfctr_igc_4_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF870A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_inj1_oc
			"Vxx_pfctr_inj1_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF870B
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_inj1_scg
			"Vxx_pfctr_inj1_scg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF870C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_inj1_vb_sc
			"Vxx_pfctr_inj1_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF870D
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_inj2_oc
			"Vxx_pfctr_inj2_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF870E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_inj2_scg
			"Vxx_pfctr_inj2_scg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF870F
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_inj2_vb_sc
			"Vxx_pfctr_inj2_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8710
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_inj3_oc
			"Vxx_pfctr_inj3_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8711
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_inj3_scg
			"Vxx_pfctr_inj3_scg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8712
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_inj3_vb_sc
			"Vxx_pfctr_inj3_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8713
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_inj4_oc
			"Vxx_pfctr_inj4_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8714
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_inj4_scg
			"Vxx_pfctr_inj4_scg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8715
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_inj4_vb_sc
			"Vxx_pfctr_inj4_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8716
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_inj_ecu
			"Vxx_pfctr_inj_ecu"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8717
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_ip_inj_cnt
			"Vxx_pfctr_ip_inj_cnt"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8718
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_knk
			"Vxx_pfctr_knk"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8719
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_lbdw_hot_oc
			"Vxx_pfctr_lbdw_hot_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF871D
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_lbdw_hot_scg
			"Vxx_pfctr_lbdw_hot_scg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF871E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_lbdw_hot_vb_sc
			"Vxx_pfctr_lbdw_hot_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF871F
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_lbdw_oc
			"Vxx_pfctr_lbdw_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF871A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_lbdw_pump_crt
			"Vxx_pfctr_lbdw_pump_crt"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8720
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_lbdw_scg
			"Vxx_pfctr_lbdw_scg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF871B
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_lbdw_vb_sc
			"Vxx_pfctr_lbdw_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF871C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_lbup_hot_oc
			"Vxx_pfctr_lbup_hot_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8724
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_lbup_hot_scg
			"Vxx_pfctr_lbup_hot_scg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8725
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_lbup_hot_vb_sc
			"Vxx_pfctr_lbup_hot_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8726
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_lbup_oc
			"Vxx_pfctr_lbup_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8721
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_lbup_pump_crt
			"Vxx_pfctr_lbup_pump_crt"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8727
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_lbup_scg
			"Vxx_pfctr_lbup_scg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8722
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_lbup_vb_sc
			"Vxx_pfctr_lbup_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8723
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_lpg_rcpt
			"Vxx_pfctr_lpg_rcpt"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8728
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_map
			"Vxx_pfctr_map"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8729
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_map_chr
			"Vxx_pfctr_map_chr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF872A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_mastervac_cc
			"Vxx_pfctr_mastervac_cc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF872B
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_mastervac_oc
			"Vxx_pfctr_mastervac_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF872C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_mcut_sens1
			"Vxx_pfctr_mcut_sens1"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF872D
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_mdf1_oc
			"Vxx_pfctr_mdf1_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF872E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_mdf1_scg
			"Vxx_pfctr_mdf1_scg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF872F
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_mdf1_vb_sc
			"Vxx_pfctr_mdf1_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8730
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_mdf2_oc
			"Vxx_pfctr_mdf2_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8731
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_mdf2_scg
			"Vxx_pfctr_mdf2_scg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8732
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_mdf2_vb_sc
			"Vxx_pfctr_mdf2_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8733
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_min_gas_lvl
			"Vxx_pfctr_min_gas_lvl"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8734
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_min_lpg_lvl
			"Vxx_pfctr_min_lpg_lvl"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8735
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_mis_cata
			"Vxx_pfctr_mis_cata"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8736
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_mis_cata_1
			"Vxx_pfctr_mis_cata_1"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8737
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_mis_cata_1_lpg
			"Vxx_pfctr_mis_cata_1_lpg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8738
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_mis_cata_2
			"Vxx_pfctr_mis_cata_2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8739
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_mis_cata_2_lpg
			"Vxx_pfctr_mis_cata_2_lpg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF873A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_mis_cata_3
			"Vxx_pfctr_mis_cata_3"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF873B
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_mis_cata_3_lpg
			"Vxx_pfctr_mis_cata_3_lpg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF873C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_mis_cata_4
			"Vxx_pfctr_mis_cata_4"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF873D
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_mis_cata_4_lpg
			"Vxx_pfctr_mis_cata_4_lpg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF873E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_mis_cata_gas
			"Vxx_pfctr_mis_cata_gas"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF873F
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_mis_cata_lpg
			"Vxx_pfctr_mis_cata_lpg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8740
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_mis_fast
			"Vxx_pfctr_mis_fast"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8741
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_mis_lih
			"Vxx_pfctr_mis_lih"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8742
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_mis_polu
			"Vxx_pfctr_mis_polu"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8743
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_mis_polu_1
			"Vxx_pfctr_mis_polu_1"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8744
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_mis_polu_1_lpg
			"Vxx_pfctr_mis_polu_1_lpg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8745
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_mis_polu_2
			"Vxx_pfctr_mis_polu_2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8746
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_mis_polu_2_lpg
			"Vxx_pfctr_mis_polu_2_lpg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8747
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_mis_polu_3
			"Vxx_pfctr_mis_polu_3"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8748
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_mis_polu_3_lpg
			"Vxx_pfctr_mis_polu_3_lpg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8749
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_mis_polu_4
			"Vxx_pfctr_mis_polu_4"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF874A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_mis_polu_4_lpg
			"Vxx_pfctr_mis_polu_4_lpg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF874B
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_mis_polu_gas
			"Vxx_pfctr_mis_polu_gas"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF874C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_mis_polu_lpg
			"Vxx_pfctr_mis_polu_lpg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF874D
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_mvac_pump_oc
			"Vxx_pfctr_mvac_pump_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF874E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_mvac_pump_scg
			"Vxx_pfctr_mvac_pump_scg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF874F
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_mvac_pump_vb_sc
			"Vxx_pfctr_mvac_pump_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8750
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_mvac_sys
			"Vxx_pfctr_mvac_sys"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8751
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_obd_cata
			"Vxx_pfctr_obd_cata"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8752
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_obd_lamb
			"Vxx_pfctr_obd_lamb"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8753
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_obd_sa
			"Vxx_pfctr_obd_sa"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8754
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_oil_cc
			"Vxx_pfctr_oil_cc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8755
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_oil_co
			"Vxx_pfctr_oil_co"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8756
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_pdl_sens1_oc
			"Vxx_pfctr_pdl_sens1_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8757
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_pdl_sens1_vb_sc
			"Vxx_pfctr_pdl_sens1_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8758
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_pdl_sens2_oc
			"Vxx_pfctr_pdl_sens2_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8759
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_pdl_sens2_vb_sc
			"Vxx_pfctr_pdl_sens2_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF875A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_pdl_sens_chr
			"Vxx_pfctr_pdl_sens_chr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF875B
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_pmh_cc
			"Vxx_pfctr_pmh_cc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF875C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_pmh_co
			"Vxx_pfctr_pmh_co"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF875D
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_pow_lbdw
			"Vxx_pfctr_pow_lbdw"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF875E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_pow_lbup
			"Vxx_pfctr_pow_lbup"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF875F
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_ptc
			"Vxx_pfctr_ptc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8760
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_ptc_rov_oc
			"Vxx_pfctr_ptc_rov_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8761
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_ptc_rov_scg
			"Vxx_pfctr_ptc_rov_scg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8762
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_ptc_rov_vb_sc
			"Vxx_pfctr_ptc_rov_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8763
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_pws_1
			"Vxx_pfctr_pws_1"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8764
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_pws_2
			"Vxx_pfctr_pws_2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8765
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_pws_pdl2
			"Vxx_pfctr_pws_pdl2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8766
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_pws_thr_pdl1
			"Vxx_pfctr_pws_thr_pdl1"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8767
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_rams_map_tq
			"Vxx_pfctr_rams_map_tq"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8768
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_rams_pdl
			"Vxx_pfctr_rams_pdl"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF876B
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_rams_tq_ctl
			"Vxx_pfctr_rams_tq_ctl"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8769
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_rams_tq_req
			"Vxx_pfctr_rams_tq_req"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF876A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_reserve_3_oc
			"Vxx_pfctr_reserve_3_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF876C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_reserve_3_scg
			"Vxx_pfctr_reserve_3_scg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF876D
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_reserve_3_vb_sc
			"Vxx_pfctr_reserve_3_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF876E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_rmc_algopp
			"Vxx_pfctr_rmc_algopp"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF876F
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_rmc_clockpp
			"Vxx_pfctr_rmc_clockpp"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8770
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_rmc_comspipp
			"Vxx_pfctr_rmc_comspipp"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8771
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_rmc_inhwp
			"Vxx_pfctr_rmc_inhwp"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8772
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_rmc_monitpp
			"Vxx_pfctr_rmc_monitpp"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8773
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_rmc_papmpp
			"Vxx_pfctr_rmc_papmpp"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8774
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_rmc_pedmpp
			"Vxx_pfctr_rmc_pedmpp"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8775
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_rmc_timeoutpp
			"Vxx_pfctr_rmc_timeoutpp"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8776
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_sa_ev_oc
			"Vxx_pfctr_sa_ev_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF877A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_sa_ev_scg
			"Vxx_pfctr_sa_ev_scg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF877B
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_sa_ev_vb_sc
			"Vxx_pfctr_sa_ev_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF877C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_sa_oc
			"Vxx_pfctr_sa_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8777
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_sa_scg
			"Vxx_pfctr_sa_scg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8778
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_sa_vb_sc
			"Vxx_pfctr_sa_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8779
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_spg
			"Vxx_pfctr_spg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF877D
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_spg_sys
			"Vxx_pfctr_spg_sys"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF877E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_spi_cc
			"Vxx_pfctr_spi_cc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF877F
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_svkl_chk_springs
			"Vxx_pfctr_svkl_chk_springs"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8780
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_svkl_lih
			"Vxx_pfctr_svkl_lih"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8781
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_svkl_oc
			"Vxx_pfctr_svkl_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8782
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_svkl_psn
			"Vxx_pfctr_svkl_psn"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8783
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_svkl_sge
			"Vxx_pfctr_svkl_sge"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8784
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_svkl_trt_srch
			"Vxx_pfctr_svkl_trt_srch"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8785
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_swlk_mem
			"Vxx_pfctr_swlk_mem"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8786
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_tco_acq
			"Vxx_pfctr_tco_acq"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8787
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_tco_chr
			"Vxx_pfctr_tco_chr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8788
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_thpl_oc
			"Vxx_pfctr_thpl_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8789
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_thpl_scg
			"Vxx_pfctr_thpl_scg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF878A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_thpl_vb_sc
			"Vxx_pfctr_thpl_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF878B
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_thr_cmd_cpt
			"Vxx_pfctr_thr_cmd_cpt"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8791
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_thr_cmd_vb_sc
			"Vxx_pfctr_thr_cmd_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8792
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_thr_sens1_oc
			"Vxx_pfctr_thr_sens1_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF878C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_thr_sens1_vb_sc
			"Vxx_pfctr_thr_sens1_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF878D
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_thr_sens2_scg
			"Vxx_pfctr_thr_sens2_scg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF878E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_thr_sens2_vb_sc
			"Vxx_pfctr_thr_sens2_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF878F
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_thr_sens_chr
			"Vxx_pfctr_thr_sens_chr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8790
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_tia_high
			"Vxx_pfctr_tia_high"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8793
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_tia_low
			"Vxx_pfctr_tia_low"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8794
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_tjy_ctl
			"Vxx_pfctr_tjy_ctl"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8795
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_tlz_ad_b
			"Vxx_pfctr_tlz_ad_b"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8796
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_vb_high
			"Vxx_pfctr_vb_high"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8797
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_vb_low
			"Vxx_pfctr_vb_low"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8798
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_vs_eal
			"Vxx_pfctr_vs_eal"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8799
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_vs_mux
			"Vxx_pfctr_vs_mux"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF879A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_vs_parasite
			"Vxx_pfctr_vs_parasite"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF879B
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_vta_intake_pmh
			"Vxx_pfctr_vta_intake_pmh"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF879C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_vta_intake_shift
			"Vxx_pfctr_vta_intake_shift"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF879D
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_vvt_int_ev_oc
			"Vxx_pfctr_vvt_int_ev_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF879F
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_vvt_int_ev_scg
			"Vxx_pfctr_vvt_int_ev_scg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87A0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_vvt_int_ev_vb_sc
			"Vxx_pfctr_vvt_int_ev_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87A1
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_vvt_int_old_off
			"Vxx_pfctr_vvt_int_old_off"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF879E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_vvt_intake_blk
			"Vxx_pfctr_vvt_intake_blk"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87A2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_vvt_intake_bound
			"Vxx_pfctr_vvt_intake_bound"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87A3
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_vvt_intake_dyn
			"Vxx_pfctr_vvt_intake_dyn"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87A4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_vvt_intake_int
			"Vxx_pfctr_vvt_intake_int"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87A5
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_vvtc_toth_3
			"Vxx_pfctr_vvtc_toth_3"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87A6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_wat_temp_high
			"Vxx_pfctr_wat_temp_high"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87A7
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_wat_temp_low
			"Vxx_pfctr_wat_temp_low"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87A8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_wgc_oc
			"Vxx_pfctr_wgc_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87A9
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_wgc_scg
			"Vxx_pfctr_wgc_scg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87AA
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_wgc_vb_sc
			"Vxx_pfctr_wgc_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87AB
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_wpmp_oc
			"Vxx_pfctr_wpmp_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87AC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_wpmp_scg
			"Vxx_pfctr_wpmp_scg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87AD
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pfctr_wpmp_vb_sc
			"Vxx_pfctr_wpmp_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87AE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pinj_t
			"Vxx_pinj_t"
			UBYTE
			F_4_p0_128
			2
			2
			0
			1020
			ECU_ADDRESS 0xFFFF7AE0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pred_air_fac
			"Vxx_pred_air_fac"
			UWORD
			F_1_p0_9
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7B76
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pred_air_wht
			"Vxx_pred_air_wht"
			UWORD
			F_6v75_p0_401
			2
			2
			0
			442361.25
			ECU_ADDRESS 0xFFFF7B78
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pred_eal
			"Vxx_pred_eal"
			UWORD
			F_0v0061035156_p0_23
			2
			2
			0
			399.9938965
			ECU_ADDRESS 0xFFFF841E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pred_map
			"Vxx_pred_map"
			UWORD
			F_3v7_p103_37
			2
			2
			103
			242582.5
			ECU_ADDRESS 0xFFFF803E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pred_map_dif
			"Vxx_pred_map_dif"
			SWORD
			F_0v47_p0_270
			2
			2
			-15400.96
			15400.49
			ECU_ADDRESS 0xFFFF8028
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pred_map_efv_thr_ar
			"Vxx_pred_map_efv_thr_ar"
			UWORD
			F_0v0596046_p0_76
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF801E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pred_map_mdl_eng_maf
			"Vxx_pred_map_mdl_eng_maf"
			UWORD
			F_0v119209_p0_402
			2
			2
			0
			7812.361815
			ECU_ADDRESS 0xFFFF8040
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pred_map_mdl_thr_maf
			"Vxx_pred_map_mdl_thr_maf"
			UWORD
			F_0v119209_p0_402
			2
			2
			0
			7812.361815
			ECU_ADDRESS 0xFFFF8042
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pred_map_psi_fac
			"Vxx_pred_map_psi_fac"
			UWORD
			F_0v95367_p0_403
			2
			2
			0
			62498.76345
			ECU_ADDRESS 0xFFFF8044
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pred_map_psi_fac_ofs
			"Vxx_pred_map_psi_fac_ofs"
			UWORD
			F_15v2587890625_p0_68
			2
			2
			0
			999984.7412
			ECU_ADDRESS 0xFFFF8046
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pred_map_psi_fac_slop
			"Vxx_pred_map_psi_fac_slop"
			UWORD
			F_m15v2587890625_p0_82
			2
			2
			-999984.7412
			0
			ECU_ADDRESS 0xFFFF8048
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pred_map_thr_maf_fac
			"Vxx_pred_map_thr_maf_fac"
			UWORD
			F_0v0625_p0_404
			2
			2
			0
			4095.9375
			ECU_ADDRESS 0xFFFF804A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pred_val_fil_fac
			"Vxx_pred_val_fil_fac"
			UBYTE
			F_0v00390625_p0_90
			2
			2
			0
			0.99609375
			ECU_ADDRESS 0xFFFF8343
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_prev2_n
			"Vxx_prev2_n"
			UWORD
			F_1_p0_14
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF8134
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_prev4_n
			"Vxx_prev4_n"
			UWORD
			F_1_p0_14
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF8138
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_prev_tkof_n_sp
			"Vxx_prev_tkof_n_sp"
			UWORD
			F_1_p0_405
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7812
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_prev_tq_pump_maf
			"Vxx_prev_tq_pump_maf"
			UWORD
			F_0v0152588_p0_362
			2
			2
			0
			999.985458
			ECU_ADDRESS 0xFFFF8420
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_prev_whl_angl
			"Vxx_prev_whl_angl"
			SWORD
			F_0v04376_p0_180
			2
			2
			-1433.92768
			1433.88392
			ECU_ADDRESS 0xFFFF77CA
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_prmt_n_ac_dsb_dly
			"Vxx_prmt_n_ac_dsb_dly"
			UBYTE
			F_128_p0_125
			2
			2
			0
			32640
			ECU_ADDRESS 0xFFFF7461
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_prot_eng_tq_lim
			"Vxx_prot_eng_tq_lim"
			UBYTE
			F_2_m100_36
			2
			2
			-100
			410
			ECU_ADDRESS 0xFFFF8344
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_prs_cylr_mem
			"Vxx_prs_cylr_mem"
			UWORD
			F_3v7_p103_37
			2
			2
			103
			242582.5
			ECU_ADDRESS 0xFFFF6BE0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_prs_dif
			"Vxx_prs_dif"
			UWORD
			F_3v7_m2841v6_44
			2
			2
			-2841.6
			239637.9
			ECU_ADDRESS 0xFFFF7B7A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_prs_dif_ti_cor
			"Vxx_prs_dif_ti_cor"
			SWORD
			F_0v0031_p0_406
			2
			2
			-101.5808
			101.5777
			ECU_ADDRESS 0xFFFF7B0A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_prs_trs_cor_iga
			"Vxx_prs_trs_cor_iga"
			UBYTE
			F_0v375_p0_29
			2
			2
			0
			95.625
			ECU_ADDRESS 0xFFFF6DC3
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_psi_fac_cor
			"Vxx_psi_fac_cor"
			UWORD
			F_0v25_p0_69
			2
			2
			0
			16383.75
			ECU_ADDRESS 0xFFFF804C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ptc_is_cor_appl_dly
			"Vxx_ptc_is_cor_appl_dly"
			UBYTE
			F_16_p0_10
			2
			2
			0
			4080
			ECU_ADDRESS 0xFFFF79CE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ptc_is_cor_appl_dly1
			"Vxx_ptc_is_cor_appl_dly1"
			UBYTE
			F_16_p0_10
			2
			2
			0
			4080
			ECU_ADDRESS 0xFFFF79CF
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ptc_max_pow
			"Vxx_ptc_max_pow"
			UBYTE
			F_20_p0_63
			2
			2
			0
			5100
			ECU_ADDRESS 0xFFFF808C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ptc_max_pow_1
			"Vxx_ptc_max_pow_1"
			UWORD
			F_1_p0_231
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF8094
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ptc_min_is_n
			"Vxx_ptc_min_is_n"
			UBYTE
			F_16_p0_83
			2
			2
			0
			4080
			ECU_ADDRESS 0xFFFF80FE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ptc_pow
			"Vxx_ptc_pow"
			UBYTE
			F_100_p0_70
			2
			2
			0
			25500
			ECU_ADDRESS 0xFFFF7354
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ptc_pow_i_1
			"Vxx_ptc_pow_i_1"
			UBYTE
			F_100_p0_70
			2
			2
			0
			25500
			ECU_ADDRESS 0xFFFF79D0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pump_max_maf
			"Vxx_pump_max_maf"
			UWORD
			F_0v000015287_p0_407
			2
			2
			0
			1.001833545
			ECU_ADDRESS 0xFFFF84E6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pump_mvac_dp_inc
			"Vxx_pump_mvac_dp_inc"
			UWORD
			F_0v014453125_p0_391
			2
			2
			0
			947.1855469
			ECU_ADDRESS 0xFFFF791A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pump_tq_loss
			"Vxx_pump_tq_loss"
			SWORD
			F_0v0078125_p0_15
			2
			2
			-256
			255.9921875
			ECU_ADDRESS 0xFFFF8362
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pwl_dly
			"Vxx_pwl_dly"
			UWORD
			F_0v064_p0_283
			2
			2
			0
			4194.24
			ECU_ADDRESS 0xFFFF8156
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pwst_min_is_n
			"Vxx_pwst_min_is_n"
			UBYTE
			F_16_p0_83
			2
			2
			0
			4080
			ECU_ADDRESS 0xFFFF80FF
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pwst_min_is_n_iga_cor
			"Vxx_pwst_min_is_n_iga_cor"
			UBYTE
			F_0v375_p0_29
			2
			2
			0
			95.625
			ECU_ADDRESS 0xFFFF6DC4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pwst_off_is_cor_dly
			"Vxx_pwst_off_is_cor_dly"
			UBYTE
			F_16_p0_10
			2
			2
			0
			4080
			ECU_ADDRESS 0xFFFF79D1
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_pwst_on_is_cor_dly
			"Vxx_pwst_on_is_cor_dly"
			UBYTE
			F_16_p0_10
			2
			2
			0
			4080
			ECU_ADDRESS 0xFFFF79D2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_rams_ac_pow
			"Vxx_rams_ac_pow"
			UBYTE
			F_20_p0_63
			2
			2
			0
			5100
			ECU_ADDRESS 0xFFFF8345
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_rams_aj_driv_tqe_sp
			"Vxx_rams_aj_driv_tqe_sp"
			UWORD
			F_0v0078125_m100_35
			2
			2
			-100
			411.9921875
			ECU_ADDRESS 0xFFFF8422
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_rams_csm_pow_loss
			"Vxx_rams_csm_pow_loss"
			UBYTE
			F_20_p0_63
			2
			2
			0
			5100
			ECU_ADDRESS 0xFFFF8346
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_rams_csm_tq_loss
			"Vxx_rams_csm_tq_loss"
			UWORD
			F_0v0078125_p0_15
			2
			2
			0
			511.9921875
			ECU_ADDRESS 0xFFFF8424
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_rams_ena_diag_t_1
			"Vxx_rams_ena_diag_t_1"
			UWORD
			F_8_p0_56
			2
			2
			0
			524280
			ECU_ADDRESS 0xFFFF8426
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_rams_ena_diag_t_2
			"Vxx_rams_ena_diag_t_2"
			UWORD
			F_8_p0_56
			2
			2
			0
			524280
			ECU_ADDRESS 0xFFFF8428
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_rams_ena_diag_t_3
			"Vxx_rams_ena_diag_t_3"
			UWORD
			F_8_p0_56
			2
			2
			0
			524280
			ECU_ADDRESS 0xFFFF842A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_rams_esti_tq_fail_ctr
			"Vxx_rams_esti_tq_fail_ctr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8347
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_rams_esti_tq_fail_ctr_max
			"Vxx_rams_esti_tq_fail_ctr_max"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7DC1
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_rams_esti_tqe
			"Vxx_rams_esti_tqe"
			UWORD
			F_0v0078125_m100_35
			2
			2
			-100
			411.9921875
			ECU_ADDRESS 0xFFFF842C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_rams_esti_tqe_err
			"Vxx_rams_esti_tqe_err"
			UWORD
			F_0v0078125_m100_35
			2
			2
			-100
			411.9921875
			ECU_ADDRESS 0xFFFF842E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_rams_esti_tqe_err_max
			"Vxx_rams_esti_tqe_err_max"
			UWORD
			F_0v0078125_m100_35
			2
			2
			-100
			411.9921875
			ECU_ADDRESS 0xFFFF7E5A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_rams_esti_tqe_err_min
			"Vxx_rams_esti_tqe_err_min"
			UWORD
			F_0v0078125_m100_35
			2
			2
			-100
			411.9921875
			ECU_ADDRESS 0xFFFF7E5C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_rams_fil_max_tqi
			"Vxx_rams_fil_max_tqi"
			UWORD
			F_0v0078125_m100_35
			2
			2
			-100
			411.9921875
			ECU_ADDRESS 0xFFFF8430
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_rams_fil_thr_ar
			"Vxx_rams_fil_thr_ar"
			UWORD
			F_0v0596_p0_108
			2
			2
			0
			3905.886
			ECU_ADDRESS 0xFFFF8432
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_rams_fmt_pdl_psn_rat
			"Vxx_rams_fmt_pdl_psn_rat"
			UWORD
			F_0v0015258_p0_48
			2
			2
			0
			99.993303
			ECU_ADDRESS 0xFFFF8434
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_rams_frn_tq_loss
			"Vxx_rams_frn_tq_loss"
			UWORD
			F_0v0078125_p0_15
			2
			2
			0
			511.9921875
			ECU_ADDRESS 0xFFFF8436
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_rams_lim_thr_ar
			"Vxx_rams_lim_thr_ar"
			UWORD
			F_0v0596_p0_108
			2
			2
			0
			3905.886
			ECU_ADDRESS 0xFFFF8438
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_rams_mask_t_tq_req
			"Vxx_rams_mask_t_tq_req"
			UWORD
			F_0v0078125_m100_35
			2
			2
			-100
			411.9921875
			ECU_ADDRESS 0xFFFF843A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_rams_max_avl_tqe
			"Vxx_rams_max_avl_tqe"
			UWORD
			F_0v0078125_m100_35
			2
			2
			-100
			411.9921875
			ECU_ADDRESS 0xFFFF843C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_rams_max_avl_tqe_prev
			"Vxx_rams_max_avl_tqe_prev"
			UWORD
			F_0v0078125_m100_35
			2
			2
			-100
			411.9921875
			ECU_ADDRESS 0xFFFF843E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_rams_max_tqi
			"Vxx_rams_max_tqi"
			UWORD
			F_0v0078125_m100_35
			2
			2
			-100
			411.9921875
			ECU_ADDRESS 0xFFFF8440
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_rams_min_avl_tqe
			"Vxx_rams_min_avl_tqe"
			UWORD
			F_0v0078125_m100_35
			2
			2
			-100
			411.9921875
			ECU_ADDRESS 0xFFFF8442
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_rams_ovt_dly_counter
			"Vxx_rams_ovt_dly_counter"
			UBYTE
			F_128_p0_125
			2
			2
			0
			32640
			ECU_ADDRESS 0xFFFF8348
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_rams_pdl_dif
			"Vxx_rams_pdl_dif"
			UBYTE
			F_0v390625_p0_4
			2
			2
			0
			99.609375
			ECU_ADDRESS 0xFFFF8277
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_rams_pdl_dif_max
			"Vxx_rams_pdl_dif_max"
			UBYTE
			F_0v390625_p0_4
			2
			2
			0
			99.609375
			ECU_ADDRESS 0xFFFF7DC2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_rams_pdl_dif_min
			"Vxx_rams_pdl_dif_min"
			UBYTE
			F_0v390625_p0_4
			2
			2
			0
			99.609375
			ECU_ADDRESS 0xFFFF7DC3
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_rams_pdl_psn_rat
			"Vxx_rams_pdl_psn_rat"
			UWORD
			F_0v09765625_p0_71
			2
			2
			0
			6399.902344
			ECU_ADDRESS 0xFFFF8444
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_rams_pump_tq_loss
			"Vxx_rams_pump_tq_loss"
			UWORD
			F_0v0078125_m256_408
			2
			2
			-256
			255.9921875
			ECU_ADDRESS 0xFFFF8446
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_rams_thr_ar_sp
			"Vxx_rams_thr_ar_sp"
			UWORD
			F_0v0596_p0_108
			2
			2
			0
			3905.886
			ECU_ADDRESS 0xFFFF8448
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_rams_tkof_driv_tqe_sp
			"Vxx_rams_tkof_driv_tqe_sp"
			UWORD
			F_0v0078125_m100_35
			2
			2
			-100
			411.9921875
			ECU_ADDRESS 0xFFFF844A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_rams_tot_tq_loss
			"Vxx_rams_tot_tq_loss"
			UWORD
			F_0v0078125_p0_15
			2
			2
			0
			511.9921875
			ECU_ADDRESS 0xFFFF844C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_rams_tq_req
			"Vxx_rams_tq_req"
			UWORD
			F_0v0078125_m100_35
			2
			2
			-100
			411.9921875
			ECU_ADDRESS 0xFFFF844E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_rams_tq_req_err
			"Vxx_rams_tq_req_err"
			UWORD
			F_0v0078125_m100_35
			2
			2
			-100
			411.9921875
			ECU_ADDRESS 0xFFFF8450
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_rams_tq_req_err_max
			"Vxx_rams_tq_req_err_max"
			UWORD
			F_0v0078125_m100_35
			2
			2
			-100
			411.9921875
			ECU_ADDRESS 0xFFFF7E5E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_rams_tq_req_err_min
			"Vxx_rams_tq_req_err_min"
			UWORD
			F_0v0078125_m100_35
			2
			2
			-100
			411.9921875
			ECU_ADDRESS 0xFFFF7E60
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_rams_tq_req_fail_ctr
			"Vxx_rams_tq_req_fail_ctr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8349
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_rams_tq_req_fail_ctr_max
			"Vxx_rams_tq_req_fail_ctr_max"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7DC4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_rams_tq_req_prev
			"Vxx_rams_tq_req_prev"
			UWORD
			F_0v0078125_m100_35
			2
			2
			-100
			411.9921875
			ECU_ADDRESS 0xFFFF8452
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_raw_ac_prs
			"Vxx_raw_ac_prs"
			UWORD
			F_0v0000762951_p0_353
			2
			2
			0
			5.000000034
			ECU_ADDRESS 0xFFFF746A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_raw_alt_crt
			"Vxx_raw_alt_crt"
			UBYTE
			F_0v0472_p0_154
			2
			2
			0
			12.036
			ECU_ADDRESS 0xFFFF6D3F
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_raw_alt_pwm
			"Vxx_raw_alt_pwm"
			UBYTE
			F_0v3921569_p0_340
			2
			2
			0
			100.0000095
			ECU_ADDRESS 0xFFFF6D40
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_raw_alti
			"Vxx_raw_alti"
			UBYTE
			F_3v7_p0_21
			2
			2
			0
			943.5
			ECU_ADDRESS 0xFFFF8605
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_raw_cart_iga
			"Vxx_raw_cart_iga"
			UBYTE
			F_0v375_m23v625_34
			2
			2
			-23.625
			72
			ECU_ADDRESS 0xFFFF6DC5
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_raw_driv_slow_eng_tq
			"Vxx_raw_driv_slow_eng_tq"
			UWORD
			F_0v0078125_m100_35
			2
			2
			-100
			411.9921875
			ECU_ADDRESS 0xFFFF8454
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_raw_dyn_efy_cor
			"Vxx_raw_dyn_efy_cor"
			UWORD
			F_0v0002441406_p0_182
			2
			2
			0
			15.99975586
			ECU_ADDRESS 0xFFFF7A50
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_raw_fac_cor_thr_adj
			"Vxx_raw_fac_cor_thr_adj"
			UWORD
			F_3v05176_m100000_370
			2
			2
			-100000
			99997.0916
			ECU_ADDRESS 0xFFFF6D08
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_raw_map
			"Vxx_raw_map"
			UWORD
			F_0v925_p103_345
			2
			2
			103
			60722.875
			ECU_ADDRESS 0xFFFF8068
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_raw_map_sum
			"Vxx_raw_map_sum"
			UWORD
			F_0v925_p103_345
			2
			2
			103
			60722.875
			ECU_ADDRESS 0xFFFF806A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_raw_mdl_map_spg_rat
			"Vxx_raw_mdl_map_spg_rat"
			UWORD
			F_30v517578125_p0_67
			2
			2
			0
			1999969.482
			ECU_ADDRESS 0xFFFF804E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_raw_n_dif_drv
			"Vxx_raw_n_dif_drv"
			UWORD
			F_1_m8192_66
			2
			2
			-8192
			57343
			ECU_ADDRESS 0xFFFF82A2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_raw_n_dif_drv_prec
			"Vxx_raw_n_dif_drv_prec"
			UWORD
			F_1_m8192_66
			2
			2
			-8192
			57343
			ECU_ADDRESS 0xFFFF82A4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_raw_otl_iga
			"Vxx_raw_otl_iga"
			UBYTE
			F_0v375_m23v625_34
			2
			2
			-23.625
			72
			ECU_ADDRESS 0xFFFF7A30
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_raw_pdl_psn
			"Vxx_raw_pdl_psn"
			UWORD
			F_0v390625_p0_4
			2
			2
			0
			25599.60938
			ECU_ADDRESS 0xFFFF8230
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_raw_prs_rat
			"Vxx_raw_prs_rat"
			UWORD
			F_15v2587890625_p0_68
			2
			2
			0
			999984.7412
			ECU_ADDRESS 0xFFFF8456
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_raw_spg
			"Vxx_raw_spg"
			UWORD
			F_0v925_p103_345
			2
			2
			103
			60722.875
			ECU_ADDRESS 0xFFFF84E8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_raw_spg_sum
			"Vxx_raw_spg_sum"
			UWORD
			F_0v925_p103_345
			2
			2
			103
			60722.875
			ECU_ADDRESS 0xFFFF84EA
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_raw_thd_n_ovn
			"Vxx_raw_thd_n_ovn"
			UWORD
			F_1_p0_14
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF8458
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_raw_thr_psn_mdl
			"Vxx_raw_thr_psn_mdl"
			UWORD
			F_0v097656_p0_5
			2
			2
			0
			6399.88596
			ECU_ADDRESS 0xFFFF7A52
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_raw_thr_psn_sp
			"Vxx_raw_thr_psn_sp"
			UWORD
			F_0v097656_p0_5
			2
			2
			0
			6399.88596
			ECU_ADDRESS 0xFFFF845A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_raw_tq_abst_agb
			"Vxx_raw_tq_abst_agb"
			UBYTE
			F_2_m100_36
			2
			2
			-100
			410
			ECU_ADDRESS 0xFFFF834A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_raw_whl_angl
			"Vxx_raw_whl_angl"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF73BE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ref_rest_cor
			"Vxx_ref_rest_cor"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF80E1
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_rel_in_vvt_mes
			"Vxx_rel_in_vvt_mes"
			UWORD
			F_0v09375_p0_282
			2
			2
			0
			6143.90625
			ECU_ADDRESS 0xFFFF8582
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_rel_in_vvt_mes_prec
			"Vxx_rel_in_vvt_mes_prec"
			UWORD
			F_0v09375_p0_282
			2
			2
			0
			6143.90625
			ECU_ADDRESS 0xFFFF8584
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_rel_thr_pos
			"Vxx_rel_thr_pos"
			UBYTE
			F_0v4_p0_106
			2
			2
			0
			102
			ECU_ADDRESS 0xFFFF76B4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_rest_ufld_dly
			"Vxx_rest_ufld_dly"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8652
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_rgt_trt_ad
			"Vxx_rgt_trt_ad"
			UWORD
			F_0v04376_p0_180
			2
			2
			0
			2867.8116
			ECU_ADDRESS 0xFFFF77DA
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_rich_dstb_iga_cor_cyl1
			"Vxx_rich_dstb_iga_cor_cyl1"
			SBYTE
			F_0v375_p0_29
			2
			2
			-48
			47.625
			ECU_ADDRESS 0xFFFF6D8C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_rich_dstb_iga_cor_cyl2
			"Vxx_rich_dstb_iga_cor_cyl2"
			SBYTE
			F_0v375_p0_29
			2
			2
			-48
			47.625
			ECU_ADDRESS 0xFFFF6D8F
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_rich_dstb_iga_cor_cyl3
			"Vxx_rich_dstb_iga_cor_cyl3"
			SBYTE
			F_0v375_p0_29
			2
			2
			-48
			47.625
			ECU_ADDRESS 0xFFFF6D8D
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_rich_dstb_iga_cor_cyl4
			"Vxx_rich_dstb_iga_cor_cyl4"
			SBYTE
			F_0v375_p0_29
			2
			2
			-48
			47.625
			ECU_ADDRESS 0xFFFF6D8E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_rich_i_apl
			"Vxx_rich_i_apl"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7B7C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_rich_sp
			"Vxx_rich_sp"
			UWORD
			F_0v0000305176_p0_72
			2
			2
			0
			1.999969605
			ECU_ADDRESS 0xFFFF7B7E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_rtn_eal
			"Vxx_rtn_eal"
			UBYTE
			F_0v39215686_p0_209
			2
			2
			0
			99.9999993
			ECU_ADDRESS 0xFFFF8623
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_rtn_frm_tco
			"Vxx_rtn_frm_tco"
			UBYTE
			F_0v625_m40_25
			2
			2
			-40
			119.375
			ECU_ADDRESS 0xFFFF8628
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_rtn_map
			"Vxx_rtn_map"
			UWORD
			F_3v7_p103_37
			2
			2
			103
			242582.5
			ECU_ADDRESS 0xFFFF8620
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_rtn_mv_ad_fac
			"Vxx_rtn_mv_ad_fac"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8626
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_rtn_mv_ad_ofs
			"Vxx_rtn_mv_ad_ofs"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8625
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_rtn_n01
			"Vxx_rtn_n01"
			UWORD
			F_1_p0_14
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF861E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_rtn_rich_loop_ti_fac
			"Vxx_rtn_rich_loop_ti_fac"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8624
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_rtn_vs
			"Vxx_rtn_vs"
			UBYTE
			F_1_p0_58
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8627
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_run_eng_ena
			"Vxx_run_eng_ena"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7355
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_run_eng_ena_eep
			"Vxx_run_eng_ena_eep"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF86DD
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_run_eng_rst_ctr
			"Vxx_run_eng_rst_ctr"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF86B4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_run_re_phs_ctr
			"Vxx_run_re_phs_ctr"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF866E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_run_toth_ctr
			"Vxx_run_toth_ctr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7FA2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_run_vh_dsb_dly
			"Vxx_run_vh_dsb_dly"
			UBYTE
			F_16_p0_10
			2
			2
			0
			4080
			ECU_ADDRESS 0xFFFF77C5
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_run_vh_min_is_n
			"Vxx_run_vh_min_is_n"
			UBYTE
			F_16_p0_83
			2
			2
			0
			4080
			ECU_ADDRESS 0xFFFF8100
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_sa_in_ctr
			"Vxx_sa_in_ctr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7DC5
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_sa_lbdw_dif
			"Vxx_sa_lbdw_dif"
			UWORD
			F_0v038125_p0_237
			2
			2
			0
			2498.521875
			ECU_ADDRESS 0xFFFF7E62
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_sa_lbdw_dif_rtn
			"Vxx_sa_lbdw_dif_rtn"
			UWORD
			F_0v038125_p0_237
			2
			2
			0
			2498.521875
			ECU_ADDRESS 0xFFFF8928
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_sa_lbdw_fil_aftr
			"Vxx_sa_lbdw_fil_aftr"
			UWORD
			F_0v038125_p0_237
			2
			2
			0
			2498.521875
			ECU_ADDRESS 0xFFFF7E64
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_sa_lbdw_fil_bfr
			"Vxx_sa_lbdw_fil_bfr"
			UWORD
			F_0v038125_p0_237
			2
			2
			0
			2498.521875
			ECU_ADDRESS 0xFFFF7E66
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_sa_mes_dly
			"Vxx_sa_mes_dly"
			UBYTE
			F_64_p0_145
			2
			2
			0
			16320
			ECU_ADDRESS 0xFFFF7DC6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_sa_mis_vld
			"Vxx_sa_mis_vld"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7DC7
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_sa_stt
			"Vxx_sa_stt"
			UBYTE
			Vxx_sa_stt_conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF7DC8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_secu_dly
			"Vxx_secu_dly"
			UBYTE
			F_100_p0_305
			2
			2
			0
			25500
			ECU_ADDRESS 0xFFFF6C0B
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_sens1_pdl_fil_psn
			"Vxx_sens1_pdl_fil_psn"
			UWORD
			F_0v097656_p0_5
			2
			2
			0
			6399.88596
			ECU_ADDRESS 0xFFFF7772
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_sens1_pdl_fil_psn_max
			"Vxx_sens1_pdl_fil_psn_max"
			UWORD
			F_0v097656_p0_5
			2
			2
			0
			6399.88596
			ECU_ADDRESS 0xFFFF7E68
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_sens1_pdl_fil_psn_min
			"Vxx_sens1_pdl_fil_psn_min"
			UWORD
			F_0v097656_p0_5
			2
			2
			0
			6399.88596
			ECU_ADDRESS 0xFFFF7E6A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_sens1_thr_fil_psn
			"Vxx_sens1_thr_fil_psn"
			UWORD
			F_0v048828125_p0_199
			2
			2
			0
			3199.951172
			ECU_ADDRESS 0xFFFF7774
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_sens1_thr_fil_psn1
			"Vxx_sens1_thr_fil_psn1"
			UWORD
			F_0v048828125_p0_199
			2
			2
			0
			3199.951172
			ECU_ADDRESS 0xFFFF7776
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_sens1_thr_fil_psn1_old
			"Vxx_sens1_thr_fil_psn1_old"
			UWORD
			F_0v048828125_p0_199
			2
			2
			0
			3199.951172
			ECU_ADDRESS 0xFFFF7778
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_sens1_thr_fil_psn_max
			"Vxx_sens1_thr_fil_psn_max"
			UWORD
			F_0v097656_p0_5
			2
			2
			0
			6399.88596
			ECU_ADDRESS 0xFFFF7E6C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_sens1_thr_fil_psn_min
			"Vxx_sens1_thr_fil_psn_min"
			UWORD
			F_0v097656_p0_5
			2
			2
			0
			6399.88596
			ECU_ADDRESS 0xFFFF7E6E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_sens1_thr_psn
			"Vxx_sens1_thr_psn"
			UWORD
			F_0v09765625_p0_71
			2
			2
			0
			6399.902344
			ECU_ADDRESS 0xFFFF777A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_sens2_pdl_fil_psn
			"Vxx_sens2_pdl_fil_psn"
			UWORD
			F_0v097656_p0_5
			2
			2
			0
			6399.88596
			ECU_ADDRESS 0xFFFF777C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_sens2_pdl_fil_psn_max
			"Vxx_sens2_pdl_fil_psn_max"
			UWORD
			F_0v097656_p0_5
			2
			2
			0
			6399.88596
			ECU_ADDRESS 0xFFFF7E70
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_sens2_pdl_fil_psn_min
			"Vxx_sens2_pdl_fil_psn_min"
			UWORD
			F_0v097656_p0_5
			2
			2
			0
			6399.88596
			ECU_ADDRESS 0xFFFF7E72
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_sens2_pdl_fmt_psn
			"Vxx_sens2_pdl_fmt_psn"
			UWORD
			F_0v09765_p0_3
			2
			2
			0
			6399.49275
			ECU_ADDRESS 0xFFFF777E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_sens2_thr_fil_psn
			"Vxx_sens2_thr_fil_psn"
			UWORD
			F_0v048828125_p0_199
			2
			2
			0
			3199.951172
			ECU_ADDRESS 0xFFFF7780
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_sens2_thr_fil_psn1
			"Vxx_sens2_thr_fil_psn1"
			UWORD
			F_0v048828125_p0_199
			2
			2
			0
			3199.951172
			ECU_ADDRESS 0xFFFF7782
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_sens2_thr_fil_psn1_old
			"Vxx_sens2_thr_fil_psn1_old"
			UWORD
			F_0v048828125_p0_199
			2
			2
			0
			3199.951172
			ECU_ADDRESS 0xFFFF7784
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_sens2_thr_fil_psn_max
			"Vxx_sens2_thr_fil_psn_max"
			UWORD
			F_0v097656_p0_5
			2
			2
			0
			6399.88596
			ECU_ADDRESS 0xFFFF7E74
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_sens2_thr_fil_psn_min
			"Vxx_sens2_thr_fil_psn_min"
			UWORD
			F_0v097656_p0_5
			2
			2
			0
			6399.88596
			ECU_ADDRESS 0xFFFF7E76
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_sens2_thr_psn
			"Vxx_sens2_thr_psn"
			UWORD
			F_0v09765625_p0_71
			2
			2
			0
			6399.902344
			ECU_ADDRESS 0xFFFF7786
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_sens_thr_psn_diff
			"Vxx_sens_thr_psn_diff"
			SWORD
			F_0v09765625_p0_71
			2
			2
			-3200
			3199.902344
			ECU_ADDRESS 0xFFFF76EC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_sens_thr_psn_diff_prec
			"Vxx_sens_thr_psn_diff_prec"
			SWORD
			F_0v09765625_p0_71
			2
			2
			-3200
			3199.902344
			ECU_ADDRESS 0xFFFF76EE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_set_stal_dly
			"Vxx_set_stal_dly"
			UBYTE
			F_8_p0_56
			2
			2
			0
			2040
			ECU_ADDRESS 0xFFFF78E2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_sfg_seq_trs_ctr
			"Vxx_sfg_seq_trs_ctr"
			UBYTE
			F_1_p0_53
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7AE1
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_sl_tqe_sp
			"Vxx_sl_tqe_sp"
			UBYTE
			F_2_m100_36
			2
			2
			-100
			410
			ECU_ADDRESS 0xFFFF81F6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_sl_tqe_sp_temp
			"Vxx_sl_tqe_sp_temp"
			UWORD
			F_0v0078125_m100_35
			2
			2
			-100
			411.9921875
			ECU_ADDRESS 0xFFFF8232
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_slop_ac_dsb_dly
			"Vxx_slop_ac_dsb_dly"
			UBYTE
			F_128_p0_125
			2
			2
			0
			32640
			ECU_ADDRESS 0xFFFF7462
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_slop_map_mmv
			"Vxx_slop_map_mmv"
			UWORD
			F_0v0578125_p103_96
			2
			2
			103
			3891.742188
			ECU_ADDRESS 0xFFFF8020
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_slow_agb_tq_sp
			"Vxx_slow_agb_tq_sp"
			UBYTE
			F_2_m100_36
			2
			2
			-100
			410
			ECU_ADDRESS 0xFFFF7356
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_slow_asr_tq_sp
			"Vxx_slow_asr_tq_sp"
			UBYTE
			F_2_m100_36
			2
			2
			-100
			410
			ECU_ADDRESS 0xFFFF7357
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_slow_pdl_ad_ctr
			"Vxx_slow_pdl_ad_ctr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7FC4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_spg
			"Vxx_spg"
			UWORD
			F_3v7_p103_37
			2
			2
			103
			242582.5
			ECU_ADDRESS 0xFFFF84EC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_spg16
			"Vxx_spg16"
			UWORD
			F_0v0578125_p103_96
			2
			2
			103
			3891.742188
			ECU_ADDRESS 0xFFFF84FA
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_spg_ad_cdn
			"Vxx_spg_ad_cdn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF849F
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_spg_ad_pwm
			"Vxx_spg_ad_pwm"
			SWORD
			F_0v0015258789_p0_115
			2
			2
			-50
			49.99847412
			ECU_ADDRESS 0xFFFF8696
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_spg_ad_pwm_inc_cor
			"Vxx_spg_ad_pwm_inc_cor"
			SWORD
			F_0v001526_p0_42
			2
			2
			-50.003968
			50.002442
			ECU_ADDRESS 0xFFFF84C0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_spg_alti_cor
			"Vxx_spg_alti_cor"
			UBYTE
			F_3v7_p0_21
			2
			2
			0
			943.5
			ECU_ADDRESS 0xFFFF84B8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_spg_alti_ofs
			"Vxx_spg_alti_ofs"
			SBYTE
			F_3v7_p0_21
			2
			2
			-473.6
			469.9
			ECU_ADDRESS 0xFFFF84A4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_spg_ar_maf_fac
			"Vxx_spg_ar_maf_fac"
			UWORD
			F_0v9537_p0_73
			2
			2
			0
			62500.7295
			ECU_ADDRESS 0xFFFF84EE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_spg_cl_cdn
			"Vxx_spg_cl_cdn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF84A0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_spg_d_pwm
			"Vxx_spg_d_pwm"
			SWORD
			F_0v0015258_p0_48
			2
			2
			-49.9974144
			49.9958886
			ECU_ADDRESS 0xFFFF84C2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_spg_fail_ctr
			"Vxx_spg_fail_ctr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF84B9
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_spg_fail_ctr_max
			"Vxx_spg_fail_ctr_max"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7DC9
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_spg_fail_thd
			"Vxx_spg_fail_thd"
			UWORD
			F_3v7_p103_37
			2
			2
			103
			242582.5
			ECU_ADDRESS 0xFFFF84F0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_spg_fil_prs_err
			"Vxx_spg_fil_prs_err"
			SBYTE
			F_3v7_p0_21
			2
			2
			-473.6
			469.9
			ECU_ADDRESS 0xFFFF84A5
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_spg_fil_prs_err_drv
			"Vxx_spg_fil_prs_err_drv"
			SBYTE
			F_0v925_p0_245
			2
			2
			-118.4
			117.475
			ECU_ADDRESS 0xFFFF84A6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_spg_fil_spg_prs_sp
			"Vxx_spg_fil_spg_prs_sp"
			UWORD
			F_3v7_p103_37
			2
			2
			103
			242582.5
			ECU_ADDRESS 0xFFFF84F2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_spg_i_pwm
			"Vxx_spg_i_pwm"
			SWORD
			F_0v001526_p0_42
			2
			2
			-50.003968
			50.002442
			ECU_ADDRESS 0xFFFF84C4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_spg_l_hys
			"Vxx_spg_l_hys"
			UWORD
			F_3v7_p0_21
			2
			2
			0
			242479.5
			ECU_ADDRESS 0xFFFF84F4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_spg_max
			"Vxx_spg_max"
			UWORD
			F_3v7_p103_37
			2
			2
			103
			242582.5
			ECU_ADDRESS 0xFFFF7E78
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_spg_min
			"Vxx_spg_min"
			UWORD
			F_3v7_p103_37
			2
			2
			103
			242582.5
			ECU_ADDRESS 0xFFFF7E7A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_spg_ol_cdn
			"Vxx_spg_ol_cdn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF84A1
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_spg_p_pwm
			"Vxx_spg_p_pwm"
			SWORD
			F_0v001526_p0_42
			2
			2
			-50.003968
			50.002442
			ECU_ADDRESS 0xFFFF84C6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_spg_prs_err
			"Vxx_spg_prs_err"
			SBYTE
			F_3v7_p0_21
			2
			2
			-473.6
			469.9
			ECU_ADDRESS 0xFFFF84A7
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_spg_prs_err_max
			"Vxx_spg_prs_err_max"
			SBYTE
			F_3v7_p0_21
			2
			2
			-473.6
			469.9
			ECU_ADDRESS 0xFFFF7D7B
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_spg_prs_sp
			"Vxx_spg_prs_sp"
			UWORD
			F_3v7_p103_37
			2
			2
			103
			242582.5
			ECU_ADDRESS 0xFFFF84F6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_spg_pwm_dsb_req
			"Vxx_spg_pwm_dsb_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF84A2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_spg_pwm_sp
			"Vxx_spg_pwm_sp"
			UBYTE
			F_0v390625_p0_4
			2
			2
			0
			99.609375
			ECU_ADDRESS 0xFFFF84BA
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_spg_tia_cor
			"Vxx_spg_tia_cor"
			UBYTE
			F_3v7_m473v6_118
			2
			2
			-473.6
			469.9
			ECU_ADDRESS 0xFFFF84BB
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_spg_tq_rat_sp
			"Vxx_spg_tq_rat_sp"
			UBYTE
			F_0v00390625_p0_74
			2
			2
			0
			0.99609375
			ECU_ADDRESS 0xFFFF84BC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_spg_trs
			"Vxx_spg_trs"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF84A3
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_spg_up_hys
			"Vxx_spg_up_hys"
			UWORD
			F_3v7_p0_21
			2
			2
			0
			242479.5
			ECU_ADDRESS 0xFFFF84F8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_sqrt_cor_tia
			"Vxx_sqrt_cor_tia"
			UBYTE
			F_0v125_p0_409
			2
			2
			0
			31.875
			ECU_ADDRESS 0xFFFF834B
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_sta_ac_dsb_dly
			"Vxx_sta_ac_dsb_dly"
			UBYTE
			F_128_p0_125
			2
			2
			0
			32640
			ECU_ADDRESS 0xFFFF7463
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_sta_gas_pump_dly
			"Vxx_sta_gas_pump_dly"
			UBYTE
			F_8_p0_56
			2
			2
			0
			2040
			ECU_ADDRESS 0xFFFF6C0D
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_sta_iga
			"Vxx_sta_iga"
			UBYTE
			F_0v375_m23v625_6
			2
			2
			-23.625
			72
			ECU_ADDRESS 0xFFFF6DC6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_sta_iga_vld_ctr
			"Vxx_sta_iga_vld_ctr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7A31
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_sta_is_fil_pwm
			"Vxx_sta_is_fil_pwm"
			UWORD
			F_0v0015259_p0_92
			2
			2
			0
			99.9998565
			ECU_ADDRESS 0xFFFF7A10
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_sta_out_sfg_ti_ctr
			"Vxx_sta_out_sfg_ti_ctr"
			UBYTE
			F_1_p0_53
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7AE2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_sta_tco
			"Vxx_sta_tco"
			UBYTE
			F_0v625_m40_25
			2
			2
			-40
			119.375
			ECU_ADDRESS 0xFFFF858D
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_sta_tco_ti_fac
			"Vxx_sta_tco_ti_fac"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7B80
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_sta_tco_ti_tdc_ctr
			"Vxx_sta_tco_ti_tdc_ctr"
			UBYTE
			F_1_p0_53
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7AE3
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_sta_ti
			"Vxx_sta_ti"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7B82
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stab_toil
			"Vxx_stab_toil"
			UWORD
			F_0v625_m40_25
			2
			2
			-40
			40919.375
			ECU_ADDRESS 0xFFFF7CE2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_ac_prs
			"Vxx_stactr_ac_prs"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8978
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_ac_rcpt
			"Vxx_stactr_ac_rcpt"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8979
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_acr_oc
			"Vxx_stactr_acr_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF897A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_acr_scg
			"Vxx_stactr_acr_scg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF897B
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_acr_vb_sc
			"Vxx_stactr_acr_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF897C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_actr_rly
			"Vxx_stactr_actr_rly"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF897D
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_actr_rly_cut
			"Vxx_stactr_actr_rly_cut"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF897E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_agb_conv_stt
			"Vxx_stactr_agb_conv_stt"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF897F
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_agb_gear
			"Vxx_stactr_agb_gear"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8980
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_agb_rcpt
			"Vxx_stactr_agb_rcpt"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8981
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_agb_tq_nok
			"Vxx_stactr_agb_tq_nok"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8982
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_air
			"Vxx_stactr_air"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8983
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_alt_ecu
			"Vxx_stactr_alt_ecu"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8984
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_alt_load_in
			"Vxx_stactr_alt_load_in"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8986
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_alt_mux
			"Vxx_stactr_alt_mux"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8985
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_bkup_mem
			"Vxx_stactr_bkup_mem"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8987
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_checksum
			"Vxx_stactr_checksum"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8988
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_clu
			"Vxx_stactr_clu"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8989
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_cp_oc
			"Vxx_stactr_cp_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF898A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_cp_scg
			"Vxx_stactr_cp_scg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF898B
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_cp_vb_sc
			"Vxx_stactr_cp_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF898C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_crk
			"Vxx_stactr_crk"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF898D
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_crk_nr
			"Vxx_stactr_crk_nr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF898E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_cru_brk_cnt1
			"Vxx_stactr_cru_brk_cnt1"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF898F
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_cru_brk_cnt2
			"Vxx_stactr_cru_brk_cnt2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8990
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_cru_on_off_chr
			"Vxx_stactr_cru_on_off_chr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8991
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_cru_whl_cmd
			"Vxx_stactr_cru_whl_cmd"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8992
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_el_wind_rcpt
			"Vxx_stactr_el_wind_rcpt"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8993
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_eng_temp_oc
			"Vxx_stactr_eng_temp_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8994
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_eng_temp_scg
			"Vxx_stactr_eng_temp_scg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8995
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_eng_temp_vb_sc
			"Vxx_stactr_eng_temp_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8996
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_eng_whl
			"Vxx_stactr_eng_whl"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8997
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_fsys
			"Vxx_stactr_fsys"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8998
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_fsys_lpg
			"Vxx_stactr_fsys_lpg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8999
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_gas_pump_oc
			"Vxx_stactr_gas_pump_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF899A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_gas_pump_scg
			"Vxx_stactr_gas_pump_scg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF899B
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_gas_pump_vb_sc
			"Vxx_stactr_gas_pump_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF899C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_igc_1_oc
			"Vxx_stactr_igc_1_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF899D
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_igc_1_vb_sc
			"Vxx_stactr_igc_1_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF899E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_igc_2_oc
			"Vxx_stactr_igc_2_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF899F
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_igc_2_vb_sc
			"Vxx_stactr_igc_2_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89A0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_igc_3_oc
			"Vxx_stactr_igc_3_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89A1
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_igc_3_vb_sc
			"Vxx_stactr_igc_3_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89A2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_igc_4_oc
			"Vxx_stactr_igc_4_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89A3
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_igc_4_vb_sc
			"Vxx_stactr_igc_4_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89A4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_inj1_oc
			"Vxx_stactr_inj1_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89A5
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_inj1_scg
			"Vxx_stactr_inj1_scg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89A6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_inj1_vb_sc
			"Vxx_stactr_inj1_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89A7
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_inj2_oc
			"Vxx_stactr_inj2_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89A8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_inj2_scg
			"Vxx_stactr_inj2_scg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89A9
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_inj2_vb_sc
			"Vxx_stactr_inj2_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89AA
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_inj3_oc
			"Vxx_stactr_inj3_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89AB
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_inj3_scg
			"Vxx_stactr_inj3_scg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89AC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_inj3_vb_sc
			"Vxx_stactr_inj3_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89AD
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_inj4_oc
			"Vxx_stactr_inj4_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89AE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_inj4_scg
			"Vxx_stactr_inj4_scg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89AF
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_inj4_vb_sc
			"Vxx_stactr_inj4_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89B0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_inj_ecu
			"Vxx_stactr_inj_ecu"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89B1
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_ip_inj_cnt
			"Vxx_stactr_ip_inj_cnt"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89B2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_knk
			"Vxx_stactr_knk"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89B3
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_lbdw_hot_oc
			"Vxx_stactr_lbdw_hot_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89B7
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_lbdw_hot_scg
			"Vxx_stactr_lbdw_hot_scg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89B8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_lbdw_hot_vb_sc
			"Vxx_stactr_lbdw_hot_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89B9
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_lbdw_oc
			"Vxx_stactr_lbdw_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89B4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_lbdw_pump_crt
			"Vxx_stactr_lbdw_pump_crt"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89BA
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_lbdw_scg
			"Vxx_stactr_lbdw_scg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89B5
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_lbdw_vb_sc
			"Vxx_stactr_lbdw_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89B6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_lbup_hot_oc
			"Vxx_stactr_lbup_hot_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89BE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_lbup_hot_scg
			"Vxx_stactr_lbup_hot_scg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89BF
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_lbup_hot_vb_sc
			"Vxx_stactr_lbup_hot_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89C0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_lbup_oc
			"Vxx_stactr_lbup_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89BB
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_lbup_pump_crt
			"Vxx_stactr_lbup_pump_crt"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89C1
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_lbup_scg
			"Vxx_stactr_lbup_scg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89BC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_lbup_vb_sc
			"Vxx_stactr_lbup_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89BD
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_lpg_rcpt
			"Vxx_stactr_lpg_rcpt"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89C2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_map
			"Vxx_stactr_map"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89C3
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_map_chr
			"Vxx_stactr_map_chr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89C4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_mastervac_cc
			"Vxx_stactr_mastervac_cc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89C5
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_mastervac_oc
			"Vxx_stactr_mastervac_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89C6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_mcut_sens1
			"Vxx_stactr_mcut_sens1"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89C7
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_mdf1_oc
			"Vxx_stactr_mdf1_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89C8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_mdf1_scg
			"Vxx_stactr_mdf1_scg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89C9
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_mdf1_vb_sc
			"Vxx_stactr_mdf1_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89CA
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_mdf2_oc
			"Vxx_stactr_mdf2_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89CB
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_mdf2_scg
			"Vxx_stactr_mdf2_scg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89CC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_mdf2_vb_sc
			"Vxx_stactr_mdf2_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89CD
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_min_gas_lvl
			"Vxx_stactr_min_gas_lvl"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89CE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_min_lpg_lvl
			"Vxx_stactr_min_lpg_lvl"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89CF
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_mis_cata
			"Vxx_stactr_mis_cata"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89D0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_mis_cata_1
			"Vxx_stactr_mis_cata_1"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89D1
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_mis_cata_1_lpg
			"Vxx_stactr_mis_cata_1_lpg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89D2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_mis_cata_2
			"Vxx_stactr_mis_cata_2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89D3
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_mis_cata_2_lpg
			"Vxx_stactr_mis_cata_2_lpg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89D4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_mis_cata_3
			"Vxx_stactr_mis_cata_3"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89D5
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_mis_cata_3_lpg
			"Vxx_stactr_mis_cata_3_lpg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89D6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_mis_cata_4
			"Vxx_stactr_mis_cata_4"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89D7
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_mis_cata_4_lpg
			"Vxx_stactr_mis_cata_4_lpg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89D8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_mis_cata_gas
			"Vxx_stactr_mis_cata_gas"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89D9
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_mis_cata_lpg
			"Vxx_stactr_mis_cata_lpg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89DA
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_mis_fast
			"Vxx_stactr_mis_fast"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89DB
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_mis_lih
			"Vxx_stactr_mis_lih"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89DC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_mis_polu
			"Vxx_stactr_mis_polu"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89DD
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_mis_polu_1
			"Vxx_stactr_mis_polu_1"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89DE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_mis_polu_1_lpg
			"Vxx_stactr_mis_polu_1_lpg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89DF
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_mis_polu_2
			"Vxx_stactr_mis_polu_2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89E0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_mis_polu_2_lpg
			"Vxx_stactr_mis_polu_2_lpg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89E1
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_mis_polu_3
			"Vxx_stactr_mis_polu_3"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89E2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_mis_polu_3_lpg
			"Vxx_stactr_mis_polu_3_lpg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89E3
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_mis_polu_4
			"Vxx_stactr_mis_polu_4"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89E4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_mis_polu_4_lpg
			"Vxx_stactr_mis_polu_4_lpg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89E5
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_mis_polu_gas
			"Vxx_stactr_mis_polu_gas"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89E6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_mis_polu_lpg
			"Vxx_stactr_mis_polu_lpg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89E7
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_mvac_pump_oc
			"Vxx_stactr_mvac_pump_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89E8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_mvac_pump_scg
			"Vxx_stactr_mvac_pump_scg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89E9
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_mvac_pump_vb_sc
			"Vxx_stactr_mvac_pump_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89EA
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_mvac_sys
			"Vxx_stactr_mvac_sys"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89EB
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_obd_cata
			"Vxx_stactr_obd_cata"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89EC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_obd_lamb
			"Vxx_stactr_obd_lamb"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89ED
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_obd_sa
			"Vxx_stactr_obd_sa"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89EE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_oil_cc
			"Vxx_stactr_oil_cc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89EF
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_oil_co
			"Vxx_stactr_oil_co"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89F0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_pdl_sens1_oc
			"Vxx_stactr_pdl_sens1_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89F1
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_pdl_sens1_vb_sc
			"Vxx_stactr_pdl_sens1_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89F2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_pdl_sens2_oc
			"Vxx_stactr_pdl_sens2_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89F3
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_pdl_sens2_vb_sc
			"Vxx_stactr_pdl_sens2_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89F4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_pdl_sens_chr
			"Vxx_stactr_pdl_sens_chr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89F5
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_pmh_cc
			"Vxx_stactr_pmh_cc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89F6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_pmh_co
			"Vxx_stactr_pmh_co"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89F7
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_pow_lbdw
			"Vxx_stactr_pow_lbdw"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89F8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_pow_lbup
			"Vxx_stactr_pow_lbup"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89F9
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_ptc
			"Vxx_stactr_ptc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89FA
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_ptc_rov_oc
			"Vxx_stactr_ptc_rov_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89FB
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_ptc_rov_scg
			"Vxx_stactr_ptc_rov_scg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89FC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_ptc_rov_vb_sc
			"Vxx_stactr_ptc_rov_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89FD
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_pws_1
			"Vxx_stactr_pws_1"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89FE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_pws_2
			"Vxx_stactr_pws_2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF89FF
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_pws_pdl2
			"Vxx_stactr_pws_pdl2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A00
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_pws_thr_pdl1
			"Vxx_stactr_pws_thr_pdl1"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A01
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_rams_map_tq
			"Vxx_stactr_rams_map_tq"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A02
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_rams_pdl
			"Vxx_stactr_rams_pdl"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A05
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_rams_tq_ctl
			"Vxx_stactr_rams_tq_ctl"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A03
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_rams_tq_req
			"Vxx_stactr_rams_tq_req"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A04
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_reserve_3_oc
			"Vxx_stactr_reserve_3_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A06
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_reserve_3_scg
			"Vxx_stactr_reserve_3_scg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A07
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_reserve_3_vb_sc
			"Vxx_stactr_reserve_3_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A08
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_rmc_algopp
			"Vxx_stactr_rmc_algopp"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A09
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_rmc_clockpp
			"Vxx_stactr_rmc_clockpp"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A0A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_rmc_comspipp
			"Vxx_stactr_rmc_comspipp"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A0B
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_rmc_inhwp
			"Vxx_stactr_rmc_inhwp"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A0C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_rmc_monitpp
			"Vxx_stactr_rmc_monitpp"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A0D
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_rmc_papmpp
			"Vxx_stactr_rmc_papmpp"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A0E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_rmc_pedmpp
			"Vxx_stactr_rmc_pedmpp"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A0F
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_rmc_timeoutpp
			"Vxx_stactr_rmc_timeoutpp"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A10
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_sa_ev_oc
			"Vxx_stactr_sa_ev_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A14
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_sa_ev_scg
			"Vxx_stactr_sa_ev_scg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A15
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_sa_ev_vb_sc
			"Vxx_stactr_sa_ev_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A16
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_sa_oc
			"Vxx_stactr_sa_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A11
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_sa_scg
			"Vxx_stactr_sa_scg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A12
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_sa_vb_sc
			"Vxx_stactr_sa_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A13
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_spg
			"Vxx_stactr_spg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A17
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_spg_sys
			"Vxx_stactr_spg_sys"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A18
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_spi_cc
			"Vxx_stactr_spi_cc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A19
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_svkl_chk_springs
			"Vxx_stactr_svkl_chk_springs"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A1A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_svkl_lih
			"Vxx_stactr_svkl_lih"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A1B
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_svkl_oc
			"Vxx_stactr_svkl_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A1C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_svkl_psn
			"Vxx_stactr_svkl_psn"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A1D
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_svkl_sge
			"Vxx_stactr_svkl_sge"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A1E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_svkl_trt_srch
			"Vxx_stactr_svkl_trt_srch"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A1F
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_swlk_mem
			"Vxx_stactr_swlk_mem"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A20
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_tco_acq
			"Vxx_stactr_tco_acq"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A21
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_tco_chr
			"Vxx_stactr_tco_chr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A22
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_thpl_oc
			"Vxx_stactr_thpl_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A23
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_thpl_scg
			"Vxx_stactr_thpl_scg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A24
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_thpl_vb_sc
			"Vxx_stactr_thpl_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A25
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_thr_cmd_cpt
			"Vxx_stactr_thr_cmd_cpt"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A2B
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_thr_cmd_vb_sc
			"Vxx_stactr_thr_cmd_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A2C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_thr_sens1_oc
			"Vxx_stactr_thr_sens1_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A26
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_thr_sens1_vb_sc
			"Vxx_stactr_thr_sens1_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A27
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_thr_sens2_scg
			"Vxx_stactr_thr_sens2_scg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A28
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_thr_sens2_vb_sc
			"Vxx_stactr_thr_sens2_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A29
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_thr_sens_chr
			"Vxx_stactr_thr_sens_chr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A2A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_tia_high
			"Vxx_stactr_tia_high"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A2D
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_tia_low
			"Vxx_stactr_tia_low"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A2E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_tjy_ctl
			"Vxx_stactr_tjy_ctl"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A2F
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_tlz_ad_b
			"Vxx_stactr_tlz_ad_b"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A30
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_vb_high
			"Vxx_stactr_vb_high"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A31
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_vb_low
			"Vxx_stactr_vb_low"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A32
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_vs_eal
			"Vxx_stactr_vs_eal"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A33
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_vs_mux
			"Vxx_stactr_vs_mux"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A34
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_vs_parasite
			"Vxx_stactr_vs_parasite"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A35
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_vta_intake_pmh
			"Vxx_stactr_vta_intake_pmh"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A36
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_vta_intake_shift
			"Vxx_stactr_vta_intake_shift"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A37
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_vvt_int_ev_oc
			"Vxx_stactr_vvt_int_ev_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A39
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_vvt_int_ev_scg
			"Vxx_stactr_vvt_int_ev_scg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A3A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_vvt_int_ev_vb_sc
			"Vxx_stactr_vvt_int_ev_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A3B
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_vvt_int_old_off
			"Vxx_stactr_vvt_int_old_off"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A38
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_vvt_intake_blk
			"Vxx_stactr_vvt_intake_blk"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A3C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_vvt_intake_bound
			"Vxx_stactr_vvt_intake_bound"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A3D
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_vvt_intake_dyn
			"Vxx_stactr_vvt_intake_dyn"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A3E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_vvt_intake_int
			"Vxx_stactr_vvt_intake_int"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A3F
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_vvtc_toth_3
			"Vxx_stactr_vvtc_toth_3"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A40
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_wat_temp_high
			"Vxx_stactr_wat_temp_high"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A41
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_wat_temp_low
			"Vxx_stactr_wat_temp_low"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A42
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_wgc_oc
			"Vxx_stactr_wgc_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A43
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_wgc_scg
			"Vxx_stactr_wgc_scg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A44
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_wgc_vb_sc
			"Vxx_stactr_wgc_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A45
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_wpmp_oc
			"Vxx_stactr_wpmp_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A46
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_wpmp_scg
			"Vxx_stactr_wpmp_scg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A47
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stactr_wpmp_vb_sc
			"Vxx_stactr_wpmp_vb_sc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A48
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stal_ac_dsb_dly
			"Vxx_stal_ac_dsb_dly"
			UBYTE
			F_1v024_p0_119
			2
			2
			0
			261.12
			ECU_ADDRESS 0xFFFF7464
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stal_det_swlk_dly
			"Vxx_stal_det_swlk_dly"
			UBYTE
			F_8v192_p0_248
			2
			2
			0
			2088.96
			ECU_ADDRESS 0xFFFF78E3
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stal_dly
			"Vxx_stal_dly"
			UBYTE
			F_8_p0_56
			2
			2
			0
			2040
			ECU_ADDRESS 0xFFFF78E4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stat_iga_efy
			"Vxx_stat_iga_efy"
			UWORD
			F_0v015258_p0_93
			2
			2
			0
			999.93303
			ECU_ADDRESS 0xFFFF7A54
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stat_min_iga
			"Vxx_stat_min_iga"
			UBYTE
			F_0v375_m23v625_34
			2
			2
			-23.625
			72
			ECU_ADDRESS 0xFFFF7A32
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_stat_whl_dly
			"Vxx_stat_whl_dly"
			UBYTE
			F_16_p0_10
			2
			2
			0
			4080
			ECU_ADDRESS 0xFFFF77C6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_svkl_fil_psn_err
			"Vxx_svkl_fil_psn_err"
			SWORD
			F_0v097656_p0_5
			2
			2
			-3199.991808
			3199.894152
			ECU_ADDRESS 0xFFFF76F0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_svkl_fil_psn_err_max
			"Vxx_svkl_fil_psn_err_max"
			SWORD
			F_0v097656_p0_5
			2
			2
			-3199.991808
			3199.894152
			ECU_ADDRESS 0xFFFF7DD8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_svkl_fil_psn_err_min
			"Vxx_svkl_fil_psn_err_min"
			SWORD
			F_0v097656_p0_5
			2
			2
			-3199.991808
			3199.894152
			ECU_ADDRESS 0xFFFF7DDA
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_svkl_i_max
			"Vxx_svkl_i_max"
			SWORD
			F_0v625_p0_258
			2
			2
			-20480
			20479.375
			ECU_ADDRESS 0xFFFF7DDC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_svkl_i_min
			"Vxx_svkl_i_min"
			SWORD
			F_0v625_p0_258
			2
			2
			-20480
			20479.375
			ECU_ADDRESS 0xFFFF7DDE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_svkl_i_msb
			"Vxx_svkl_i_msb"
			SWORD
			F_0v625_p0_258
			2
			2
			-20480
			20479.375
			ECU_ADDRESS 0xFFFF77A0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_svkl_oc_detect_tempo
			"Vxx_svkl_oc_detect_tempo"
			UBYTE
			F_2_p0_249
			2
			2
			0
			510
			ECU_ADDRESS 0xFFFF76B5
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_svkl_oc_diag_dsb_tempo
			"Vxx_svkl_oc_diag_dsb_tempo"
			UBYTE
			F_2_p0_249
			2
			2
			0
			510
			ECU_ADDRESS 0xFFFF76B6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_syn_ctl_toth_nr
			"Vxx_syn_ctl_toth_nr"
			SBYTE
			Id_0x00
			2
			2
			-128
			127
			ECU_ADDRESS 0xFFFF7F9C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_t_toth_0_lsb
			"Vxx_t_toth_0_lsb"
			UWORD
			F_0v1_p0_275
			2
			2
			0
			6553.5
			ECU_ADDRESS 0xFFFF7F86
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_t_toth_0_msb
			"Vxx_t_toth_0_msb"
			UWORD
			F_6v5536_p0_274
			2
			2
			0
			429490.176
			ECU_ADDRESS 0xFFFF7F84
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_t_toth_1_lsb
			"Vxx_t_toth_1_lsb"
			UWORD
			F_0v1_p0_275
			2
			2
			0
			6553.5
			ECU_ADDRESS 0xFFFF7F8A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_t_toth_1_msb
			"Vxx_t_toth_1_msb"
			UWORD
			F_6v5536_p0_274
			2
			2
			0
			429490.176
			ECU_ADDRESS 0xFFFF7F88
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_t_toth_2_lsb
			"Vxx_t_toth_2_lsb"
			UWORD
			F_0v1_p0_275
			2
			2
			0
			6553.5
			ECU_ADDRESS 0xFFFF7F8E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_t_toth_2_msb
			"Vxx_t_toth_2_msb"
			UWORD
			F_6v5536_p0_274
			2
			2
			0
			429490.176
			ECU_ADDRESS 0xFFFF7F8C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_t_toth_3_lsb
			"Vxx_t_toth_3_lsb"
			UWORD
			F_0v1_p0_275
			2
			2
			0
			6553.5
			ECU_ADDRESS 0xFFFF7F92
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_t_toth_3_msb
			"Vxx_t_toth_3_msb"
			UWORD
			F_6v5536_p0_274
			2
			2
			0
			429490.176
			ECU_ADDRESS 0xFFFF7F90
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_t_toth_4_lsb
			"Vxx_t_toth_4_lsb"
			UWORD
			F_0v1_p0_275
			2
			2
			0
			6553.5
			ECU_ADDRESS 0xFFFF7F96
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_t_toth_4_msb
			"Vxx_t_toth_4_msb"
			UWORD
			F_6v5536_p0_274
			2
			2
			0
			429490.176
			ECU_ADDRESS 0xFFFF7F94
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_t_toth_5_lsb
			"Vxx_t_toth_5_lsb"
			UWORD
			F_0v1_p0_275
			2
			2
			0
			6553.5
			ECU_ADDRESS 0xFFFF7F9A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_t_toth_5_msb
			"Vxx_t_toth_5_msb"
			UWORD
			F_6v5536_p0_274
			2
			2
			0
			429490.176
			ECU_ADDRESS 0xFFFF7F98
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tco
			"Vxx_tco"
			UBYTE
			F_0v625_m40_25
			2
			2
			-40
			119.375
			ECU_ADDRESS 0xFFFF858E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tco_chr_fil_dly
			"Vxx_tco_chr_fil_dly"
			UBYTE
			F_1v024_p0_119
			2
			2
			0
			261.12
			ECU_ADDRESS 0xFFFF858F
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tco_chr_fil_dly2
			"Vxx_tco_chr_fil_dly2"
			UBYTE
			F_1v024_p0_119
			2
			2
			0
			261.12
			ECU_ADDRESS 0xFFFF8590
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tco_dif
			"Vxx_tco_dif"
			UBYTE
			F_0v625_m40_25
			2
			2
			-40
			119.375
			ECU_ADDRESS 0xFFFF7CE0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tco_eai_ti_fac
			"Vxx_tco_eai_ti_fac"
			UBYTE
			F_1_p0_9
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7AE4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tco_fil
			"Vxx_tco_fil"
			UBYTE
			F_0v625_m40_25
			2
			2
			-40
			119.375
			ECU_ADDRESS 0xFFFF7CE1
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tco_is_n_ofs
			"Vxx_tco_is_n_ofs"
			UBYTE
			F_16_p0_83
			2
			2
			0
			4080
			ECU_ADDRESS 0xFFFF8101
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tco_is_n_ofs_raw
			"Vxx_tco_is_n_ofs_raw"
			UBYTE
			F_16_p0_83
			2
			2
			0
			4080
			ECU_ADDRESS 0xFFFF8102
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tco_lean_ti_fac
			"Vxx_tco_lean_ti_fac"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7AE5
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tco_mdf_dly
			"Vxx_tco_mdf_dly"
			UWORD
			F_4v096_p0_12
			2
			2
			0
			268431.36
			ECU_ADDRESS 0xFFFF7930
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tco_mdl
			"Vxx_tco_mdl"
			UBYTE
			F_0v625_m40_25
			2
			2
			-40
			119.375
			ECU_ADDRESS 0xFFFF8591
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tco_min_is_n
			"Vxx_tco_min_is_n"
			UBYTE
			F_16_p0_83
			2
			2
			0
			4080
			ECU_ADDRESS 0xFFFF8103
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tco_mon_dly
			"Vxx_tco_mon_dly"
			UBYTE
			F_1v024_p0_119
			2
			2
			0
			261.12
			ECU_ADDRESS 0xFFFF8592
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tco_para
			"Vxx_tco_para"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF8598
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tco_rich_ti_fac
			"Vxx_tco_rich_ti_fac"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7AE6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tco_ti_cor
			"Vxx_tco_ti_cor"
			UBYTE
			F_0v015625_p0v5_126
			2
			2
			0.5
			4.484375
			ECU_ADDRESS 0xFFFF7AE7
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tco_ti_cor_fil_ctr
			"Vxx_tco_ti_cor_fil_ctr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7AE8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tco_ti_cor_fil_ctr2
			"Vxx_tco_ti_cor_fil_ctr2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7AE9
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tco_ti_fac1
			"Vxx_tco_ti_fac1"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7AEA
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tco_ti_fac2
			"Vxx_tco_ti_fac2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7AEB
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tco_ti_fac3
			"Vxx_tco_ti_fac3"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7AEC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_agb_rcpt
			"Vxx_tctr_agb_rcpt"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B60
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_air
			"Vxx_tctr_air"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B61
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_bkup_mem
			"Vxx_tctr_bkup_mem"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B62
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_clu
			"Vxx_tctr_clu"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B63
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_cp
			"Vxx_tctr_cp"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B8F
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_crk
			"Vxx_tctr_crk"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B64
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_crk_nr
			"Vxx_tctr_crk_nr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B65
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_eng_whl
			"Vxx_tctr_eng_whl"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B66
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_fsys
			"Vxx_tctr_fsys"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B67
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_fsys_lpg
			"Vxx_tctr_fsys_lpg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B68
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_gas_pump
			"Vxx_tctr_gas_pump"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B90
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_igc_1
			"Vxx_tctr_igc_1"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B91
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_igc_2
			"Vxx_tctr_igc_2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B92
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_igc_3
			"Vxx_tctr_igc_3"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B93
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_igc_4
			"Vxx_tctr_igc_4"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B94
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_inj1
			"Vxx_tctr_inj1"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B95
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_inj2
			"Vxx_tctr_inj2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B96
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_inj3
			"Vxx_tctr_inj3"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B97
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_inj4
			"Vxx_tctr_inj4"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B98
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_inj_ecu
			"Vxx_tctr_inj_ecu"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B69
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_knk
			"Vxx_tctr_knk"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B6A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_lbdw
			"Vxx_tctr_lbdw"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B99
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_lbdw_hot
			"Vxx_tctr_lbdw_hot"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B9A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_lbup
			"Vxx_tctr_lbup"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B9B
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_lbup_hot
			"Vxx_tctr_lbup_hot"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B9C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_lpg_rcpt
			"Vxx_tctr_lpg_rcpt"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B6B
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_map
			"Vxx_tctr_map"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B6C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_min_gas_lvl
			"Vxx_tctr_min_gas_lvl"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B6D
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_mis_cata
			"Vxx_tctr_mis_cata"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B6E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_mis_cata_1
			"Vxx_tctr_mis_cata_1"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B6F
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_mis_cata_1_lpg
			"Vxx_tctr_mis_cata_1_lpg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B70
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_mis_cata_2
			"Vxx_tctr_mis_cata_2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B71
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_mis_cata_2_lpg
			"Vxx_tctr_mis_cata_2_lpg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B72
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_mis_cata_3
			"Vxx_tctr_mis_cata_3"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B73
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_mis_cata_3_lpg
			"Vxx_tctr_mis_cata_3_lpg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B74
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_mis_cata_4
			"Vxx_tctr_mis_cata_4"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B75
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_mis_cata_4_lpg
			"Vxx_tctr_mis_cata_4_lpg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B76
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_mis_cata_gas
			"Vxx_tctr_mis_cata_gas"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B77
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_mis_cata_lpg
			"Vxx_tctr_mis_cata_lpg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B78
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_mis_polu
			"Vxx_tctr_mis_polu"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B79
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_mis_polu_1
			"Vxx_tctr_mis_polu_1"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B7A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_mis_polu_1_lpg
			"Vxx_tctr_mis_polu_1_lpg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B7B
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_mis_polu_2
			"Vxx_tctr_mis_polu_2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B7C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_mis_polu_2_lpg
			"Vxx_tctr_mis_polu_2_lpg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B7D
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_mis_polu_3
			"Vxx_tctr_mis_polu_3"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B7E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_mis_polu_3_lpg
			"Vxx_tctr_mis_polu_3_lpg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B7F
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_mis_polu_4
			"Vxx_tctr_mis_polu_4"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B80
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_mis_polu_4_lpg
			"Vxx_tctr_mis_polu_4_lpg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B81
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_mis_polu_gas
			"Vxx_tctr_mis_polu_gas"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B82
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_mis_polu_lpg
			"Vxx_tctr_mis_polu_lpg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B83
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_obd_cata
			"Vxx_tctr_obd_cata"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B84
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_obd_lamb
			"Vxx_tctr_obd_lamb"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B85
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_obd_sa
			"Vxx_tctr_obd_sa"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B86
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_pow_lbdw
			"Vxx_tctr_pow_lbdw"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B87
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_pow_lbup
			"Vxx_tctr_pow_lbup"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B88
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_rams_pdl
			"Vxx_tctr_rams_pdl"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B89
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_sa
			"Vxx_tctr_sa"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B9D
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_sa_ev
			"Vxx_tctr_sa_ev"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B9E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_spg
			"Vxx_tctr_spg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B8A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_spg_sys
			"Vxx_tctr_spg_sys"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B8B
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_tco
			"Vxx_tctr_tco"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B9F
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_tia
			"Vxx_tctr_tia"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6BA0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_tlz_ad_b
			"Vxx_tctr_tlz_ad_b"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B8C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_vs
			"Vxx_tctr_vs"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6BA1
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_vta_intake
			"Vxx_tctr_vta_intake"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6BA2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_vvt_int_ev
			"Vxx_tctr_vvt_int_ev"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6BA3
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_vvt_int_old_off
			"Vxx_tctr_vvt_int_old_off"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B8D
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_vvt_intake
			"Vxx_tctr_vvt_intake"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6BA4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_vvtc_toth_3
			"Vxx_tctr_vvtc_toth_3"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6B8E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tctr_wgc
			"Vxx_tctr_wgc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6BA5
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tdc0_map
			"Vxx_tdc0_map"
			UWORD
			F_3v7_p103_37
			2
			2
			103
			242582.5
			ECU_ADDRESS 0xFFFF806C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tdc0_raw_map
			"Vxx_tdc0_raw_map"
			UWORD
			F_0v925_p103_345
			2
			2
			103
			60722.875
			ECU_ADDRESS 0xFFFF806E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tdc0_raw_spg
			"Vxx_tdc0_raw_spg"
			UWORD
			F_0v925_p103_345
			2
			2
			103
			60722.875
			ECU_ADDRESS 0xFFFF84FC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tdc0_spg
			"Vxx_tdc0_spg"
			UWORD
			F_3v7_p103_37
			2
			2
			103
			242582.5
			ECU_ADDRESS 0xFFFF84FE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tdc1_raw_map
			"Vxx_tdc1_raw_map"
			UWORD
			F_0v925_p103_345
			2
			2
			103
			60722.875
			ECU_ADDRESS 0xFFFF8070
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tdc1_raw_spg
			"Vxx_tdc1_raw_spg"
			UWORD
			F_0v925_p103_345
			2
			2
			103
			60722.875
			ECU_ADDRESS 0xFFFF8500
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tdc1_spg
			"Vxx_tdc1_spg"
			UWORD
			F_3v7_p103_37
			2
			2
			103
			242582.5
			ECU_ADDRESS 0xFFFF8502
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tdc2_map
			"Vxx_tdc2_map"
			UWORD
			F_3v7_p103_37
			2
			2
			103
			242582.5
			ECU_ADDRESS 0xFFFF8072
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tdc2_raw_map
			"Vxx_tdc2_raw_map"
			UWORD
			F_0v925_p103_345
			2
			2
			103
			60722.875
			ECU_ADDRESS 0xFFFF8074
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tdc2_raw_spg
			"Vxx_tdc2_raw_spg"
			UWORD
			F_0v925_p103_345
			2
			2
			103
			60722.875
			ECU_ADDRESS 0xFFFF8504
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tdc2_spg
			"Vxx_tdc2_spg"
			UWORD
			F_3v7_p103_37
			2
			2
			103
			242582.5
			ECU_ADDRESS 0xFFFF8506
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tdc3_map
			"Vxx_tdc3_map"
			UWORD
			F_3v7_p103_37
			2
			2
			103
			242582.5
			ECU_ADDRESS 0xFFFF8076
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tdc3_spg
			"Vxx_tdc3_spg"
			UWORD
			F_3v7_p103_37
			2
			2
			103
			242582.5
			ECU_ADDRESS 0xFFFF8508
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tdc4_map
			"Vxx_tdc4_map"
			UWORD
			F_3v7_p103_37
			2
			2
			103
			242582.5
			ECU_ADDRESS 0xFFFF8078
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tdc4_spg
			"Vxx_tdc4_spg"
			UWORD
			F_3v7_p103_37
			2
			2
			103
			242582.5
			ECU_ADDRESS 0xFFFF850A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tdc_ctr
			"Vxx_tdc_ctr"
			UWORD
			F_1_p0_53
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7FAC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_temp_ac_dsb_dly
			"Vxx_temp_ac_dsb_dly"
			UBYTE
			F_128_p0_125
			2
			2
			0
			32640
			ECU_ADDRESS 0xFFFF7465
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tempo_alti_upd
			"Vxx_tempo_alti_upd"
			ULONG
			F_0v128_p0_75
			2
			2
			0
			549755813.8
			ECU_ADDRESS 0xFFFF6C2C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_thd_n_ovn
			"Vxx_thd_n_ovn"
			UWORD
			F_1_p0_14
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF845C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_thd_n_ovn_bas
			"Vxx_thd_n_ovn_bas"
			UBYTE
			F_32_p0_46
			2
			2
			0
			8160
			ECU_ADDRESS 0xFFFF834C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_thpl_dsb_dly
			"Vxx_thpl_dsb_dly"
			UBYTE
			F_1v024_p0_119
			2
			2
			0
			261.12
			ECU_ADDRESS 0xFFFF82E2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_thpl_el_csm_clc_dly
			"Vxx_thpl_el_csm_clc_dly"
			UBYTE
			F_128_p0_125
			2
			2
			0
			32640
			ECU_ADDRESS 0xFFFF82E3
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_thpl_el_csm_vb
			"Vxx_thpl_el_csm_vb"
			UBYTE
			F_0v032_p8_130
			2
			2
			8
			16.16
			ECU_ADDRESS 0xFFFF82E4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_thpl_fil_vb
			"Vxx_thpl_fil_vb"
			UWORD
			F_0v000125_p8_7
			2
			2
			8
			16.191875
			ECU_ADDRESS 0xFFFF82E8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_thpl_is_cor
			"Vxx_thpl_is_cor"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7A12
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_thpl_is_cor_dly
			"Vxx_thpl_is_cor_dly"
			UBYTE
			F_16_p0_10
			2
			2
			0
			4080
			ECU_ADDRESS 0xFFFF79D3
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_thpl_min_is_n
			"Vxx_thpl_min_is_n"
			UBYTE
			F_16_p0_83
			2
			2
			0
			4080
			ECU_ADDRESS 0xFFFF8104
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_thpl_min_tia
			"Vxx_thpl_min_tia"
			UBYTE
			F_0v625_m40_131
			2
			2
			-40
			119.375
			ECU_ADDRESS 0xFFFF82E5
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_thpl_neg_el_csm_ctr
			"Vxx_thpl_neg_el_csm_ctr"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF82EA
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_thpl_nr
			"Vxx_thpl_nr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF82E6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_thpl_nr_i_1
			"Vxx_thpl_nr_i_1"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF79D4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_thpl_off_dly
			"Vxx_thpl_off_dly"
			UBYTE
			F_128_p0_125
			2
			2
			0
			32640
			ECU_ADDRESS 0xFFFF82E7
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_thpl_per
			"Vxx_thpl_per"
			UWORD
			F_0v0032_p0_8
			2
			2
			0
			209.712
			ECU_ADDRESS 0xFFFF82EC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_thpl_pos_el_csm_ctr
			"Vxx_thpl_pos_el_csm_ctr"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF82EE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_thpl_puls
			"Vxx_thpl_puls"
			UWORD
			F_0v0032_p0_8
			2
			2
			0
			209.712
			ECU_ADDRESS 0xFFFF82F0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_thr_acel_req
			"Vxx_thr_acel_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8314
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_thr_ar_maf
			"Vxx_thr_ar_maf"
			UWORD
			F_7v8125_p0_410
			2
			2
			0
			511992.1875
			ECU_ADDRESS 0xFFFF845E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_thr_ar_sp
			"Vxx_thr_ar_sp"
			UWORD
			F_0v0596046448_p0_151
			2
			2
			0
			3906.190395
			ECU_ADDRESS 0xFFFF8460
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_thr_bch_auto_sp
			"Vxx_thr_bch_auto_sp"
			UWORD
			F_0v09765625_p0_71
			2
			2
			0
			6399.902344
			ECU_ADDRESS 0xFFFF7788
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_thr_chk_lh_ctr
			"Vxx_thr_chk_lh_ctr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF76B7
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_thr_chk_lh_dly
			"Vxx_thr_chk_lh_dly"
			UBYTE
			F_8v192_p0_248
			2
			2
			0
			2088.96
			ECU_ADDRESS 0xFFFF76B8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_thr_dft_eng_max_n
			"Vxx_thr_dft_eng_max_n"
			UWORD
			F_1_p0_14
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF813A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_thr_lh_chk_tempo
			"Vxx_thr_lh_chk_tempo"
			UBYTE
			F_32_p0_122
			2
			2
			0
			8160
			ECU_ADDRESS 0xFFFF76B9
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_thr_maf_sp
			"Vxx_thr_maf_sp"
			UWORD
			F_0v0000152588_p0_27
			2
			2
			0
			0.999985458
			ECU_ADDRESS 0xFFFF8462
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_thr_maf_sp_vvt_off
			"Vxx_thr_maf_sp_vvt_off"
			UWORD
			F_0v0152587891_p0_384
			2
			2
			0
			999.9847412
			ECU_ADDRESS 0xFFFF8464
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_thr_mcut_svkl_frz_dly
			"Vxx_thr_mcut_svkl_frz_dly"
			UBYTE
			F_2_p0_249
			2
			2
			0
			510
			ECU_ADDRESS 0xFFFF76BA
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_thr_mcut_thd_ctr
			"Vxx_thr_mcut_thd_ctr"
			UBYTE
			F_1_p0_9
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF76BB
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_thr_mcut_voltage
			"Vxx_thr_mcut_voltage"
			UWORD
			F_0v625_m20480_132
			2
			2
			-20480
			20479.375
			ECU_ADDRESS 0xFFFF778A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_thr_pos
			"Vxx_thr_pos"
			UBYTE
			F_0v4_p0_106
			2
			2
			0
			102
			ECU_ADDRESS 0xFFFF76BC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_thr_pos_ref_lim
			"Vxx_thr_pos_ref_lim"
			UWORD
			F_0v048828125_p0_199
			2
			2
			0
			3199.951172
			ECU_ADDRESS 0xFFFF778C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_thr_psn_dif
			"Vxx_thr_psn_dif"
			UBYTE
			F_0v4_p0_106
			2
			2
			0
			102
			ECU_ADDRESS 0xFFFF7EFE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_thr_psn_mdl
			"Vxx_thr_psn_mdl"
			UWORD
			F_0v097656_p0_5
			2
			2
			0
			6399.88596
			ECU_ADDRESS 0xFFFF7A56
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_thr_psn_sp
			"Vxx_thr_psn_sp"
			UWORD
			F_0v097656_p0_5
			2
			2
			0
			6399.88596
			ECU_ADDRESS 0xFFFF8466
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_thr_psn_sp_tact
			"Vxx_thr_psn_sp_tact"
			UWORD
			F_0v097656_p0_5
			2
			2
			0
			6399.88596
			ECU_ADDRESS 0xFFFF82D6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_thr_sens_shift_diag_dly
			"Vxx_thr_sens_shift_diag_dly"
			UBYTE
			F_2_p0_249
			2
			2
			0
			510
			ECU_ADDRESS 0xFFFF76BD
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_thr_sge_dsb_dly
			"Vxx_thr_sge_dsb_dly"
			UWORD
			F_2_p0_249
			2
			2
			0
			131070
			ECU_ADDRESS 0xFFFF778E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_thr_sge_err
			"Vxx_thr_sge_err"
			ULONG
			F_0v09765625_p0_71
			2
			2
			0
			419430399.9
			ECU_ADDRESS 0xFFFF7684
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_thr_sge_err_dly
			"Vxx_thr_sge_err_dly"
			UWORD
			F_2_p0_249
			2
			2
			0
			131070
			ECU_ADDRESS 0xFFFF7790
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_thr_sge_err_lsb
			"Vxx_thr_sge_err_lsb"
			UWORD
			F_0v09765625_p0_71
			2
			2
			0
			6399.902344
			ECU_ADDRESS 0xFFFF7686
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_thr_sge_err_msb
			"Vxx_thr_sge_err_msb"
			UWORD
			F_6400_p0_411
			2
			2
			0
			419424000
			ECU_ADDRESS 0xFFFF7684
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_thr_sge_fil_psn_sp
			"Vxx_thr_sge_fil_psn_sp"
			UWORD
			F_0v0015259_p0_92
			2
			2
			0
			99.9998565
			ECU_ADDRESS 0xFFFF7792
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_thr_sge_fil_psn_sp_memory
			"Vxx_thr_sge_fil_psn_sp_memory"
			UWORD
			F_0v0015259_p0_92
			2
			2
			0
			99.9998565
			ECU_ADDRESS 0xFFFF7794
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_thr_sge_fil_psn_sp_prec_1
			"Vxx_thr_sge_fil_psn_sp_prec_1"
			UWORD
			F_0v0015259_p0_92
			2
			2
			0
			99.9998565
			ECU_ADDRESS 0xFFFF7796
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_thr_sge_svkl_ol_dly
			"Vxx_thr_sge_svkl_ol_dly"
			UWORD
			F_2_p0_249
			2
			2
			0
			131070
			ECU_ADDRESS 0xFFFF7798
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ti_ad_fac
			"Vxx_ti_ad_fac"
			UBYTE
			F_0v39_p0_292
			2
			2
			0
			99.45
			ECU_ADDRESS 0xFFFF7AED
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ti_ad_ofs
			"Vxx_ti_ad_ofs"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7AEE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ti_b_0
			"Vxx_ti_b_0"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7ABB
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ti_b_1
			"Vxx_ti_b_1"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7ABC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ti_b_2
			"Vxx_ti_b_2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7ABD
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ti_b_3
			"Vxx_ti_b_3"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7ABE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ti_b_4
			"Vxx_ti_b_4"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7ABF
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ti_cor_eai_tdc_ctr
			"Vxx_ti_cor_eai_tdc_ctr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7AEF
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ti_cylr_mem
			"Vxx_ti_cylr_mem"
			UBYTE
			F_0v816_p0_412
			2
			2
			0
			208.08
			ECU_ADDRESS 0xFFFF6BD8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ti_i2_cor
			"Vxx_ti_i2_cor"
			SWORD
			Id_0x00
			2
			2
			-32768
			32767
			ECU_ADDRESS 0xFFFF7B0C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ti_i_cor
			"Vxx_ti_i_cor"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7AF0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ti_ofs2_cor
			"Vxx_ti_ofs2_cor"
			SWORD
			Id_0x00
			2
			2
			-32768
			32767
			ECU_ADDRESS 0xFFFF7B10
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ti_ofs_cor
			"Vxx_ti_ofs_cor"
			SWORD
			Id_0x00
			2
			2
			-32768
			32767
			ECU_ADDRESS 0xFFFF7B0E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ti_p2_cor
			"Vxx_ti_p2_cor"
			SWORD
			Id_0x00
			2
			2
			-32768
			32767
			ECU_ADDRESS 0xFFFF7B12
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ti_p_cor
			"Vxx_ti_p_cor"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7AF1
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ti_p_cor_lean1
			"Vxx_ti_p_cor_lean1"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7AF2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ti_p_cor_lean2
			"Vxx_ti_p_cor_lean2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7AF3
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ti_sum
			"Vxx_ti_sum"
			ULONG
			F_4_p0_149
			2
			2
			0
			1.717986918E+010
			ECU_ADDRESS 0xFFFF75AC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ti_sum_mux
			"Vxx_ti_sum_mux"
			UBYTE
			F_80_p0_413
			2
			2
			0
			20400
			ECU_ADDRESS 0xFFFF7358
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ti_sum_mux_2
			"Vxx_ti_sum_mux_2"
			ULONG
			F_4_p0_149
			2
			2
			0
			1.717986918E+010
			ECU_ADDRESS 0xFFFF73A4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ti_sum_mux_2_lpg
			"Vxx_ti_sum_mux_2_lpg"
			ULONG
			F_4_p0_149
			2
			2
			0
			1.717986918E+010
			ECU_ADDRESS 0xFFFF73A8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ti_sum_mux_gas
			"Vxx_ti_sum_mux_gas"
			UBYTE
			F_80_p0_413
			2
			2
			0
			20400
			ECU_ADDRESS 0xFFFF7359
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ti_sum_mux_lpg
			"Vxx_ti_sum_mux_lpg"
			UBYTE
			F_80_p0_413
			2
			2
			0
			20400
			ECU_ADDRESS 0xFFFF735A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_ti_zon_nr
			"Vxx_ti_zon_nr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7AF4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tia
			"Vxx_tia"
			UBYTE
			F_0v625_m40_25
			2
			2
			-40
			119.375
			ECU_ADDRESS 0xFFFF6D0F
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tia_iga_cor
			"Vxx_tia_iga_cor"
			SBYTE
			F_0v375_p0_29
			2
			2
			-48
			47.625
			ECU_ADDRESS 0xFFFF6D98
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tia_inj_cor
			"Vxx_tia_inj_cor"
			UBYTE
			F_0v392156_p0_414
			2
			2
			0
			99.99978
			ECU_ADDRESS 0xFFFF7AF5
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tkof_ac_dsb_dly
			"Vxx_tkof_ac_dsb_dly"
			UBYTE
			F_1v024_p0_119
			2
			2
			0
			261.12
			ECU_ADDRESS 0xFFFF7466
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tkof_driv_eng_tq
			"Vxx_tkof_driv_eng_tq"
			UWORD
			F_0v0078125_m100_35
			2
			2
			-100
			411.9921875
			ECU_ADDRESS 0xFFFF8468
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tkof_efy_eng_tq
			"Vxx_tkof_efy_eng_tq"
			UWORD
			F_0v0078125_m100_35
			2
			2
			-100
			411.9921875
			ECU_ADDRESS 0xFFFF846A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tkof_n_dif
			"Vxx_tkof_n_dif"
			UWORD
			F_1_m4096_65
			2
			2
			-4096
			61439
			ECU_ADDRESS 0xFFFF82A6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tkof_n_dif_drv
			"Vxx_tkof_n_dif_drv"
			UWORD
			F_1_m8192_66
			2
			2
			-8192
			57343
			ECU_ADDRESS 0xFFFF82A8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tkof_n_dif_prec
			"Vxx_tkof_n_dif_prec"
			UWORD
			F_1_m4096_65
			2
			2
			-4096
			61439
			ECU_ADDRESS 0xFFFF82AA
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tkof_n_sp
			"Vxx_tkof_n_sp"
			UWORD
			F_1_p0_14
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7814
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tkof_raw_tq_abst_agb
			"Vxx_tkof_raw_tq_abst_agb"
			UBYTE
			F_2_m100_36
			2
			2
			-100
			410
			ECU_ADDRESS 0xFFFF834D
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tkof_tq_cor
			"Vxx_tkof_tq_cor"
			SWORD
			F_0v0078125_p0_15
			2
			2
			-256
			255.9921875
			ECU_ADDRESS 0xFFFF8364
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tlz_ad_b1_ctr_tdc
			"Vxx_tlz_ad_b1_ctr_tdc"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF88D6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tlz_ad_b1_dif
			"Vxx_tlz_ad_b1_dif"
			SLONG
			Id_0x00
			2
			2
			-2147483648
			2147483647
			ECU_ADDRESS 0xFFFF757C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tlz_ad_b1_fil
			"Vxx_tlz_ad_b1_fil"
			SLONG
			Id_0x00
			2
			2
			-2147483648
			2147483647
			ECU_ADDRESS 0xFFFF7580
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tlz_ad_b1_fil_1
			"Vxx_tlz_ad_b1_fil_1"
			SLONG
			F_1_p0_9
			2
			2
			-2147483648
			2147483647
			ECU_ADDRESS 0xFFFF7544
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tlz_ad_b1_fil_2
			"Vxx_tlz_ad_b1_fil_2"
			SLONG
			F_1_p0_9
			2
			2
			-2147483648
			2147483647
			ECU_ADDRESS 0xFFFF7548
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tlz_ad_b1_fil_3
			"Vxx_tlz_ad_b1_fil_3"
			SLONG
			F_1_p0_9
			2
			2
			-2147483648
			2147483647
			ECU_ADDRESS 0xFFFF754C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tlz_ad_b1_fil_4
			"Vxx_tlz_ad_b1_fil_4"
			SLONG
			F_1_p0_9
			2
			2
			-2147483648
			2147483647
			ECU_ADDRESS 0xFFFF7550
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tlz_ad_b1_fil_5
			"Vxx_tlz_ad_b1_fil_5"
			SLONG
			F_1_p0_9
			2
			2
			-2147483648
			2147483647
			ECU_ADDRESS 0xFFFF7554
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tlz_ad_b1_fil_6
			"Vxx_tlz_ad_b1_fil_6"
			SLONG
			F_1_p0_9
			2
			2
			-2147483648
			2147483647
			ECU_ADDRESS 0xFFFF7558
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tlz_ad_b1_fil_prev
			"Vxx_tlz_ad_b1_fil_prev"
			SLONG
			Id_0x00
			2
			2
			-2147483648
			2147483647
			ECU_ADDRESS 0xFFFF7584
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tlz_ad_b2_ctr_tdc
			"Vxx_tlz_ad_b2_ctr_tdc"
			UWORD
			F_1_p0_53
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF88D8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tlz_ad_b2_dif
			"Vxx_tlz_ad_b2_dif"
			SLONG
			Id_0x00
			2
			2
			-2147483648
			2147483647
			ECU_ADDRESS 0xFFFF7588
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tlz_ad_b2_fil
			"Vxx_tlz_ad_b2_fil"
			SLONG
			Id_0x00
			2
			2
			-2147483648
			2147483647
			ECU_ADDRESS 0xFFFF758C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tlz_ad_b2_fil_1
			"Vxx_tlz_ad_b2_fil_1"
			SLONG
			F_1_p0_9
			2
			2
			-2147483648
			2147483647
			ECU_ADDRESS 0xFFFF755C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tlz_ad_b2_fil_2
			"Vxx_tlz_ad_b2_fil_2"
			SLONG
			F_1_p0_9
			2
			2
			-2147483648
			2147483647
			ECU_ADDRESS 0xFFFF7560
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tlz_ad_b2_fil_3
			"Vxx_tlz_ad_b2_fil_3"
			SLONG
			F_1_p0_9
			2
			2
			-2147483648
			2147483647
			ECU_ADDRESS 0xFFFF7564
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tlz_ad_b2_fil_4
			"Vxx_tlz_ad_b2_fil_4"
			SLONG
			F_1_p0_9
			2
			2
			-2147483648
			2147483647
			ECU_ADDRESS 0xFFFF7568
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tlz_ad_b2_fil_5
			"Vxx_tlz_ad_b2_fil_5"
			SLONG
			F_1_p0_9
			2
			2
			-2147483648
			2147483647
			ECU_ADDRESS 0xFFFF756C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tlz_ad_b2_fil_6
			"Vxx_tlz_ad_b2_fil_6"
			SLONG
			F_1_p0_9
			2
			2
			-2147483648
			2147483647
			ECU_ADDRESS 0xFFFF7570
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tlz_ad_b2_fil_prev
			"Vxx_tlz_ad_b2_fil_prev"
			SLONG
			Id_0x00
			2
			2
			-2147483648
			2147483647
			ECU_ADDRESS 0xFFFF7590
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tlz_ad_b_ctr_tdc
			"Vxx_tlz_ad_b_ctr_tdc"
			UWORD
			F_1_p0_53
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7540
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tlz_ad_b_dif
			"Vxx_tlz_ad_b_dif"
			SLONG
			Id_0x00
			2
			2
			-2147483648
			2147483647
			ECU_ADDRESS 0xFFFF7574
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tlz_ad_b_dif_sw
			"Vxx_tlz_ad_b_dif_sw"
			SWORD
			F_65536_p0_396
			2
			2
			-2147483648
			2147418112
			ECU_ADDRESS 0xFFFF7528
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tlz_ad_b_fil
			"Vxx_tlz_ad_b_fil"
			SLONG
			Id_0x00
			2
			2
			-2147483648
			2147483647
			ECU_ADDRESS 0xFFFF7578
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tlz_ad_b_fil_sw
			"Vxx_tlz_ad_b_fil_sw"
			SWORD
			F_65536_p0_396
			2
			2
			-2147483648
			2147418112
			ECU_ADDRESS 0xFFFF752A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tlz_ad_b_ok
			"Vxx_tlz_ad_b_ok"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF88DB
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tlz_ad_b_slow_ctr_tdc
			"Vxx_tlz_ad_b_slow_ctr_tdc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7521
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tlz_ad_b_stt1_ena
			"Vxx_tlz_ad_b_stt1_ena"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7522
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tlz_ad_b_stt2_ena
			"Vxx_tlz_ad_b_stt2_ena"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7523
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tlz_ad_b_stt3_ena
			"Vxx_tlz_ad_b_stt3_ena"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7524
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tlz_ad_bkp
			"Vxx_tlz_ad_bkp"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7525
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tlz_ad_bkp_last
			"Vxx_tlz_ad_bkp_last"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF88EE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tlz_ad_cor_ctr_tdc
			"Vxx_tlz_ad_cor_ctr_tdc"
			UWORD
			F_1_p0_53
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF88E0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tlz_ad_cor_dif
			"Vxx_tlz_ad_cor_dif"
			SLONG
			Id_0x00
			2
			2
			-2147483648
			2147483647
			ECU_ADDRESS 0xFFFF7594
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tlz_ad_cor_fil
			"Vxx_tlz_ad_cor_fil"
			SWORD
			Id_0x00
			2
			2
			-32768
			32767
			ECU_ADDRESS 0xFFFF88DE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tlz_ad_cor_val
			"Vxx_tlz_ad_cor_val"
			SWORD
			Id_0x00
			2
			2
			-32768
			32767
			ECU_ADDRESS 0xFFFF88DC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tlz_b1_val
			"Vxx_tlz_b1_val"
			SWORD
			F_1_p0_9
			2
			2
			-32768
			32767
			ECU_ADDRESS 0xFFFF752E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tlz_b2_val
			"Vxx_tlz_b2_val"
			SWORD
			F_1_p0_9
			2
			2
			-32768
			32767
			ECU_ADDRESS 0xFFFF7530
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tlz_b_cor
			"Vxx_tlz_b_cor"
			SLONG
			F_1_p0_235
			2
			2
			-2147483648
			2147483647
			ECU_ADDRESS 0xFFFF7598
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tlz_b_val
			"Vxx_tlz_b_val"
			SWORD
			F_1_p0_9
			2
			2
			-32768
			32767
			ECU_ADDRESS 0xFFFF752C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tlz_clc_stt
			"Vxx_tlz_clc_stt"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7526
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tlz_cor_tmp
			"Vxx_tlz_cor_tmp"
			SLONG
			Id_0x00
			2
			2
			-2147483648
			2147483647
			ECU_ADDRESS 0xFFFF759C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tlz_raw_val
			"Vxx_tlz_raw_val"
			SWORD
			F_0v1_p0_22
			2
			2
			-3276.8
			3276.7
			ECU_ADDRESS 0xFFFF7532
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tlz_val
			"Vxx_tlz_val"
			SWORD
			F_0v1_p0_22
			2
			2
			-3276.8
			3276.7
			ECU_ADDRESS 0xFFFF7534
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tlz_val_tmp
			"Vxx_tlz_val_tmp"
			SLONG
			Id_0x00
			2
			2
			-2147483648
			2147483647
			ECU_ADDRESS 0xFFFF75A0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tmp_aj_driv_tqe_sp
			"Vxx_tmp_aj_driv_tqe_sp"
			UWORD
			F_0v0078125_m100_35
			2
			2
			-100
			411.9921875
			ECU_ADDRESS 0xFFFF846C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tmp_csm
			"Vxx_tmp_csm"
			UWORD
			F_0v01_p0_356
			2
			2
			0
			655.35
			ECU_ADDRESS 0xFFFF75A8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_toil
			"Vxx_toil"
			UWORD
			F_0v625_m40_25
			2
			2
			-40
			40919.375
			ECU_ADDRESS 0xFFFF7CE4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_toil_is_n_ofs
			"Vxx_toil_is_n_ofs"
			UBYTE
			F_16_p0_83
			2
			2
			0
			4080
			ECU_ADDRESS 0xFFFF8105
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_toil_mem
			"Vxx_toil_mem"
			ULONG
			F_0v0000095367_m40_415
			2
			2
			-40
			40919.99999
			ECU_ADDRESS 0xFFFF7CDC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tot_tq_loss_1
			"Vxx_tot_tq_loss_1"
			UBYTE
			F_2_m100_36
			2
			2
			-100
			410
			ECU_ADDRESS 0xFFFF834E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tot_tq_loss_2
			"Vxx_tot_tq_loss_2"
			UWORD
			F_0v0078125_p0_15
			2
			2
			0
			511.9921875
			ECU_ADDRESS 0xFFFF846E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tq_abst_agb
			"Vxx_tq_abst_agb"
			UBYTE
			F_2_m100_36
			2
			2
			-100
			410
			ECU_ADDRESS 0xFFFF834F
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tq_d_cor
			"Vxx_tq_d_cor"
			SWORD
			F_0v0078125_p0_15
			2
			2
			-256
			255.9921875
			ECU_ADDRESS 0xFFFF8366
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tq_dec
			"Vxx_tq_dec"
			SWORD
			F_0v1_p0_22
			2
			2
			-3276.8
			3276.7
			ECU_ADDRESS 0xFFFF6BDA
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tq_dyn_ref
			"Vxx_tq_dyn_ref"
			UWORD
			F_0v0078125_m100_35
			2
			2
			-100
			411.9921875
			ECU_ADDRESS 0xFFFF8470
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tq_efy_degr
			"Vxx_tq_efy_degr"
			UWORD
			F_0v00097656_p0_325
			2
			2
			0
			63.9988596
			ECU_ADDRESS 0xFFFF8472
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tq_inrt_rat
			"Vxx_tq_inrt_rat"
			SWORD
			F_0v15259_p0_416
			2
			2
			-5000.06912
			4999.91653
			ECU_ADDRESS 0xFFFF77FC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tq_inrt_rat_temp1
			"Vxx_tq_inrt_rat_temp1"
			SWORD
			F_0v15259_p0_416
			2
			2
			-5000.06912
			4999.91653
			ECU_ADDRESS 0xFFFF77FE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tq_inrt_rat_temp2
			"Vxx_tq_inrt_rat_temp2"
			SWORD
			F_0v15259_p0_416
			2
			2
			-5000.06912
			4999.91653
			ECU_ADDRESS 0xFFFF7800
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tq_lim_iga
			"Vxx_tq_lim_iga"
			UBYTE
			F_0v375_m23v625_6
			2
			2
			-23.625
			72
			ECU_ADDRESS 0xFFFF7A33
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tq_ovn_cor
			"Vxx_tq_ovn_cor"
			UWORD
			F_0v0078125_p0_15
			2
			2
			0
			511.9921875
			ECU_ADDRESS 0xFFFF8474
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tq_ovn_fac
			"Vxx_tq_ovn_fac"
			UBYTE
			F_0v00390625_p0_90
			2
			2
			0
			0.99609375
			ECU_ADDRESS 0xFFFF8350
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tq_ovn_mpl_fac
			"Vxx_tq_ovn_mpl_fac"
			UBYTE
			F_0v00390625_p1_100
			2
			2
			1
			1.99609375
			ECU_ADDRESS 0xFFFF8351
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tq_p_cor
			"Vxx_tq_p_cor"
			SWORD
			F_0v0078125_p0_15
			2
			2
			-256
			255.9921875
			ECU_ADDRESS 0xFFFF8368
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tq_rat_ovn
			"Vxx_tq_rat_ovn"
			UBYTE
			F_0v390625_p0_4
			2
			2
			0
			99.609375
			ECU_ADDRESS 0xFFFF8352
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tq_rat_ovn_eol
			"Vxx_tq_rat_ovn_eol"
			UBYTE
			F_0v390625_p0_4
			2
			2
			0
			99.609375
			ECU_ADDRESS 0xFFFF8353
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tq_rat_sp
			"Vxx_tq_rat_sp"
			UBYTE
			F_0v390625_p0_4
			2
			2
			0
			99.609375
			ECU_ADDRESS 0xFFFF8354
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tq_stat_ref
			"Vxx_tq_stat_ref"
			UWORD
			F_0v0078125_m100_35
			2
			2
			-100
			411.9921875
			ECU_ADDRESS 0xFFFF8476
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tq_thr_ar_sp
			"Vxx_tq_thr_ar_sp"
			UWORD
			F_0v0596046448_p0_151
			2
			2
			0
			3906.190395
			ECU_ADDRESS 0xFFFF8478
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tqr_ct_fac
			"Vxx_tqr_ct_fac"
			UBYTE
			F_0v390625_p0_4
			2
			2
			0
			99.609375
			ECU_ADDRESS 0xFFFF6DC7
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tqr_decl_acel_jerk
			"Vxx_tqr_decl_acel_jerk"
			UWORD
			F_0v0015258789_p0_115
			2
			2
			0
			99.99847412
			ECU_ADDRESS 0xFFFF6DDE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tqr_fast_cut_bas_fac
			"Vxx_tqr_fast_cut_bas_fac"
			UBYTE
			F_0v390625_p0_4
			2
			2
			0
			99.609375
			ECU_ADDRESS 0xFFFF6DC8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tqr_fast_cut_decl
			"Vxx_tqr_fast_cut_decl"
			UWORD
			F_0v00152588_p0_107
			2
			2
			0
			99.9985458
			ECU_ADDRESS 0xFFFF6DE0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tqr_fast_cut_fac
			"Vxx_tqr_fast_cut_fac"
			UBYTE
			F_0v390625_p0_4
			2
			2
			0
			99.609375
			ECU_ADDRESS 0xFFFF6DC9
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tqr_fast_swi_ctr
			"Vxx_tqr_fast_swi_ctr"
			UBYTE
			F_0v390625_p0_4
			2
			2
			0
			99.609375
			ECU_ADDRESS 0xFFFF6DCA
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_tqr_fast_thr_ct
			"Vxx_tqr_fast_thr_ct"
			UWORD
			F_0v0015258789_p0_115
			2
			2
			0
			99.99847412
			ECU_ADDRESS 0xFFFF6DE2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_trs_cl_ti_fac_mem
			"Vxx_trs_cl_ti_fac_mem"
			UBYTE
			F_0v390625_p0_4
			2
			2
			0
			99.609375
			ECU_ADDRESS 0xFFFF7AF6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_trt_sp
			"Vxx_trt_sp"
			UWORD
			F_0v048828125_p0_199
			2
			2
			0
			3199.951172
			ECU_ADDRESS 0xFFFF779A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_trz_ad_b1_dif
			"Vxx_trz_ad_b1_dif"
			SWORD
			Id_0x00
			2
			2
			-32768
			32767
			ECU_ADDRESS 0xFFFF7536
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_trz_ad_b1_fil
			"Vxx_trz_ad_b1_fil"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF8614
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_trz_ad_b1_val
			"Vxx_trz_ad_b1_val"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF8610
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_trz_ad_b2_dif
			"Vxx_trz_ad_b2_dif"
			SWORD
			Id_0x00
			2
			2
			-32768
			32767
			ECU_ADDRESS 0xFFFF7538
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_trz_ad_b2_fil
			"Vxx_trz_ad_b2_fil"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF8616
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_trz_ad_b2_val
			"Vxx_trz_ad_b2_val"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF8612
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_trz_ad_b_ctr_tdc
			"Vxx_trz_ad_b_ctr_tdc"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF8618
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_trz_ad_b_ok
			"Vxx_trz_ad_b_ok"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF74FE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_trz_cor
			"Vxx_trz_cor"
			SWORD
			F_0v1_p0_22
			2
			2
			-3276.8
			3276.7
			ECU_ADDRESS 0xFFFF753A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_trz_cylr_mem
			"Vxx_trz_cylr_mem"
			SWORD
			F_0v1_p0_22
			2
			2
			-3276.8
			3276.7
			ECU_ADDRESS 0xFFFF6BDC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_trz_raw_val
			"Vxx_trz_raw_val"
			SWORD
			F_0v1_p0_22
			2
			2
			-3276.8
			3276.7
			ECU_ADDRESS 0xFFFF753C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_trz_t_toth_0
			"Vxx_trz_t_toth_0"
			ULONG
			F_0v1_p0_275
			2
			2
			0
			429496729.5
			ECU_ADDRESS 0xFFFF7500
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_trz_t_toth_0_lsb
			"Vxx_trz_t_toth_0_lsb"
			UWORD
			F_0v1_p0_275
			2
			2
			0
			6553.5
			ECU_ADDRESS 0xFFFF7502
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_trz_t_toth_0_msb
			"Vxx_trz_t_toth_0_msb"
			UWORD
			F_6v5536_p0_274
			2
			2
			0
			429490.176
			ECU_ADDRESS 0xFFFF7500
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_trz_t_toth_1
			"Vxx_trz_t_toth_1"
			ULONG
			F_0v1_p0_275
			2
			2
			0
			429496729.5
			ECU_ADDRESS 0xFFFF7504
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_trz_t_toth_1_lsb
			"Vxx_trz_t_toth_1_lsb"
			UWORD
			F_0v1_p0_275
			2
			2
			0
			6553.5
			ECU_ADDRESS 0xFFFF7506
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_trz_t_toth_1_msb
			"Vxx_trz_t_toth_1_msb"
			UWORD
			F_6v5536_p0_274
			2
			2
			0
			429490.176
			ECU_ADDRESS 0xFFFF7504
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_trz_t_toth_2
			"Vxx_trz_t_toth_2"
			ULONG
			F_0v1_p0_275
			2
			2
			0
			429496729.5
			ECU_ADDRESS 0xFFFF7508
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_trz_t_toth_2_lsb
			"Vxx_trz_t_toth_2_lsb"
			UWORD
			F_0v1_p0_275
			2
			2
			0
			6553.5
			ECU_ADDRESS 0xFFFF750A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_trz_t_toth_2_msb
			"Vxx_trz_t_toth_2_msb"
			UWORD
			F_6v5536_p0_274
			2
			2
			0
			429490.176
			ECU_ADDRESS 0xFFFF7508
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_trz_t_toth_3
			"Vxx_trz_t_toth_3"
			ULONG
			F_0v1_p0_275
			2
			2
			0
			429496729.5
			ECU_ADDRESS 0xFFFF750C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_trz_t_toth_3_lsb
			"Vxx_trz_t_toth_3_lsb"
			UWORD
			F_0v1_p0_275
			2
			2
			0
			6553.5
			ECU_ADDRESS 0xFFFF750E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_trz_t_toth_3_msb
			"Vxx_trz_t_toth_3_msb"
			UWORD
			F_6v5536_p0_274
			2
			2
			0
			429490.176
			ECU_ADDRESS 0xFFFF750C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_trz_t_toth_4
			"Vxx_trz_t_toth_4"
			ULONG
			F_0v1_p0_275
			2
			2
			0
			429496729.5
			ECU_ADDRESS 0xFFFF7510
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_trz_t_toth_4_lsb
			"Vxx_trz_t_toth_4_lsb"
			UWORD
			F_0v1_p0_275
			2
			2
			0
			6553.5
			ECU_ADDRESS 0xFFFF7512
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_trz_t_toth_4_msb
			"Vxx_trz_t_toth_4_msb"
			UWORD
			F_6v5536_p0_274
			2
			2
			0
			429490.176
			ECU_ADDRESS 0xFFFF7510
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_trz_t_toth_5
			"Vxx_trz_t_toth_5"
			ULONG
			F_0v1_p0_275
			2
			2
			0
			429496729.5
			ECU_ADDRESS 0xFFFF7514
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_trz_t_toth_5_lsb
			"Vxx_trz_t_toth_5_lsb"
			UWORD
			F_0v1_p0_275
			2
			2
			0
			6553.5
			ECU_ADDRESS 0xFFFF7516
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_trz_t_toth_5_msb
			"Vxx_trz_t_toth_5_msb"
			UWORD
			F_6v5536_p0_274
			2
			2
			0
			429490.176
			ECU_ADDRESS 0xFFFF7514
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_trz_t_toth_5_nxt
			"Vxx_trz_t_toth_5_nxt"
			ULONG
			F_0v1_p0_275
			2
			2
			0
			429496729.5
			ECU_ADDRESS 0xFFFF7518
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_trz_t_toth_5_nxt_lsb
			"Vxx_trz_t_toth_5_nxt_lsb"
			UWORD
			F_0v1_p0_275
			2
			2
			0
			6553.5
			ECU_ADDRESS 0xFFFF751A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_trz_t_toth_5_nxt_msb
			"Vxx_trz_t_toth_5_nxt_msb"
			UWORD
			F_6v5536_p0_274
			2
			2
			0
			429490.176
			ECU_ADDRESS 0xFFFF7518
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_trz_t_toth_6
			"Vxx_trz_t_toth_6"
			ULONG
			F_0v1_p0_275
			2
			2
			0
			429496729.5
			ECU_ADDRESS 0xFFFF751C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_trz_val
			"Vxx_trz_val"
			SWORD
			F_0v1_p0_22
			2
			2
			-3276.8
			3276.7
			ECU_ADDRESS 0xFFFF753E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_trz_val_tmp
			"Vxx_trz_val_tmp"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7542
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_up_down_thr_prs_rat
			"Vxx_up_down_thr_prs_rat"
			UWORD
			F_15v2587890625_p0_68
			2
			2
			0
			999984.7412
			ECU_ADDRESS 0xFFFF847A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_up_tbn_prs_dif
			"Vxx_up_tbn_prs_dif"
			UWORD
			F_3v7_p0_21
			2
			2
			0
			242479.5
			ECU_ADDRESS 0xFFFF850C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_up_tbn_prs_dif_fac
			"Vxx_up_tbn_prs_dif_fac"
			UBYTE
			F_1894v4_p0_26
			2
			2
			0
			483072
			ECU_ADDRESS 0xFFFF84BD
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vb_inj_dly_cor
			"Vxx_vb_inj_dly_cor"
			UBYTE
			F_8_p0_136
			2
			2
			0
			2040
			ECU_ADDRESS 0xFFFF7AF7
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_agb_rcpt
			"Vxx_vfctr_agb_rcpt"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF885C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_air
			"Vxx_vfctr_air"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF885D
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_bkup_mem
			"Vxx_vfctr_bkup_mem"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF885E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_clu
			"Vxx_vfctr_clu"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF885F
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_cp
			"Vxx_vfctr_cp"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8890
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_crk
			"Vxx_vfctr_crk"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8860
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_crk_nr
			"Vxx_vfctr_crk_nr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8861
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_eng_whl
			"Vxx_vfctr_eng_whl"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8862
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_fsys
			"Vxx_vfctr_fsys"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8863
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_fsys_lpg
			"Vxx_vfctr_fsys_lpg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8864
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_gas_pump
			"Vxx_vfctr_gas_pump"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8891
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_igc_1
			"Vxx_vfctr_igc_1"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8892
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_igc_2
			"Vxx_vfctr_igc_2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8893
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_igc_3
			"Vxx_vfctr_igc_3"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8894
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_igc_4
			"Vxx_vfctr_igc_4"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8895
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_inj1
			"Vxx_vfctr_inj1"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8896
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_inj2
			"Vxx_vfctr_inj2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8897
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_inj3
			"Vxx_vfctr_inj3"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8898
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_inj4
			"Vxx_vfctr_inj4"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8899
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_inj_ecu
			"Vxx_vfctr_inj_ecu"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8865
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_knk
			"Vxx_vfctr_knk"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8866
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_lbdw
			"Vxx_vfctr_lbdw"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF889A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_lbdw_hot
			"Vxx_vfctr_lbdw_hot"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF889B
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_lbup
			"Vxx_vfctr_lbup"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF889C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_lbup_hot
			"Vxx_vfctr_lbup_hot"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF889D
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_lpg_rcpt
			"Vxx_vfctr_lpg_rcpt"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8867
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_map
			"Vxx_vfctr_map"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8868
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_min_gas_lvl
			"Vxx_vfctr_min_gas_lvl"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8869
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_mis_cata
			"Vxx_vfctr_mis_cata"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF886A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_mis_cata_1
			"Vxx_vfctr_mis_cata_1"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF886B
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_mis_cata_1_lpg
			"Vxx_vfctr_mis_cata_1_lpg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF886C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_mis_cata_2
			"Vxx_vfctr_mis_cata_2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF886D
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_mis_cata_2_lpg
			"Vxx_vfctr_mis_cata_2_lpg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF886E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_mis_cata_3
			"Vxx_vfctr_mis_cata_3"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF886F
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_mis_cata_3_lpg
			"Vxx_vfctr_mis_cata_3_lpg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8870
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_mis_cata_4
			"Vxx_vfctr_mis_cata_4"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8871
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_mis_cata_4_lpg
			"Vxx_vfctr_mis_cata_4_lpg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8872
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_mis_cata_gas
			"Vxx_vfctr_mis_cata_gas"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8873
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_mis_cata_lpg
			"Vxx_vfctr_mis_cata_lpg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8874
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_mis_polu
			"Vxx_vfctr_mis_polu"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8875
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_mis_polu_1
			"Vxx_vfctr_mis_polu_1"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8876
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_mis_polu_1_lpg
			"Vxx_vfctr_mis_polu_1_lpg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8877
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_mis_polu_2
			"Vxx_vfctr_mis_polu_2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8878
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_mis_polu_2_lpg
			"Vxx_vfctr_mis_polu_2_lpg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8879
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_mis_polu_3
			"Vxx_vfctr_mis_polu_3"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF887A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_mis_polu_3_lpg
			"Vxx_vfctr_mis_polu_3_lpg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF887B
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_mis_polu_4
			"Vxx_vfctr_mis_polu_4"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF887C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_mis_polu_4_lpg
			"Vxx_vfctr_mis_polu_4_lpg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF887D
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_mis_polu_gas
			"Vxx_vfctr_mis_polu_gas"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF887E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_mis_polu_lpg
			"Vxx_vfctr_mis_polu_lpg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF887F
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_obd_cata
			"Vxx_vfctr_obd_cata"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8880
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_obd_lamb
			"Vxx_vfctr_obd_lamb"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8881
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_obd_sa
			"Vxx_vfctr_obd_sa"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8882
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_pow_lbdw
			"Vxx_vfctr_pow_lbdw"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8883
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_pow_lbup
			"Vxx_vfctr_pow_lbup"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8884
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_rams_pdl
			"Vxx_vfctr_rams_pdl"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8885
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_sa
			"Vxx_vfctr_sa"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF889E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_sa_ev
			"Vxx_vfctr_sa_ev"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF889F
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_spg
			"Vxx_vfctr_spg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8886
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_spg_sys
			"Vxx_vfctr_spg_sys"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8887
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_tco
			"Vxx_vfctr_tco"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF88A0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_tia
			"Vxx_vfctr_tia"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF88A1
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_tlz_ad_b
			"Vxx_vfctr_tlz_ad_b"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8888
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_vs
			"Vxx_vfctr_vs"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF88A2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_vta_intake
			"Vxx_vfctr_vta_intake"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF88A3
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_vvt_int_ev
			"Vxx_vfctr_vvt_int_ev"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF88A4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_vvt_int_old_off
			"Vxx_vfctr_vvt_int_old_off"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8889
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_vvt_intake
			"Vxx_vfctr_vvt_intake"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF88A5
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_vvtc_toth_3
			"Vxx_vfctr_vvtc_toth_3"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF888A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vfctr_wgc
			"Vxx_vfctr_wgc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF88A6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vh_min_is_n
			"Vxx_vh_min_is_n"
			UBYTE
			F_16_p0_83
			2
			2
			0
			4080
			ECU_ADDRESS 0xFFFF8106
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vs
			"Vxx_vs"
			UBYTE
			F_1_p0_58
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8292
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vs16
			"Vxx_vs16"
			UWORD
			F_0v01_p0_62
			2
			2
			0
			655.35
			ECU_ADDRESS 0xFFFF73A0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vs_n_rat
			"Vxx_vs_n_rat"
			UBYTE
			F_0v390625_p0_268
			2
			2
			0
			99.609375
			ECU_ADDRESS 0xFFFF81F7
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vs_n_rat16
			"Vxx_vs_n_rat16"
			UWORD
			F_0v0015259_p0_78
			2
			2
			0
			99.9998565
			ECU_ADDRESS 0xFFFF813C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vs_n_rat_mem
			"Vxx_vs_n_rat_mem"
			ULONG
			Id_0x00
			2
			2
			0
			4294967295
			ECU_ADDRESS 0xFFFF81B4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vs_n_rat_raw
			"Vxx_vs_n_rat_raw"
			UBYTE
			F_0v390625_p0_268
			2
			2
			0
			99.609375
			ECU_ADDRESS 0xFFFF81F8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vs_nok_prec
			"Vxx_vs_nok_prec"
			UWORD
			F_0v01_p0_62
			2
			2
			0
			655.35
			ECU_ADDRESS 0xFFFF8234
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vs_samp_per
			"Vxx_vs_samp_per"
			UWORD
			F_51v2_p0_417
			2
			2
			0
			3355392
			ECU_ADDRESS 0xFFFF82AC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vvt_fill_efv_cor
			"Vxx_vvt_fill_efv_cor"
			SWORD
			F_1_p0_418
			2
			2
			-32768
			32767
			ECU_ADDRESS 0xFFFF7B14
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vvt_fill_efv_cor_fac1
			"Vxx_vvt_fill_efv_cor_fac1"
			UWORD
			F_0v00174825_p0_51
			2
			2
			0
			114.5715638
			ECU_ADDRESS 0xFFFF7B84
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vvt_fill_efv_cor_fac2
			"Vxx_vvt_fill_efv_cor_fac2"
			SWORD
			F_0v04166_p0_419
			2
			2
			-1365.11488
			1365.07322
			ECU_ADDRESS 0xFFFF7B16
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vvt_tdc
			"Vxx_vvt_tdc"
			UBYTE
			F_1_p0_53
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6DCB
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vvt_trs_val
			"Vxx_vvt_trs_val"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF77AC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vvtc_angl_fil_fac
			"Vxx_vvtc_angl_fil_fac"
			UBYTE
			F_0v390625_p0_4
			2
			2
			0
			99.609375
			ECU_ADDRESS 0xFFFF8532
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vvtc_hot_in_angl_sp
			"Vxx_vvtc_hot_in_angl_sp"
			UBYTE
			F_0v375_p0_33
			2
			2
			0
			95.625
			ECU_ADDRESS 0xFFFF77AD
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vvtc_iga
			"Vxx_vvtc_iga"
			UBYTE
			F_0v375_m23v625_34
			2
			2
			-23.625
			72
			ECU_ADDRESS 0xFFFF6DCC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vvtc_iga_fac1
			"Vxx_vvtc_iga_fac1"
			UBYTE
			F_0v390625_p0_4
			2
			2
			0
			99.609375
			ECU_ADDRESS 0xFFFF6DCD
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vvtc_iga_fac2
			"Vxx_vvtc_iga_fac2"
			UBYTE
			F_0v390625_p0_4
			2
			2
			0
			99.609375
			ECU_ADDRESS 0xFFFF6DCE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vvtc_in_angl_sp
			"Vxx_vvtc_in_angl_sp"
			UBYTE
			F_0v375_p0_33
			2
			2
			0
			95.625
			ECU_ADDRESS 0xFFFF77AE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vvtc_in_angl_sp_fil
			"Vxx_vvtc_in_angl_sp_fil"
			UBYTE
			F_0v375_p0_29
			2
			2
			0
			95.625
			ECU_ADDRESS 0xFFFF8533
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vvtc_in_angl_sp_fil_mem
			"Vxx_vvtc_in_angl_sp_fil_mem"
			ULONG
			F_0v0014648438_p0_381
			2
			2
			0
			6291455.999
			ECU_ADDRESS 0xFFFF8524
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vvtc_off_iga
			"Vxx_vvtc_off_iga"
			UBYTE
			F_0v375_m23v625_34
			2
			2
			-23.625
			72
			ECU_ADDRESS 0xFFFF6DCF
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vvtc_off_otl_iga
			"Vxx_vvtc_off_otl_iga"
			UBYTE
			F_0v375_m23v625_34
			2
			2
			-23.625
			72
			ECU_ADDRESS 0xFFFF7A34
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vvtc_on_iga
			"Vxx_vvtc_on_iga"
			UBYTE
			F_0v375_m23v625_34
			2
			2
			-23.625
			72
			ECU_ADDRESS 0xFFFF6DD0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vvtc_on_otl_iga
			"Vxx_vvtc_on_otl_iga"
			UBYTE
			F_0v375_m23v625_34
			2
			2
			-23.625
			72
			ECU_ADDRESS 0xFFFF7A35
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_vvtc_otl_iga
			"Vxx_vvtc_otl_iga"
			UBYTE
			F_0v375_m23v625_6
			2
			2
			-23.625
			72
			ECU_ADDRESS 0xFFFF7A36
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wet_acel_decl_cor_fac
			"Vxx_wet_acel_decl_cor_fac"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7AF8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wet_aftr_sta_t
			"Vxx_wet_aftr_sta_t"
			UBYTE
			F_1v024_p0_119
			2
			2
			0
			261.12
			ECU_ADDRESS 0xFFFF7AF9
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wet_dyn_vol
			"Vxx_wet_dyn_vol"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7B86
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wet_dyn_vol_fil_fac
			"Vxx_wet_dyn_vol_fil_fac"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7AFA
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wet_dyn_vol_prev
			"Vxx_wet_dyn_vol_prev"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7B88
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wet_h_tco_eal_cor_fac
			"Vxx_wet_h_tco_eal_cor_fac"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7AFB
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wet_h_tco_eal_fil_fac
			"Vxx_wet_h_tco_eal_fil_fac"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7AFC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wet_ini_acel_cor_ofs
			"Vxx_wet_ini_acel_cor_ofs"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7AFD
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wet_ini_acel_sta_t
			"Vxx_wet_ini_acel_sta_t"
			UBYTE
			F_256_p0_142
			2
			2
			0
			65280
			ECU_ADDRESS 0xFFFF7AFE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wet_l_tco_eal_cor_fac
			"Vxx_wet_l_tco_eal_cor_fac"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7AFF
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wet_l_tco_eal_fil_fac
			"Vxx_wet_l_tco_eal_fil_fac"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7B00
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wet_stat_vol
			"Vxx_wet_stat_vol"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7B8A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wet_stat_vol_fac
			"Vxx_wet_stat_vol_fac"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7B01
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wet_tb_cor_tdc_ctr
			"Vxx_wet_tb_cor_tdc_ctr"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7B8C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wet_tdc_rat_ctr
			"Vxx_wet_tdc_rat_ctr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7B02
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wet_ti_cor
			"Vxx_wet_ti_cor"
			SWORD
			Id_0x00
			2
			2
			-32768
			32767
			ECU_ADDRESS 0xFFFF7B18
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wet_ti_cut_ctr
			"Vxx_wet_ti_cut_ctr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7B03
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wet_ti_cut_tdc_ctr
			"Vxx_wet_ti_cut_tdc_ctr"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7B8E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wet_vol_dif_thd
			"Vxx_wet_vol_dif_thd"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7B90
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_whl_angl
			"Vxx_whl_angl"
			SWORD
			F_0v04376_p0_180
			2
			2
			-1433.92768
			1433.88392
			ECU_ADDRESS 0xFFFF77CC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_whl_angl_i_1
			"Vxx_whl_angl_i_1"
			SWORD
			F_0v04376_p0_180
			2
			2
			-1433.92768
			1433.88392
			ECU_ADDRESS 0xFFFF77CE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_whl_angl_ref
			"Vxx_whl_angl_ref"
			SWORD
			F_0v04376_p0_180
			2
			2
			-1433.92768
			1433.88392
			ECU_ADDRESS 0xFFFF77D0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_whl_angl_spd
			"Vxx_whl_angl_spd"
			SWORD
			F_2v188_p0_202
			2
			2
			-71696.384
			71694.196
			ECU_ADDRESS 0xFFFF77D2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_whl_angl_spd_i_1
			"Vxx_whl_angl_spd_i_1"
			SWORD
			F_2v188_p0_202
			2
			2
			-71696.384
			71694.196
			ECU_ADDRESS 0xFFFF77D4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_whl_mov_sgn
			"Vxx_whl_mov_sgn"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF77C7
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_whl_spd_abv
			"Vxx_whl_spd_abv"
			UBYTE
			F_8v752_p0_109
			2
			2
			0
			2231.76
			ECU_ADDRESS 0xFFFF77C8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wpmp_dly
			"Vxx_wpmp_dly"
			UBYTE
			F_16v384_p0_161
			2
			2
			0
			4177.92
			ECU_ADDRESS 0xFFFF7F18
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wpmp_tco_dly
			"Vxx_wpmp_tco_dly"
			UBYTE
			F_16v384_p0_161
			2
			2
			0
			4177.92
			ECU_ADDRESS 0xFFFF7F19
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wrd_edic_ecu
			"Vxx_wrd_edic_ecu"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7E7C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wup_iga_cor_tmp
			"Vxx_wup_iga_cor_tmp"
			UBYTE
			F_0v375_m48_41
			2
			2
			-48
			47.625
			ECU_ADDRESS 0xFFFF6DD1
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_agb_rcpt
			"Vxx_wupctr_agb_rcpt"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87BE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_air
			"Vxx_wupctr_air"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87BF
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_bkup_mem
			"Vxx_wupctr_bkup_mem"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87C0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_clu
			"Vxx_wupctr_clu"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87C1
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_cp
			"Vxx_wupctr_cp"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87FE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_crk
			"Vxx_wupctr_crk"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87C2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_crk_nr
			"Vxx_wupctr_crk_nr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87C3
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_eng_whl
			"Vxx_wupctr_eng_whl"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87C4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_fsys
			"Vxx_wupctr_fsys"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87C5
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_fsys_lpg
			"Vxx_wupctr_fsys_lpg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87C6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_gas_pump
			"Vxx_wupctr_gas_pump"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87FF
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_igc_1
			"Vxx_wupctr_igc_1"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8800
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_igc_2
			"Vxx_wupctr_igc_2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8801
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_igc_3
			"Vxx_wupctr_igc_3"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8802
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_igc_4
			"Vxx_wupctr_igc_4"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8803
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_inj1
			"Vxx_wupctr_inj1"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8804
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_inj2
			"Vxx_wupctr_inj2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8805
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_inj3
			"Vxx_wupctr_inj3"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8806
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_inj4
			"Vxx_wupctr_inj4"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8807
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_inj_ecu
			"Vxx_wupctr_inj_ecu"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87C7
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_knk
			"Vxx_wupctr_knk"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87C8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_lbdw
			"Vxx_wupctr_lbdw"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8808
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_lbdw_hot
			"Vxx_wupctr_lbdw_hot"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8809
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_lbup
			"Vxx_wupctr_lbup"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF880A
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_lbup_hot
			"Vxx_wupctr_lbup_hot"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF880B
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_lpg_rcpt
			"Vxx_wupctr_lpg_rcpt"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87C9
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_map
			"Vxx_wupctr_map"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87CA
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_min_gas_lvl
			"Vxx_wupctr_min_gas_lvl"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87CB
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_mis_cata
			"Vxx_wupctr_mis_cata"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87CC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_mis_cata_1
			"Vxx_wupctr_mis_cata_1"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87CD
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_mis_cata_1_lpg
			"Vxx_wupctr_mis_cata_1_lpg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87CE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_mis_cata_2
			"Vxx_wupctr_mis_cata_2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87CF
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_mis_cata_2_lpg
			"Vxx_wupctr_mis_cata_2_lpg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87D0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_mis_cata_3
			"Vxx_wupctr_mis_cata_3"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87D1
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_mis_cata_3_lpg
			"Vxx_wupctr_mis_cata_3_lpg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87D2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_mis_cata_4
			"Vxx_wupctr_mis_cata_4"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87D3
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_mis_cata_4_lpg
			"Vxx_wupctr_mis_cata_4_lpg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87D4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_mis_cata_gas
			"Vxx_wupctr_mis_cata_gas"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87D5
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_mis_cata_lpg
			"Vxx_wupctr_mis_cata_lpg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87D6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_mis_polu
			"Vxx_wupctr_mis_polu"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87D7
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_mis_polu_1
			"Vxx_wupctr_mis_polu_1"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87D8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_mis_polu_1_lpg
			"Vxx_wupctr_mis_polu_1_lpg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87D9
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_mis_polu_2
			"Vxx_wupctr_mis_polu_2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87DA
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_mis_polu_2_lpg
			"Vxx_wupctr_mis_polu_2_lpg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87DB
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_mis_polu_3
			"Vxx_wupctr_mis_polu_3"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87DC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_mis_polu_3_lpg
			"Vxx_wupctr_mis_polu_3_lpg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87DD
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_mis_polu_4
			"Vxx_wupctr_mis_polu_4"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87DE
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_mis_polu_4_lpg
			"Vxx_wupctr_mis_polu_4_lpg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87DF
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_mis_polu_gas
			"Vxx_wupctr_mis_polu_gas"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87E0
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_mis_polu_lpg
			"Vxx_wupctr_mis_polu_lpg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87E1
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_obd_cata
			"Vxx_wupctr_obd_cata"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87E2
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_obd_lamb
			"Vxx_wupctr_obd_lamb"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87E3
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_obd_sa
			"Vxx_wupctr_obd_sa"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87E4
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_pow_lbdw
			"Vxx_wupctr_pow_lbdw"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87E5
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_pow_lbup
			"Vxx_wupctr_pow_lbup"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87E6
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_rams_pdl
			"Vxx_wupctr_rams_pdl"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87E7
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_sa
			"Vxx_wupctr_sa"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF880C
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_sa_ev
			"Vxx_wupctr_sa_ev"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF880D
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_spg
			"Vxx_wupctr_spg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87E8
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_spg_sys
			"Vxx_wupctr_spg_sys"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87E9
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_tco
			"Vxx_wupctr_tco"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF880E
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_tia
			"Vxx_wupctr_tia"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF880F
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_tlz_ad_b
			"Vxx_wupctr_tlz_ad_b"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87EA
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_vs
			"Vxx_wupctr_vs"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8810
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_vta_intake
			"Vxx_wupctr_vta_intake"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8811
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_vvt_int_ev
			"Vxx_wupctr_vvt_int_ev"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8812
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_vvt_int_old_off
			"Vxx_wupctr_vvt_int_old_off"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87EB
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_vvt_intake
			"Vxx_wupctr_vvt_intake"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8813
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_vvtc_toth_3
			"Vxx_wupctr_vvtc_toth_3"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF87EC
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_wupctr_wgc
			"Vxx_wupctr_wgc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8814
		/end MEASUREMENT
		/begin MEASUREMENT Vxx_zon_nr
			"Vxx_zon_nr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF77C9
		/end MEASUREMENT
		/begin MEASUREMENT Warn_cru_effective
			"WARN_CRU_EFFECTIVE"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x2
			ECU_ADDRESS 0xFFFF81DD
		/end MEASUREMENT
		/begin MEASUREMENT Warn_cru_ineffective
			"WARN_CRU_INEFFECTIVE"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x4
			ECU_ADDRESS 0xFFFF81DD
		/end MEASUREMENT
		/begin MEASUREMENT Warn_cru_sl_inactive
			"WARN_CRU_SL_INACTIVE"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF81DD
		/end MEASUREMENT
		/begin MEASUREMENT Warn_drive_master
			"WARN_DRIVE_MASTER"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x8
			ECU_ADDRESS 0xFFFF81DD
		/end MEASUREMENT
		/begin MEASUREMENT Warn_sl_effective
			"WARN_SL_EFFECTIVE"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x20
			ECU_ADDRESS 0xFFFF81DD
		/end MEASUREMENT
		/begin MEASUREMENT Warn_sl_ineffective
			"WARN_SL_INEFFECTIVE"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x40
			ECU_ADDRESS 0xFFFF81DD
		/end MEASUREMENT
		/begin MEASUREMENT Warn_sl_overspeed
			"WARN_SL_OVERSPEED"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x10
			ECU_ADDRESS 0xFFFF81DD
		/end MEASUREMENT
		/begin MEASUREMENT Waste_gate_diag_enable_bas
			"Waste_gate_diag_enable_bas"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF784A
		/end MEASUREMENT
		/begin MEASUREMENT Waste_gate_diag_enable_haut
			"Waste_gate_diag_enable_haut"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF784B
		/end MEASUREMENT
		/begin MEASUREMENT Water_temp_para_
			"Water_temp_para"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF859A
		/end MEASUREMENT
		/begin MEASUREMENT Wd_vehicule_arrete_
			"Wd_vehicule_arrete"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF82AE
		/end MEASUREMENT
		/begin MEASUREMENT Wg_erreur_regulation_brute_prec_
			"Wg_erreur_regulation_brute_prec"
			SBYTE
			F_3v7_p0_21
			2
			2
			-473.6
			469.9
			ECU_ADDRESS 0xFFFF84A8
		/end MEASUREMENT
		/begin MEASUREMENT Wtdg_panne_rmc_comspipp
			"Wtdg_panne_rmc_comspipp"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF825E
		/end MEASUREMENT
		/begin MEASUREMENT Wtdg_panne_rmc_timeoutpp
			"Wtdg_panne_rmc_timeoutpp"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF825F
		/end MEASUREMENT
		/begin MEASUREMENT Xn_1
			"Xn_1"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF74EC
		/end MEASUREMENT
		/begin MEASUREMENT Xn_2
			"Xn_2"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF74EE
		/end MEASUREMENT
		/begin MEASUREMENT Yn_1
			"Yn_1"
			SWORD
			Id_0x00
			2
			2
			-32768
			32767
			ECU_ADDRESS 0xFFFF74AC
		/end MEASUREMENT
		/begin MEASUREMENT Yn_2
			"Yn_2"
			SWORD
			Id_0x00
			2
			2
			-32768
			32767
			ECU_ADDRESS 0xFFFF74AE
		/end MEASUREMENT
		/begin COMPU_METHOD F_26940_p0_1
			""
			RAT_FUNC
			"%9.2"
			"-"
			COEFFS 0 1 0 0 0 26940
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v4_p0_2
			""
			RAT_FUNC
			"%9.2"
			"%"
			COEFFS 0 1 0 0 0 0.4
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v09765_p0_3
			""
			RAT_FUNC
			"%9.2"
			"%"
			COEFFS 0 1 0 0 0 0.09765
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v390625_p0_4
			""
			RAT_FUNC
			"%9.2"
			"%"
			COEFFS 0 1 0 0 0 0.390625
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v097656_p0_5
			""
			RAT_FUNC
			"%9.2"
			"%"
			COEFFS 0 1 0 0 0 0.097656
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v375_m23v625_6
			""
			RAT_FUNC
			"%9.2"
			"�Vil"
			COEFFS 0 1 23.625 0 0 0.375
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v000125_p8_7
			""
			RAT_FUNC
			"%9.4"
			"V"
			COEFFS 0 1 -8 0 0 0.000125
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0032_p0_8
			""
			RAT_FUNC
			"%9.3"
			"ms"
			COEFFS 0 1 0 0 0 0.0032
		/end COMPU_METHOD
		/begin COMPU_METHOD F_1_p0_9
			""
			RAT_FUNC
			"%9.2"
			"-"
			COEFFS 0 1 0 0 0 1
		/end COMPU_METHOD
		/begin COMPU_METHOD F_16_p0_10
			""
			RAT_FUNC
			"%9.2"
			"ms"
			COEFFS 0 1 0 0 0 16
		/end COMPU_METHOD
		/begin COMPU_METHOD F_4v8828125_p0_11
			""
			RAT_FUNC
			"%9.2"
			"mV"
			COEFFS 0 1 0 0 0 4.88281
		/end COMPU_METHOD
		/begin COMPU_METHOD F_4v096_p0_12
			""
			RAT_FUNC
			"%9.2"
			"s"
			COEFFS 0 1 0 0 0 4.096
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v015625_p0_13
			""
			RAT_FUNC
			"%9.2"
			"-"
			COEFFS 0 1 0 0 0 0.015625
		/end COMPU_METHOD
		/begin COMPU_METHOD F_1_p0_14
			""
			RAT_FUNC
			"%9.2"
			"tr/min"
			COEFFS 0 1 0 0 0 1
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0078125_p0_15
			""
			RAT_FUNC
			"%9.3"
			"N.m"
			COEFFS 0 1 0 0 0 0.0078125
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v78125_p0_16
			""
			RAT_FUNC
			"%9.2"
			"%"
			COEFFS 0 1 0 0 0 0.78125
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v01953125_p0_17
			""
			RAT_FUNC
			"%9.2"
			"N.m/A"
			COEFFS 0 1 0 0 0 0.0195313
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v03125_m5_18
			""
			RAT_FUNC
			"%9.2"
			"N.m"
			COEFFS 0 1 5 0 0 0.03125
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v078125_p0_19
			""
			RAT_FUNC
			"%9.2"
			"N.m"
			COEFFS 0 1 0 0 0 0.078125
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v00390625_p0v5_20
			""
			RAT_FUNC
			"%9.3"
			"-"
			COEFFS 0 1 -0.5 0 0 0.00390625
		/end COMPU_METHOD
		/begin COMPU_METHOD F_3v7_p0_21
			""
			RAT_FUNC
			"%9.2"
			"mb"
			COEFFS 0 1 0 0 0 3.7
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v1_p0_22
			""
			RAT_FUNC
			"%9.2"
			"N.m"
			COEFFS 0 1 0 0 0 0.1
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0061035156_p0_23
			""
			RAT_FUNC
			"%9.3"
			"%"
			COEFFS 0 1 0 0 0 0.00610352
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v375_m48_24
			""
			RAT_FUNC
			"%9.2"
			"�Vil"
			COEFFS 0 1 48 0 0 0.375
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v625_m40_25
			""
			RAT_FUNC
			"%9.2"
			"�C"
			COEFFS 0 1 40 0 0 0.625
		/end COMPU_METHOD
		/begin COMPU_METHOD F_1894v4_p0_26
			""
			RAT_FUNC
			"%9.2"
			"mb/(kg/s)�"
			COEFFS 0 1 0 0 0 1894.4
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0000152588_p0_27
			""
			RAT_FUNC
			"%9.5"
			"Kg/s"
			COEFFS 0 1 0 0 0 1.52588e-005
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v5_p0_28
			""
			RAT_FUNC
			"%9.2"
			"N.m"
			COEFFS 0 1 0 0 0 0.5
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v375_p0_29
			""
			RAT_FUNC
			"%9.2"
			"�Vil"
			COEFFS 0 1 0 0 0 0.375
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v125_p0_30
			""
			RAT_FUNC
			"%9.2"
			"tr/min"
			COEFFS 0 1 0 0 0 0.125
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v1_m3276v7_31
			""
			RAT_FUNC
			"%9.2"
			"N.m"
			COEFFS 0 1 3276.7 0 0 0.1
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v00260417_p0v667_32
			""
			RAT_FUNC
			"%9.3"
			"-"
			COEFFS 0 1 -0.667 0 0 0.00260417
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v375_p0_33
			""
			RAT_FUNC
			"%9.2"
			"deg"
			COEFFS 0 1 0 0 0 0.375
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v375_m23v625_34
			""
			RAT_FUNC
			"%9.2"
			"deg"
			COEFFS 0 1 23.625 0 0 0.375
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0078125_m100_35
			""
			RAT_FUNC
			"%9.3"
			"N.m"
			COEFFS 0 1 100 0 0 0.0078125
		/end COMPU_METHOD
		/begin COMPU_METHOD F_2_m100_36
			""
			RAT_FUNC
			"%9.2"
			"N.m"
			COEFFS 0 1 100 0 0 2
		/end COMPU_METHOD
		/begin COMPU_METHOD F_3v7_p103_37
			""
			RAT_FUNC
			"%9.2"
			"mb"
			COEFFS 0 1 -103 0 0 3.7
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v00260417_p0v66667_38
			""
			RAT_FUNC
			"%9.3"
			"-"
			COEFFS 0 1 -0.66667 0 0 0.00260417
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0625_p0_39
			""
			RAT_FUNC
			"%9.2"
			"N.m/(tr/min)"
			COEFFS 0 1 0 0 0 0.0625
		/end COMPU_METHOD
		/begin COMPU_METHOD F_1_m40_40
			""
			RAT_FUNC
			"%9.2"
			"�C"
			COEFFS 0 1 40 0 0 1
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v375_m48_41
			""
			RAT_FUNC
			"%9.2"
			"deg"
			COEFFS 0 1 48 0 0 0.375
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v001526_p0_42
			""
			RAT_FUNC
			"%9.3"
			"%"
			COEFFS 0 1 0 0 0 0.001526
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0031_m101v5808_43
			""
			RAT_FUNC
			"%9.3"
			"%"
			COEFFS 0 1 101.581 0 0 0.0031
		/end COMPU_METHOD
		/begin COMPU_METHOD F_3v7_m2841v6_44
			""
			RAT_FUNC
			"%9.2"
			"mb"
			COEFFS 0 1 2841.6 0 0 3.7
		/end COMPU_METHOD
		/begin COMPU_METHOD F_9v76_p0_45
			""
			RAT_FUNC
			"%9.2"
			"mV"
			COEFFS 0 1 0 0 0 9.76
		/end COMPU_METHOD
		/begin COMPU_METHOD F_32_p0_46
			""
			RAT_FUNC
			"%9.2"
			"tr/min"
			COEFFS 0 1 0 0 0 32
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v78_m100_47
			""
			RAT_FUNC
			"%9.2"
			"%"
			COEFFS 0 1 100 0 0 0.78
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0015258_p0_48
			""
			RAT_FUNC
			"%9.3"
			"%"
			COEFFS 0 1 0 0 0 0.0015258
		/end COMPU_METHOD
		/begin COMPU_METHOD F_7v4_p750_49
			""
			RAT_FUNC
			"%9.2"
			"mb"
			COEFFS 0 1 -750 0 0 7.4
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v00305176_p0_50
			""
			RAT_FUNC
			"%9.3"
			"%"
			COEFFS 0 1 0 0 0 0.00305176
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v00174825_p0_51
			""
			RAT_FUNC
			"%9.3"
			"su"
			COEFFS 0 1 0 0 0 0.00174825
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v04166_m1365v1149_52
			""
			RAT_FUNC
			"%9.2"
			"su"
			COEFFS 0 1 1365.11 0 0 0.04166
		/end COMPU_METHOD
		/begin COMPU_METHOD F_1_p0_53
			""
			RAT_FUNC
			"%9.2"
			"Pmh"
			COEFFS 0 1 0 0 0 1
		/end COMPU_METHOD
		/begin COMPU_METHOD F_1_p0_54
			""
			RAT_FUNC
			"%9.2"
			"s"
			COEFFS 0 1 0 0 0 1
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v09756098_p0_55
			""
			RAT_FUNC
			"%9.2"
			"%"
			COEFFS 0 1 0 0 0 0.097561
		/end COMPU_METHOD
		/begin COMPU_METHOD F_8_p0_56
			""
			RAT_FUNC
			"%9.2"
			"ms"
			COEFFS 0 1 0 0 0 8
		/end COMPU_METHOD
		/begin COMPU_METHOD F_16_p800_57
			""
			RAT_FUNC
			"%9.2"
			"tr/min"
			COEFFS 0 1 -800 0 0 16
		/end COMPU_METHOD
		/begin COMPU_METHOD F_1_p0_58
			""
			RAT_FUNC
			"%9.2"
			"km/h"
			COEFFS 0 1 0 0 0 1
		/end COMPU_METHOD
		/begin COMPU_METHOD F_32_m256_59
			""
			RAT_FUNC
			"%9.2"
			"tr/min"
			COEFFS 0 1 256 0 0 32
		/end COMPU_METHOD
		/begin COMPU_METHOD F_1_p0_60
			""
			RAT_FUNC
			"%9.2"
			"tr/min/s"
			COEFFS 0 1 0 0 0 1
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v02_m655v35_61
			""
			RAT_FUNC
			"%9.2"
			"N.m/s"
			COEFFS 0 1 655.35 0 0 0.02
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v01_p0_62
			""
			RAT_FUNC
			"%9.2"
			"km/h"
			COEFFS 0 1 0 0 0 0.01
		/end COMPU_METHOD
		/begin COMPU_METHOD F_20_p0_63
			""
			RAT_FUNC
			"%9.2"
			"W"
			COEFFS 0 1 0 0 0 20
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0015258789_m50_64
			""
			RAT_FUNC
			"%9.3"
			"%"
			COEFFS 0 1 50 0 0 0.00152588
		/end COMPU_METHOD
		/begin COMPU_METHOD F_1_m4096_65
			""
			RAT_FUNC
			"%9.2"
			"tr/min"
			COEFFS 0 1 4096 0 0 1
		/end COMPU_METHOD
		/begin COMPU_METHOD F_1_m8192_66
			""
			RAT_FUNC
			"%9.2"
			"tr/min/s"
			COEFFS 0 1 8192 0 0 1
		/end COMPU_METHOD
		/begin COMPU_METHOD F_30v517578125_p0_67
			""
			RAT_FUNC
			"%9.2"
			"e-6"
			COEFFS 0 1 0 0 0 30.5176
		/end COMPU_METHOD
		/begin COMPU_METHOD F_15v2587890625_p0_68
			""
			RAT_FUNC
			"%9.2"
			"e-6"
			COEFFS 0 1 0 0 0 15.2588
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v25_p0_69
			""
			RAT_FUNC
			"%9.2"
			"-"
			COEFFS 0 1 0 0 0 0.25
		/end COMPU_METHOD
		/begin COMPU_METHOD F_100_p0_70
			""
			RAT_FUNC
			"%9.2"
			"W"
			COEFFS 0 1 0 0 0 100
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v09765625_p0_71
			""
			RAT_FUNC
			"%9.2"
			"%"
			COEFFS 0 1 0 0 0 0.0976563
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0000305176_p0_72
			""
			RAT_FUNC
			"%9.5"
			"-"
			COEFFS 0 1 0 0 0 3.05176e-005
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v9537_p0_73
			""
			RAT_FUNC
			"%9.2"
			"us/m.K^0.5"
			COEFFS 0 1 0 0 0 0.9537
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v00390625_p0_74
			""
			RAT_FUNC
			"%9.3"
			"su"
			COEFFS 0 1 0 0 0 0.00390625
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v128_p0_75
			""
			RAT_FUNC
			"%9.2"
			"s"
			COEFFS 0 1 0 0 0 0.128
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0596046_p0_76
			""
			RAT_FUNC
			"%9.2"
			"mm2"
			COEFFS 0 1 0 0 0 0.0596046
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v097656_m100_77
			""
			RAT_FUNC
			"%9.2"
			"%"
			COEFFS 0 1 100 0 0 0.097656
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0015259_p0_78
			""
			RAT_FUNC
			"%9.3"
			"kmh/1000rpm"
			COEFFS 0 1 0 0 0 0.0015259
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0039062_p0_79
			""
			RAT_FUNC
			"%9.3"
			"-"
			COEFFS 0 1 0 0 0 0.0039062
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0015258789_m50_80
			""
			RAT_FUNC
			"%9.3"
			"-"
			COEFFS 0 1 50 0 0 0.00152588
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v007813_p0_81
			""
			RAT_FUNC
			"%9.3"
			"N.m"
			COEFFS 0 1 0 0 0 0.007813
		/end COMPU_METHOD
		/begin COMPU_METHOD F_m15v2587890625_p0_82
			""
			RAT_FUNC
			"%9.2"
			"e-6"
			COEFFS 0 1 0 0 0 -15.2588
		/end COMPU_METHOD
		/begin COMPU_METHOD F_16_p0_83
			""
			RAT_FUNC
			"%9.2"
			"tr/min"
			COEFFS 0 1 0 0 0 16
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0625_p0_84
			""
			RAT_FUNC
			"%9.2"
			"N.m"
			COEFFS 0 1 0 0 0 0.0625
		/end COMPU_METHOD
		/begin COMPU_METHOD F_25_p0_85
			""
			RAT_FUNC
			"%9.2"
			"N"
			COEFFS 0 1 0 0 0 25
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0044152_p0_86
			""
			RAT_FUNC
			"%9.3"
			"1/s"
			COEFFS 0 1 0 0 0 0.0044152
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0061035_p0_87
			""
			RAT_FUNC
			"%9.3"
			"%"
			COEFFS 0 1 0 0 0 0.0061035
		/end COMPU_METHOD
		/begin COMPU_METHOD F_4_m40_88
			""
			RAT_FUNC
			"%9.2"
			"�C"
			COEFFS 0 1 40 0 0 4
		/end COMPU_METHOD
		/begin COMPU_METHOD F_4_p0_89
			""
			RAT_FUNC
			"%9.2"
			"�C"
			COEFFS 0 1 0 0 0 4
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v00390625_p0_90
			""
			RAT_FUNC
			"%9.3"
			"-"
			COEFFS 0 1 0 0 0 0.00390625
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v03125_p0_91
			""
			RAT_FUNC
			"%9.2"
			"-"
			COEFFS 0 1 0 0 0 0.03125
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0015259_p0_92
			""
			RAT_FUNC
			"%9.3"
			"%"
			COEFFS 0 1 0 0 0 0.0015259
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v015258_p0_93
			""
			RAT_FUNC
			"%9.2"
			"e-3"
			COEFFS 0 1 0 0 0 0.015258
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0009765_p1_94
			""
			RAT_FUNC
			"%9.4"
			"-"
			COEFFS 0 1 -1 0 0 0.0009765
		/end COMPU_METHOD
		/begin COMPU_METHOD F_19_p0_95
			""
			RAT_FUNC
			"%9.2"
			"tr/min/s"
			COEFFS 0 1 0 0 0 19
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0578125_p103_96
			""
			RAT_FUNC
			"%9.2"
			"mb"
			COEFFS 0 1 -103 0 0 0.0578125
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v06_p0_97
			""
			RAT_FUNC
			"%9.2"
			"-"
			COEFFS 0 1 0 0 0 0.06
		/end COMPU_METHOD
		/begin COMPU_METHOD F_1_m128_98
			""
			RAT_FUNC
			"%9.2"
			"-"
			COEFFS 0 1 128 0 0 1
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v032_p0_99
			""
			RAT_FUNC
			"%9.2"
			"s"
			COEFFS 0 1 0 0 0 0.032
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v00390625_p1_100
			""
			RAT_FUNC
			"%9.3"
			"-"
			COEFFS 0 1 -1 0 0 0.00390625
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v00001526_p0_101
			""
			RAT_FUNC
			"%9.5"
			"Kg/s"
			COEFFS 0 1 0 0 0 1.526e-005
		/end COMPU_METHOD
		/begin COMPU_METHOD F_2_p600_102
			""
			RAT_FUNC
			"%9.2"
			"tr/min"
			COEFFS 0 1 -600 0 0 2
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0001953125_m0v1_103
			""
			RAT_FUNC
			"%9.4"
			"-"
			COEFFS 0 1 0.1 0 0 0.000195312
		/end COMPU_METHOD
		/begin COMPU_METHOD F_512_p0_104
			""
			RAT_FUNC
			"%9.2"
			"ms"
			COEFFS 0 1 0 0 0 512
		/end COMPU_METHOD
		/begin COMPU_METHOD F_1_m128_105
			""
			RAT_FUNC
			"%9.2"
			"tr/min"
			COEFFS 0 1 128 0 0 1
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v4_p0_106
			""
			RAT_FUNC
			"%9.2"
			"deg"
			COEFFS 0 1 0 0 0 0.4
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v00152588_p0_107
			""
			RAT_FUNC
			"%9.3"
			"%"
			COEFFS 0 1 0 0 0 0.00152588
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0596_p0_108
			""
			RAT_FUNC
			"%9.2"
			"mm2"
			COEFFS 0 1 0 0 0 0.0596
		/end COMPU_METHOD
		/begin COMPU_METHOD F_8v752_p0_109
			""
			RAT_FUNC
			"%9.2"
			"deg/s"
			COEFFS 0 1 0 0 0 8.752
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0625_p0_110
			""
			RAT_FUNC
			"%9.2"
			"km/h"
			COEFFS 0 1 0 0 0 0.0625
		/end COMPU_METHOD
		/begin COMPU_METHOD F_3_p0_111
			""
			RAT_FUNC
			"%9.2"
			"�Vil"
			COEFFS 0 1 0 0 0 3
		/end COMPU_METHOD
		/begin COMPU_METHOD F_1v319679_p0_112
			""
			RAT_FUNC
			"%9.2"
			"cm3"
			COEFFS 0 1 0 0 0 1.31968
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0037253_p0_113
			""
			RAT_FUNC
			"%9.3"
			"mm2"
			COEFFS 0 1 0 0 0 0.0037253
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0039_p0_114
			""
			RAT_FUNC
			"%9.3"
			"%"
			COEFFS 0 1 0 0 0 0.0039
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0015258789_p0_115
			""
			RAT_FUNC
			"%9.3"
			"%"
			COEFFS 0 1 0 0 0 0.00152588
		/end COMPU_METHOD
		/begin COMPU_METHOD F_8_p0_116
			""
			RAT_FUNC
			"%9.2"
			"N.m/Kg"
			COEFFS 0 1 0 0 0 8
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v00097656_p1_117
			""
			RAT_FUNC
			"%9.4"
			"su"
			COEFFS 0 1 -1 0 0 0.00097656
		/end COMPU_METHOD
		/begin COMPU_METHOD F_3v7_m473v6_118
			""
			RAT_FUNC
			"%9.2"
			"mb"
			COEFFS 0 1 473.6 0 0 3.7
		/end COMPU_METHOD
		/begin COMPU_METHOD F_1v024_p0_119
			""
			RAT_FUNC
			"%9.2"
			"s"
			COEFFS 0 1 0 0 0 1.024
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v02_p0_120
			""
			RAT_FUNC
			"%9.2"
			"-"
			COEFFS 0 1 0 0 0 0.02
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v512_p0_121
			""
			RAT_FUNC
			"%9.2"
			"s"
			COEFFS 0 1 0 0 0 0.512
		/end COMPU_METHOD
		/begin COMPU_METHOD F_32_p0_122
			""
			RAT_FUNC
			"%9.2"
			"ms"
			COEFFS 0 1 0 0 0 32
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v064_p0_123
			""
			RAT_FUNC
			"%9.2"
			"ms"
			COEFFS 0 1 0 0 0 0.064
		/end COMPU_METHOD
		/begin COMPU_METHOD F_1_m100_124
			""
			RAT_FUNC
			"%9.2"
			"-"
			COEFFS 0 1 100 0 0 1
		/end COMPU_METHOD
		/begin COMPU_METHOD F_128_p0_125
			""
			RAT_FUNC
			"%9.2"
			"ms"
			COEFFS 0 1 0 0 0 128
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v015625_p0v5_126
			""
			RAT_FUNC
			"%9.2"
			"-"
			COEFFS 0 1 -0.5 0 0 0.015625
		/end COMPU_METHOD
		/begin COMPU_METHOD F_2_p0_127
			""
			RAT_FUNC
			"%9.2"
			"tr/min"
			COEFFS 0 1 0 0 0 2
		/end COMPU_METHOD
		/begin COMPU_METHOD F_4_p0_128
			""
			RAT_FUNC
			"%9.2"
			"ms"
			COEFFS 0 1 0 0 0 4
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v000976563_p0_129
			""
			RAT_FUNC
			"%9.4"
			"-"
			COEFFS 0 1 0 0 0 0.000976563
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v032_p8_130
			""
			RAT_FUNC
			"%9.2"
			"V"
			COEFFS 0 1 -8 0 0 0.032
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v625_m40_131
			""
			RAT_FUNC
			"%9.2"
			"�C"
			COEFFS 0 1 40 0 0 0.625
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v625_m20480_132
			""
			RAT_FUNC
			"%9.2"
			"mV"
			COEFFS 0 1 20480 0 0 0.625
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v3906_p0_133
			""
			RAT_FUNC
			"%9.2"
			"%"
			COEFFS 0 1 0 0 0 0.3906
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v00244_m40_134
			""
			RAT_FUNC
			"%9.3"
			"�C"
			COEFFS 0 1 40 0 0 0.00244
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v001525878_p0_135
			""
			RAT_FUNC
			"%9.3"
			"%"
			COEFFS 0 1 0 0 0 0.00152588
		/end COMPU_METHOD
		/begin COMPU_METHOD F_8_p0_136
			""
			RAT_FUNC
			"%9.2"
			"us"
			COEFFS 0 1 0 0 0 8
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v00152587_p0_137
			""
			RAT_FUNC
			"%9.3"
			"%"
			COEFFS 0 1 0 0 0 0.00152587
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0009765625_p0_138
			""
			RAT_FUNC
			"%9.4"
			"-"
			COEFFS 0 1 0 0 0 0.000976563
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v625_p56_139
			""
			RAT_FUNC
			"%9.2"
			"�C"
			COEFFS 0 1 -56 0 0 0.625
		/end COMPU_METHOD
		/begin COMPU_METHOD F_6v4_p0_140
			""
			RAT_FUNC
			"%9.2"
			"us"
			COEFFS 0 1 0 0 0 6.4
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v1_p0_141
			""
			RAT_FUNC
			"%9.2"
			"bar"
			COEFFS 0 1 0 0 0 0.1
		/end COMPU_METHOD
		/begin COMPU_METHOD F_256_p0_142
			""
			RAT_FUNC
			"%9.2"
			"ms"
			COEFFS 0 1 0 0 0 256
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v625_p0_143
			""
			RAT_FUNC
			"%9.2"
			"�C"
			COEFFS 0 1 0 0 0 0.625
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v00007629_p0_144
			""
			RAT_FUNC
			"%9.5"
			"V"
			COEFFS 0 1 0 0 0 7.629e-005
		/end COMPU_METHOD
		/begin COMPU_METHOD F_64_p0_145
			""
			RAT_FUNC
			"%9.2"
			"ms"
			COEFFS 0 1 0 0 0 64
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v5_p0_146
			""
			RAT_FUNC
			"%9.2"
			"-"
			COEFFS 0 1 0 0 0 0.5
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v09765625_p0_147
			""
			RAT_FUNC
			"%9.2"
			"%Uref"
			COEFFS 0 1 0 0 0 0.0976563
		/end COMPU_METHOD
		/begin COMPU_METHOD F_1_p0_148
			""
			RAT_FUNC
			"%9.2"
			"basc"
			COEFFS 0 1 0 0 0 1
		/end COMPU_METHOD
		/begin COMPU_METHOD F_4_p0_149
			""
			RAT_FUNC
			"%9.2"
			"us"
			COEFFS 0 1 0 0 0 4
		/end COMPU_METHOD
		/begin COMPU_METHOD F_1_p1_150
			""
			RAT_FUNC
			"%9.2"
			"-"
			COEFFS 0 1 -1 0 0 1
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0596046448_p0_151
			""
			RAT_FUNC
			"%9.2"
			"mm2"
			COEFFS 0 1 0 0 0 0.0596046
		/end COMPU_METHOD
		/begin COMPU_METHOD F_3v2_p0_152
			""
			RAT_FUNC
			"%9.2"
			"us"
			COEFFS 0 1 0 0 0 3.2
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0046875_p0_153
			""
			RAT_FUNC
			"%9.3"
			"A/%"
			COEFFS 0 1 0 0 0 0.0046875
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0472_p0_154
			""
			RAT_FUNC
			"%9.2"
			"A"
			COEFFS 0 1 0 0 0 0.0472
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v01_p0_155
			""
			RAT_FUNC
			"%9.2"
			"-"
			COEFFS 0 1 0 0 0 0.01
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v393701_p0_156
			""
			RAT_FUNC
			"%9.2"
			"%"
			COEFFS 0 1 0 0 0 0.393701
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0030517578_p0_157
			""
			RAT_FUNC
			"%9.3"
			"%"
			COEFFS 0 1 0 0 0 0.00305176
		/end COMPU_METHOD
		/begin COMPU_METHOD F_29v6_p1_158
			""
			RAT_FUNC
			"%9.2"
			"mb/(kg/s)�"
			COEFFS 0 1 -1 0 0 29.6
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v1_p0_159
			""
			RAT_FUNC
			"%9.2"
			"m/s2"
			COEFFS 0 1 0 0 0 0.1
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v625_m40_160
			""
			RAT_FUNC
			"%9.2"
			"deg"
			COEFFS 0 1 40 0 0 0.625
		/end COMPU_METHOD
		/begin COMPU_METHOD F_16v384_p0_161
			""
			RAT_FUNC
			"%9.2"
			"s"
			COEFFS 0 1 0 0 0 16.384
		/end COMPU_METHOD
		/begin COMPU_METHOD F_1_p0_162
			""
			RAT_FUNC
			"%9.2"
			"Hz"
			COEFFS 0 1 0 0 0 1
		/end COMPU_METHOD
		/begin COMPU_METHOD F_4_p0_163
			""
			RAT_FUNC
			"%9.2"
			"s"
			COEFFS 0 1 0 0 0 4
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v00153_p0_164
			""
			RAT_FUNC
			"%9.3"
			"%"
			COEFFS 0 1 0 0 0 0.00153
		/end COMPU_METHOD
		/begin COMPU_METHOD F_1_p0_165
			""
			RAT_FUNC
			"%9.2"
			"Dent"
			COEFFS 0 1 0 0 0 1
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v48828125_p0_166
			""
			RAT_FUNC
			"%9.2"
			"N.m/s"
			COEFFS 0 1 0 0 0 0.488281
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v1_p0_167
			""
			RAT_FUNC
			"%9.2"
			"km/h"
			COEFFS 0 1 0 0 0 0.1
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v001_p0_168
			""
			RAT_FUNC
			"%9.3"
			"1/s"
			COEFFS 0 1 0 0 0 0.001
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v1_p0_169
			""
			RAT_FUNC
			"%9.2"
			"(km/h)/s"
			COEFFS 0 1 0 0 0 0.1
		/end COMPU_METHOD
		/begin COMPU_METHOD F_1_p0_170
			""
			RAT_FUNC
			"%9.2"
			"%"
			COEFFS 0 1 0 0 0 1
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0039_p0_171
			""
			RAT_FUNC
			"%9.3"
			"-"
			COEFFS 0 1 0 0 0 0.0039
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v008_p0_172
			""
			RAT_FUNC
			"%9.3"
			"s"
			COEFFS 0 1 0 0 0 0.008
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v1_p0_173
			""
			RAT_FUNC
			"%9.2"
			"s"
			COEFFS 0 1 0 0 0 0.1
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v48828125_m100_174
			""
			RAT_FUNC
			"%9.2"
			"N.m/s"
			COEFFS 0 1 100 0 0 0.488281
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0298023_p0_175
			""
			RAT_FUNC
			"%9.2"
			"1/s2"
			COEFFS 0 1 0 0 0 0.0298023
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0019073_p0_176
			""
			RAT_FUNC
			"%9.3"
			"(km/h)/s"
			COEFFS 0 1 0 0 0 0.0019073
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0019073_p0_177
			""
			RAT_FUNC
			"%9.3"
			"1/s"
			COEFFS 0 1 0 0 0 0.0019073
		/end COMPU_METHOD
		/begin COMPU_METHOD F_4_p0_178
			""
			RAT_FUNC
			"%9.2"
			"Pmh"
			COEFFS 0 1 0 0 0 4
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v78_p0_179
			""
			RAT_FUNC
			"%9.2"
			"%"
			COEFFS 0 1 0 0 0 0.78
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v04376_p0_180
			""
			RAT_FUNC
			"%9.2"
			"deg"
			COEFFS 0 1 0 0 0 0.04376
		/end COMPU_METHOD
		/begin COMPU_METHOD D_2_0v0004_p0v054_181
			""
			RAT_FUNC
			"%9.2"
			"kHz"
			COEFFS 0 -0.054 1 0 0.0004 0
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0002441406_p0_182
			""
			RAT_FUNC
			"%9.4"
			"su"
			COEFFS 0 1 0 0 0 0.000244141
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v03125_p8_183
			""
			RAT_FUNC
			"%9.2"
			"V"
			COEFFS 0 1 -8 0 0 0.03125
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v119_p0_184
			""
			RAT_FUNC
			"%9.2"
			"mg"
			COEFFS 0 1 0 0 0 0.119
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v01953125_p0_185
			""
			RAT_FUNC
			"%9.2"
			"-"
			COEFFS 0 1 0 0 0 0.0195313
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v15259_p0_186
			""
			RAT_FUNC
			"%9.2"
			"e-4"
			COEFFS 0 1 0 0 0 0.15259
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v000015258_p0_187
			""
			RAT_FUNC
			"%9.5"
			"-"
			COEFFS 0 1 0 0 0 1.5258e-005
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0000305175_p0_188
			""
			RAT_FUNC
			"%9.5"
			"-"
			COEFFS 0 1 0 0 0 3.05175e-005
		/end COMPU_METHOD
		/begin COMPU_METHOD F_1024_p0_189
			""
			RAT_FUNC
			"%9.2"
			"ms"
			COEFFS 0 1 0 0 0 1024
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v015625_p0_190
			""
			RAT_FUNC
			"%9.2"
			"s"
			COEFFS 0 1 0 0 0 0.015625
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v015259_p0_191
			""
			RAT_FUNC
			"%9.2"
			"e-3"
			COEFFS 0 1 0 0 0 0.015259
		/end COMPU_METHOD
		/begin COMPU_METHOD F_2v9296875_p0_192
			""
			RAT_FUNC
			"%9.2"
			"mH"
			COEFFS 0 1 0 0 0 2.92969
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v03125_p0_193
			""
			RAT_FUNC
			"%9.2"
			"Ohms"
			COEFFS 0 1 0 0 0 0.03125
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v1220703125_p0_194
			""
			RAT_FUNC
			"%9.2"
			"e-3/�C"
			COEFFS 0 1 0 0 0 0.12207
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v6103515625_p0_195
			""
			RAT_FUNC
			"%9.2"
			"�C/s"
			COEFFS 0 1 0 0 0 0.610352
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v023583984_p0_196
			""
			RAT_FUNC
			"%9.2"
			"V"
			COEFFS 0 1 0 0 0 0.023584
		/end COMPU_METHOD
		/begin COMPU_METHOD F_2_p0_197
			""
			RAT_FUNC
			"%9.2"
			"�C/V"
			COEFFS 0 1 0 0 0 2
		/end COMPU_METHOD
		/begin COMPU_METHOD F_2_p0_198
			""
			RAT_FUNC
			"%9.2"
			"N.m"
			COEFFS 0 1 0 0 0 2
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v048828125_p0_199
			""
			RAT_FUNC
			"%9.2"
			"%"
			COEFFS 0 1 0 0 0 0.0488281
		/end COMPU_METHOD
		/begin COMPU_METHOD F_7v63_p0_200
			""
			RAT_FUNC
			"%9.2"
			"e-6"
			COEFFS 0 1 0 0 0 7.63
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v004_p0_201
			""
			RAT_FUNC
			"%9.3"
			"ms"
			COEFFS 0 1 0 0 0 0.004
		/end COMPU_METHOD
		/begin COMPU_METHOD F_2v188_p0_202
			""
			RAT_FUNC
			"%9.2"
			"deg/s"
			COEFFS 0 1 0 0 0 2.188
		/end COMPU_METHOD
		/begin COMPU_METHOD F_19_p0_203
			""
			RAT_FUNC
			"%9.2"
			"tr/min"
			COEFFS 0 1 0 0 0 19
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v152879_p0_204
			""
			RAT_FUNC
			"%9.2"
			"e-4"
			COEFFS 0 1 0 0 0 0.152879
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v1525879_p0_205
			""
			RAT_FUNC
			"%9.2"
			"e-4"
			COEFFS 0 1 0 0 0 0.152588
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v1_p0_206
			""
			RAT_FUNC
			"%9.2"
			"%/�Vil"
			COEFFS 0 1 0 0 0 0.1
		/end COMPU_METHOD
		/begin COMPU_METHOD F_1_p0_207
			""
			RAT_FUNC
			"%9.2"
			"V�"
			COEFFS 0 1 0 0 0 1
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v1953125_p0_208
			""
			RAT_FUNC
			"%9.2"
			"%"
			COEFFS 0 1 0 0 0 0.195313
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v39215686_p0_209
			""
			RAT_FUNC
			"%9.2"
			"%"
			COEFFS 0 1 0 0 0 0.392157
		/end COMPU_METHOD
		/begin COMPU_METHOD F_8_p0_210
			""
			RAT_FUNC
			"%9.2"
			"tr/min"
			COEFFS 0 1 0 0 0 8
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v5_p0_211
			""
			RAT_FUNC
			"%9.2"
			"tr/min"
			COEFFS 0 1 0 0 0 0.5
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v06_p0_212
			""
			RAT_FUNC
			"%9.2"
			"mm2"
			COEFFS 0 1 0 0 0 0.06
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0078125_p0_213
			""
			RAT_FUNC
			"%9.3"
			"-"
			COEFFS 0 1 0 0 0 0.0078125
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v03125_p0_214
			""
			RAT_FUNC
			"%9.2"
			"su"
			COEFFS 0 1 0 0 0 0.03125
		/end COMPU_METHOD
		/begin COMPU_METHOD F_8_p0_215
			""
			RAT_FUNC
			"%9.2"
			"J/Kg/K/m3"
			COEFFS 0 1 0 0 0 8
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v000015259_p0_216
			""
			RAT_FUNC
			"%9.5"
			"-"
			COEFFS 0 1 0 0 0 1.5259e-005
		/end COMPU_METHOD
		/begin COMPU_METHOD F_16_p0_217
			""
			RAT_FUNC
			"%9.2"
			"s"
			COEFFS 0 1 0 0 0 16
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v001953_p0v75_218
			""
			RAT_FUNC
			"%9.3"
			"-"
			COEFFS 0 1 -0.75 0 0 0.001953
		/end COMPU_METHOD
		/begin COMPU_METHOD F_72v81778_p0_219
			""
			RAT_FUNC
			"%9.2"
			"m"
			COEFFS 0 1 0 0 0 72.8178
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v003051758_p0_220
			""
			RAT_FUNC
			"%9.3"
			"%"
			COEFFS 0 1 0 0 0 0.00305176
		/end COMPU_METHOD
		/begin COMPU_METHOD F_19_p0_221
			""
			RAT_FUNC
			"%9.2"
			"tr/min�"
			COEFFS 0 1 0 0 0 19
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v000390625_p0_222
			""
			RAT_FUNC
			"%9.4"
			"-"
			COEFFS 0 1 0 0 0 0.000390625
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v01_p0_223
			""
			RAT_FUNC
			"%9.2"
			"kg.m2"
			COEFFS 0 1 0 0 0 0.01
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v00260417_p0_224
			""
			RAT_FUNC
			"%9.3"
			"-"
			COEFFS 0 1 0 0 0 0.00260417
		/end COMPU_METHOD
		/begin COMPU_METHOD F_m0v0001_p0_225
			""
			RAT_FUNC
			"%9.4"
			"-"
			COEFFS 0 1 0 0 0 -0.0001
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0001_p0_226
			""
			RAT_FUNC
			"%9.4"
			"-"
			COEFFS 0 1 0 0 0 0.0001
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v5_p0_227
			""
			RAT_FUNC
			"%9.2"
			"s"
			COEFFS 0 1 0 0 0 0.5
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v3906_p0_228
			""
			RAT_FUNC
			"%9.2"
			"%/s"
			COEFFS 0 1 0 0 0 0.3906
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v4625_p0_229
			""
			RAT_FUNC
			"%9.2"
			"mb"
			COEFFS 0 1 0 0 0 0.4625
		/end COMPU_METHOD
		/begin COMPU_METHOD F_5_p0_230
			""
			RAT_FUNC
			"%9.2"
			"mb"
			COEFFS 0 1 0 0 0 5
		/end COMPU_METHOD
		/begin COMPU_METHOD F_1_p0_231
			""
			RAT_FUNC
			"%9.2"
			"W"
			COEFFS 0 1 0 0 0 1
		/end COMPU_METHOD
		/begin COMPU_METHOD F_1_p0_232
			""
			RAT_FUNC
			"%9.2"
			"ms"
			COEFFS 0 1 0 0 0 1
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v01_p0_233
			""
			RAT_FUNC
			"%9.2"
			"%"
			COEFFS 0 1 0 0 0 0.01
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v016_p0_234
			""
			RAT_FUNC
			"%9.2"
			"s"
			COEFFS 0 1 0 0 0 0.016
		/end COMPU_METHOD
		/begin COMPU_METHOD F_1_p0_235
			""
			RAT_FUNC
			"%9.2"
			"N.m"
			COEFFS 0 1 0 0 0 1
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v4_p0_236
			""
			RAT_FUNC
			"%9.2"
			"�Pap"
			COEFFS 0 1 0 0 0 0.4
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v038125_p0_237
			""
			RAT_FUNC
			"%9.2"
			"mV"
			COEFFS 0 1 0 0 0 0.038125
		/end COMPU_METHOD
		/begin COMPU_METHOD F_256_p0_238
			""
			RAT_FUNC
			"%9.2"
			"tr/min"
			COEFFS 0 1 0 0 0 256
		/end COMPU_METHOD
		/begin COMPU_METHOD F_31v25_p8000_239
			""
			RAT_FUNC
			"%9.2"
			"mV"
			COEFFS 0 1 -8000 0 0 31.25
		/end COMPU_METHOD
		/begin COMPU_METHOD F_6v1035_p0_240
			""
			RAT_FUNC
			"%9.2"
			"%/s"
			COEFFS 0 1 0 0 0 6.1035
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v48828_p0_241
			""
			RAT_FUNC
			"%9.2"
			"N.m/s"
			COEFFS 0 1 0 0 0 0.48828
		/end COMPU_METHOD
		/begin COMPU_METHOD F_3v7_p851_242
			""
			RAT_FUNC
			"%9.2"
			"mb"
			COEFFS 0 1 -851 0 0 3.7
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0156_p0_243
			""
			RAT_FUNC
			"%9.2"
			"%/mb"
			COEFFS 0 1 0 0 0 0.0156
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v2062_p0_244
			""
			RAT_FUNC
			"%9.2"
			"%/b"
			COEFFS 0 1 0 0 0 0.2062
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v925_p0_245
			""
			RAT_FUNC
			"%9.2"
			"mb"
			COEFFS 0 1 0 0 0 0.925
		/end COMPU_METHOD
		/begin COMPU_METHOD F_1v64959_p0_246
			""
			RAT_FUNC
			"%9.2"
			"%/b"
			COEFFS 0 1 0 0 0 1.64959
		/end COMPU_METHOD
		/begin COMPU_METHOD F_8v192_p0_247
			""
			RAT_FUNC
			"%9.2"
			"s"
			COEFFS 0 1 0 0 0 8.192
		/end COMPU_METHOD
		/begin COMPU_METHOD F_8v192_p0_248
			""
			RAT_FUNC
			"%9.2"
			"ms"
			COEFFS 0 1 0 0 0 8.192
		/end COMPU_METHOD
		/begin COMPU_METHOD F_2_p0_249
			""
			RAT_FUNC
			"%9.2"
			"ms"
			COEFFS 0 1 0 0 0 2
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v09765625_m100_250
			""
			RAT_FUNC
			"%9.2"
			"%"
			COEFFS 0 1 100 0 0 0.0976563
		/end COMPU_METHOD
		/begin COMPU_METHOD F_19v6_p0_251
			""
			RAT_FUNC
			"%9.2"
			"W"
			COEFFS 0 1 0 0 0 19.6
		/end COMPU_METHOD
		/begin COMPU_METHOD F_61v03515_p0_252
			""
			RAT_FUNC
			"%9.2"
			"e-6"
			COEFFS 0 1 0 0 0 61.0352
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v007812_p0_253
			""
			RAT_FUNC
			"%9.3"
			"-"
			COEFFS 0 1 0 0 0 0.007812
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v95_p0_254
			""
			RAT_FUNC
			"%9.2"
			"e-6"
			COEFFS 0 1 0 0 0 0.95
		/end COMPU_METHOD
		/begin COMPU_METHOD F_1024_p0_255
			""
			RAT_FUNC
			"%9.2"
			"us"
			COEFFS 0 1 0 0 0 1024
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v625_p0_256
			""
			RAT_FUNC
			"%9.2"
			"�C"
			COEFFS 0 1 0 0 0 0.625
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0596046_p0_257
			""
			RAT_FUNC
			"%9.2"
			"e-6"
			COEFFS 0 1 0 0 0 0.0596046
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v625_p0_258
			""
			RAT_FUNC
			"%9.2"
			"mV"
			COEFFS 0 1 0 0 0 0.625
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v125_p0_259
			""
			RAT_FUNC
			"%9.2"
			"dec/ms"
			COEFFS 0 1 0 0 0 0.125
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v048828125_p0_260
			""
			RAT_FUNC
			"%9.2"
			"%/2ms"
			COEFFS 0 1 0 0 0 0.0488281
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v7324_p0_261
			""
			RAT_FUNC
			"%9.2"
			"e-3"
			COEFFS 0 1 0 0 0 0.7324
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v625_p50_262
			""
			RAT_FUNC
			"%9.2"
			"�C"
			COEFFS 0 1 -50 0 0 0.625
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v24414_p0_263
			""
			RAT_FUNC
			"%9.2"
			"e-3"
			COEFFS 0 1 0 0 0 0.24414
		/end COMPU_METHOD
		/begin COMPU_METHOD F_32_p0_264
			""
			RAT_FUNC
			"%9.2"
			"rpm"
			COEFFS 0 1 0 0 0 32
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v390625_p0_265
			""
			RAT_FUNC
			"%9.2"
			"-"
			COEFFS 0 1 0 0 0 0.390625
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v3921568_p0_266
			""
			RAT_FUNC
			"%9.2"
			"%"
			COEFFS 0 1 0 0 0 0.392157
		/end COMPU_METHOD
		/begin COMPU_METHOD F_10_p450_267
			""
			RAT_FUNC
			"%9.2"
			"kg"
			COEFFS 0 1 -450 0 0 10
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v390625_p0_268
			""
			RAT_FUNC
			"%9.2"
			"kmh/1000rpm"
			COEFFS 0 1 0 0 0 0.390625
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v375_m32_269
			""
			RAT_FUNC
			"%9.2"
			"�Vil"
			COEFFS 0 1 32 0 0 0.375
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v47_p0_270
			""
			RAT_FUNC
			"%9.2"
			"mb"
			COEFFS 0 1 0 0 0 0.47
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v00390625_p0_271
			""
			RAT_FUNC
			"%9.3"
			"m"
			COEFFS 0 1 0 0 0 0.00390625
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v032_p0_272
			""
			RAT_FUNC
			"%9.2"
			"V"
			COEFFS 0 1 0 0 0 0.032
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v4_p0_273
			""
			RAT_FUNC
			"%9.2"
			"us"
			COEFFS 0 1 0 0 0 0.4
		/end COMPU_METHOD
		/begin COMPU_METHOD F_6v5536_p0_274
			""
			RAT_FUNC
			"%9.2"
			"ms"
			COEFFS 0 1 0 0 0 6.5536
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v1_p0_275
			""
			RAT_FUNC
			"%9.2"
			"us"
			COEFFS 0 1 0 0 0 0.1
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0125_p0_276
			""
			RAT_FUNC
			"%9.2"
			"us"
			COEFFS 0 1 0 0 0 0.0125
		/end COMPU_METHOD
		/begin COMPU_METHOD D_2_0v0000032_p0v0000032_277
			""
			RAT_FUNC
			"%9.2"
			"Hz"
			COEFFS 0 -3.2e-006 1 0 3.2e-006 0
		/end COMPU_METHOD
		/begin COMPU_METHOD D_1_0v00005_p0_278
			""
			RAT_FUNC
			"%9.2"
			"kHz"
			COEFFS 0 0 1 0 5e-005 0
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0009765625_p1_279
			""
			RAT_FUNC
			"%9.4"
			"-"
			COEFFS 0 1 -1 0 0 0.000976563
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v00256_p0_280
			""
			RAT_FUNC
			"%9.3"
			"ms/V"
			COEFFS 0 1 0 0 0 0.00256
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0048828125_p0_281
			""
			RAT_FUNC
			"%9.3"
			"V"
			COEFFS 0 1 0 0 0 0.00488281
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v09375_p0_282
			""
			RAT_FUNC
			"%9.2"
			"deg"
			COEFFS 0 1 0 0 0 0.09375
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v064_p0_283
			""
			RAT_FUNC
			"%9.2"
			"s"
			COEFFS 0 1 0 0 0 0.064
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v001_p0_284
			""
			RAT_FUNC
			"%9.3"
			"V"
			COEFFS 0 1 0 0 0 0.001
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v00488_p0_285
			""
			RAT_FUNC
			"%9.3"
			"V"
			COEFFS 0 1 0 0 0 0.00488
		/end COMPU_METHOD
		/begin COMPU_METHOD F_4096_p0_286
			""
			RAT_FUNC
			"%9.2"
			"ms"
			COEFFS 0 1 0 0 0 4096
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v05_p0_287
			""
			RAT_FUNC
			"%9.2"
			"-"
			COEFFS 0 1 0 0 0 0.05
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v078125_p0_288
			""
			RAT_FUNC
			"%9.2"
			"mV"
			COEFFS 0 1 0 0 0 0.078125
		/end COMPU_METHOD
		/begin COMPU_METHOD F_2v9479687_p0_289
			""
			RAT_FUNC
			"%9.2"
			"mV"
			COEFFS 0 1 0 0 0 2.94797
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0512_p0_290
			""
			RAT_FUNC
			"%9.2"
			"ms"
			COEFFS 0 1 0 0 0 0.0512
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0578125_p0_291
			""
			RAT_FUNC
			"%9.2"
			"mb"
			COEFFS 0 1 0 0 0 0.0578125
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v39_p0_292
			""
			RAT_FUNC
			"%9.2"
			"%"
			COEFFS 0 1 0 0 0 0.39
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v1_p0v8_293
			""
			RAT_FUNC
			"%9.2"
			"m/s2"
			COEFFS 0 1 -0.8 0 0 0.1
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0000390625_p0_294
			""
			RAT_FUNC
			"%9.5"
			"km/h"
			COEFFS 0 1 0 0 0 3.90625e-005
		/end COMPU_METHOD
		/begin COMPU_METHOD D_2_0v0004_p0_295
			""
			RAT_FUNC
			"%9.2"
			"kHz"
			COEFFS 0 0 1 0 0.0004 0
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v032_p5_296
			""
			RAT_FUNC
			"%9.2"
			"V"
			COEFFS 0 1 -5 0 0 0.032
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v003_p0_297
			""
			RAT_FUNC
			"%9.3"
			"-"
			COEFFS 0 1 0 0 0 0.003
		/end COMPU_METHOD
		/begin COMPU_METHOD F_4v8828_p0_298
			""
			RAT_FUNC
			"%9.2"
			"mV"
			COEFFS 0 1 0 0 0 4.8828
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v256_p0_299
			""
			RAT_FUNC
			"%9.2"
			"s"
			COEFFS 0 1 0 0 0 0.256
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v125_p0_300
			""
			RAT_FUNC
			"%9.2"
			"s"
			COEFFS 0 1 0 0 0 0.125
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0049_p0_301
			""
			RAT_FUNC
			"%9.3"
			"V"
			COEFFS 0 1 0 0 0 0.0049
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0048828_p0_302
			""
			RAT_FUNC
			"%9.3"
			"V"
			COEFFS 0 1 0 0 0 0.0048828
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0001525875_p0_303
			""
			RAT_FUNC
			"%9.4"
			"V"
			COEFFS 0 1 0 0 0 0.000152587
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v5_p0_304
			""
			RAT_FUNC
			"%9.2"
			"us"
			COEFFS 0 1 0 0 0 0.5
		/end COMPU_METHOD
		/begin COMPU_METHOD F_100_p0_305
			""
			RAT_FUNC
			"%9.2"
			"ms"
			COEFFS 0 1 0 0 0 100
		/end COMPU_METHOD
		/begin COMPU_METHOD F_10_p0_306
			""
			RAT_FUNC
			"%9.2"
			"ms"
			COEFFS 0 1 0 0 0 10
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0003125_p0_307
			""
			RAT_FUNC
			"%9.4"
			"V"
			COEFFS 0 1 0 0 0 0.0003125
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v003906_p0_308
			""
			RAT_FUNC
			"%9.3"
			"-"
			COEFFS 0 1 0 0 0 0.003906
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v000149_p0_309
			""
			RAT_FUNC
			"%9.4"
			"%/V"
			COEFFS 0 1 0 0 0 0.000149
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v02_p0_310
			""
			RAT_FUNC
			"%9.2"
			"1/s"
			COEFFS 0 1 0 0 0 0.02
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v000016_p0_311
			""
			RAT_FUNC
			"%9.5"
			"-"
			COEFFS 0 1 0 0 0 1.6e-005
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v61_p0_312
			""
			RAT_FUNC
			"%9.2"
			"uV.s2/%"
			COEFFS 0 1 0 0 0 0.61
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v61_p0_313
			""
			RAT_FUNC
			"%9.2"
			"uV.s/%"
			COEFFS 0 1 0 0 0 0.61
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0000000466_p0_314
			""
			RAT_FUNC
			"%9.8"
			"%"
			COEFFS 0 1 0 0 0 4.65661e-008
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v64_p0_315
			""
			RAT_FUNC
			"%9.2"
			"1/s"
			COEFFS 0 1 0 0 0 0.64
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0625_p0_316
			""
			RAT_FUNC
			"%9.2"
			"%/s"
			COEFFS 0 1 0 0 0 0.0625
		/end COMPU_METHOD
		/begin COMPU_METHOD F_64_p0_317
			""
			RAT_FUNC
			"%9.2"
			"mV"
			COEFFS 0 1 0 0 0 64
		/end COMPU_METHOD
		/begin COMPU_METHOD F_2_p0_318
			""
			RAT_FUNC
			"%9.2"
			"mV/%"
			COEFFS 0 1 0 0 0 2
		/end COMPU_METHOD
		/begin COMPU_METHOD F_64_p0_319
			""
			RAT_FUNC
			"%9.2"
			"mV/%"
			COEFFS 0 1 0 0 0 64
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0095367_p0_320
			""
			RAT_FUNC
			"%9.3"
			"uV"
			COEFFS 0 1 0 0 0 0.0095367
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v15_p0_321
			""
			RAT_FUNC
			"%9.2"
			"uV/%"
			COEFFS 0 1 0 0 0 0.15
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0976562_p0_322
			""
			RAT_FUNC
			"%9.2"
			"%"
			COEFFS 0 1 0 0 0 0.0976562
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0488281_p0_323
			""
			RAT_FUNC
			"%9.2"
			"%"
			COEFFS 0 1 0 0 0 0.0488281
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v15_p0_324
			""
			RAT_FUNC
			"%9.2"
			"uV.s/%"
			COEFFS 0 1 0 0 0 0.15
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v00097656_p0_325
			""
			RAT_FUNC
			"%9.4"
			"-"
			COEFFS 0 1 0 0 0 0.00097656
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0040690102_p0_326
			""
			RAT_FUNC
			"%9.3"
			"%"
			COEFFS 0 1 0 0 0 0.00406901
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v016276041_p0_327
			""
			RAT_FUNC
			"%9.2"
			"%"
			COEFFS 0 1 0 0 0 0.016276
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v065104164_p0_328
			""
			RAT_FUNC
			"%9.2"
			"%"
			COEFFS 0 1 0 0 0 0.0651042
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v09375_p0_329
			""
			RAT_FUNC
			"%9.2"
			"deg/s"
			COEFFS 0 1 0 0 0 0.09375
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v09375_p0_330
			""
			RAT_FUNC
			"%9.2"
			"�Vil/s"
			COEFFS 0 1 0 0 0 0.09375
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v09375_m12_331
			""
			RAT_FUNC
			"%9.2"
			"deg"
			COEFFS 0 1 12 0 0 0.09375
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v11574074_p0_332
			""
			RAT_FUNC
			"%9.2"
			"%"
			COEFFS 0 1 0 0 0 0.115741
		/end COMPU_METHOD
		/begin COMPU_METHOD F_m0v09375_p0_333
			""
			RAT_FUNC
			"%9.2"
			"deg"
			COEFFS 0 1 0 0 0 -0.09375
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v03125_p0_334
			""
			RAT_FUNC
			"%9.2"
			"ms"
			COEFFS 0 1 0 0 0 0.03125
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0078125_p0_335
			""
			RAT_FUNC
			"%9.3"
			"ms"
			COEFFS 0 1 0 0 0 0.0078125
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0763_p0_336
			""
			RAT_FUNC
			"%9.2"
			"mV"
			COEFFS 0 1 0 0 0 0.0763
		/end COMPU_METHOD
		/begin COMPU_METHOD F_3v05176_p900000_337
			""
			RAT_FUNC
			"%9.2"
			"e-6"
			COEFFS 0 1 -900000 0 0 3.05176
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v05_m10_338
			""
			RAT_FUNC
			"%9.2"
			"m/s2"
			COEFFS 0 1 10 0 0 0.05
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0390625_p0_339
			""
			RAT_FUNC
			"%9.2"
			"�C"
			COEFFS 0 1 0 0 0 0.0390625
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v3921569_p0_340
			""
			RAT_FUNC
			"%9.2"
			"%"
			COEFFS 0 1 0 0 0 0.392157
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v03125_p0_341
			""
			RAT_FUNC
			"%9.2"
			"ohms"
			COEFFS 0 1 0 0 0 0.03125
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v014453125_p103_342
			""
			RAT_FUNC
			"%9.2"
			"mb"
			COEFFS 0 1 -103 0 0 0.0144531
		/end COMPU_METHOD
		/begin COMPU_METHOD F_3v7_p103v5_343
			""
			RAT_FUNC
			"%9.2"
			"mb"
			COEFFS 0 1 -103.5 0 0 3.7
		/end COMPU_METHOD
		/begin COMPU_METHOD F_4_p0_344
			""
			RAT_FUNC
			"%9.2"
			"cm"
			COEFFS 0 1 0 0 0 4
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v925_p103_345
			""
			RAT_FUNC
			"%9.2"
			"mb"
			COEFFS 0 1 -103 0 0 0.925
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0078125_p0_346
			""
			RAT_FUNC
			"%9.3"
			"Kg/s/m^2"
			COEFFS 0 1 0 0 0 0.0078125
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v00000953_m40_347
			""
			RAT_FUNC
			"%9.6"
			"�C"
			COEFFS 0 1 40 0 0 9.53e-006
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0578_p103_348
			""
			RAT_FUNC
			"%9.2"
			"mb"
			COEFFS 0 1 -103 0 0 0.0578
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0078_p0_349
			""
			RAT_FUNC
			"%9.3"
			"K"
			COEFFS 0 1 0 0 0 0.0078
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0009536743_p0_350
			""
			RAT_FUNC
			"%9.4"
			"g/s"
			COEFFS 0 1 0 0 0 0.000953674
		/end COMPU_METHOD
		/begin COMPU_METHOD F_1_p0_351
			""
			RAT_FUNC
			"%9.2"
			"N"
			COEFFS 0 1 0 0 0 1
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0000000291_p0_352
			""
			RAT_FUNC
			"%9.8"
			"(km/h)/s"
			COEFFS 0 1 0 0 0 2.91e-008
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0000762951_p0_353
			""
			RAT_FUNC
			"%9.5"
			"V"
			COEFFS 0 1 0 0 0 7.62951e-005
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v125_p0_354
			""
			RAT_FUNC
			"%9.2"
			"N.m"
			COEFFS 0 1 0 0 0 0.125
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v01_p0_355
			""
			RAT_FUNC
			"%9.2"
			"(km/h)/s"
			COEFFS 0 1 0 0 0 0.01
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v01_p0_356
			""
			RAT_FUNC
			"%9.2"
			"L/h"
			COEFFS 0 1 0 0 0 0.01
		/end COMPU_METHOD
		/begin COMPU_METHOD F_20480_p0_357
			""
			RAT_FUNC
			"%9.2"
			"mm3"
			COEFFS 0 1 0 0 0 20480
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v125_p0_358
			""
			RAT_FUNC
			"%9.2"
			"rad/s"
			COEFFS 0 1 0 0 0 0.125
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v2777778_p0_359
			""
			RAT_FUNC
			"%9.2"
			"m"
			COEFFS 0 1 0 0 0 0.277778
		/end COMPU_METHOD
		/begin COMPU_METHOD F_18204v445_p0_360
			""
			RAT_FUNC
			"%9.2"
			"m"
			COEFFS 0 1 0 0 0 18204.4
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0000003052_p0_361
			""
			RAT_FUNC
			"%9.7"
			"N.m/s"
			COEFFS 0 1 0 0 0 3.0518e-007
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0152588_p0_362
			""
			RAT_FUNC
			"%9.2"
			"g/s"
			COEFFS 0 1 0 0 0 0.0152588
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0001220703_p0_363
			""
			RAT_FUNC
			"%9.4"
			"-"
			COEFFS 0 1 0 0 0 0.00012207
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v00305175_p0_364
			""
			RAT_FUNC
			"%9.3"
			"%"
			COEFFS 0 1 0 0 0 0.00305175
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v00305175_p0_365
			""
			RAT_FUNC
			"%9.3"
			"-"
			COEFFS 0 1 0 0 0 0.00305175
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v015625_m40_366
			""
			RAT_FUNC
			"%9.2"
			"�C"
			COEFFS 0 1 40 0 0 0.015625
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v078125_p0_367
			""
			RAT_FUNC
			"%9.2"
			"W"
			COEFFS 0 1 0 0 0 0.078125
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0000305176_p0_368
			""
			RAT_FUNC
			"%9.5"
			"N.m"
			COEFFS 0 1 0 0 0 3.05176e-005
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v014453_p0_369
			""
			RAT_FUNC
			"%9.2"
			"mb"
			COEFFS 0 1 0 0 0 0.014453
		/end COMPU_METHOD
		/begin COMPU_METHOD F_3v05176_m100000_370
			""
			RAT_FUNC
			"%9.2"
			"e-6"
			COEFFS 0 1 100000 0 0 3.05176
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0000465_m100000_371
			""
			RAT_FUNC
			"%9.5"
			"e-6"
			COEFFS 0 1 100000 0 0 4.65e-005
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0009033203_p0_372
			""
			RAT_FUNC
			"%9.4"
			"mb"
			COEFFS 0 1 0 0 0 0.00090332
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v057813_p0_373
			""
			RAT_FUNC
			"%9.2"
			"mb"
			COEFFS 0 1 0 0 0 0.057813
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v00005646_p103_374
			""
			RAT_FUNC
			"%9.5"
			"mb"
			COEFFS 0 1 -103 0 0 5.646e-005
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v000015259_p0_375
			""
			RAT_FUNC
			"%9.5"
			"tr/min"
			COEFFS 0 1 0 0 0 1.5259e-005
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v00000149_p0_376
			""
			RAT_FUNC
			"%9.6"
			"%"
			COEFFS 0 1 0 0 0 1.49e-006
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0015625_p0_377
			""
			RAT_FUNC
			"%9.3"
			"deg"
			COEFFS 0 1 0 0 0 0.0015625
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v25_p0_378
			""
			RAT_FUNC
			"%9.2"
			"tr/min"
			COEFFS 0 1 0 0 0 0.25
		/end COMPU_METHOD
		/begin COMPU_METHOD F_71v111114_p0_379
			""
			RAT_FUNC
			"%9.2"
			"m"
			COEFFS 0 1 0 0 0 71.1111
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v00076_p0_380
			""
			RAT_FUNC
			"%9.4"
			"%"
			COEFFS 0 1 0 0 0 0.00076
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0014648438_p0_381
			""
			RAT_FUNC
			"%9.3"
			"�Vil"
			COEFFS 0 1 0 0 0 0.00146484
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v375_m200_382
			""
			RAT_FUNC
			"%9.2"
			"deg/s"
			COEFFS 0 1 200 0 0 0.375
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0000305176_p0_383
			""
			RAT_FUNC
			"%9.5"
			"su"
			COEFFS 0 1 0 0 0 3.05176e-005
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0152587891_p0_384
			""
			RAT_FUNC
			"%9.2"
			"g/s"
			COEFFS 0 1 0 0 0 0.0152588
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0976563_p0_385
			""
			RAT_FUNC
			"%9.2"
			"%"
			COEFFS 0 1 0 0 0 0.0976563
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v038125_p0_386
			""
			RAT_FUNC
			"%9.2"
			"-"
			COEFFS 0 1 0 0 0 0.038125
		/end COMPU_METHOD
		/begin COMPU_METHOD F_8v333333_p0_387
			""
			RAT_FUNC
			"%9.2"
			"%"
			COEFFS 0 1 0 0 0 8.33333
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v78125_m100_388
			""
			RAT_FUNC
			"%9.2"
			"%"
			COEFFS 0 1 100 0 0 0.78125
		/end COMPU_METHOD
		/begin COMPU_METHOD F_2_p0_389
			""
			RAT_FUNC
			"%9.2"
			"g/h"
			COEFFS 0 1 0 0 0 2
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v015258_p0_390
			""
			RAT_FUNC
			"%9.2"
			"g/s"
			COEFFS 0 1 0 0 0 0.015258
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v014453125_p0_391
			""
			RAT_FUNC
			"%9.2"
			"mb"
			COEFFS 0 1 0 0 0 0.0144531
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v03125_p5_392
			""
			RAT_FUNC
			"%9.2"
			"V"
			COEFFS 0 1 -5 0 0 0.03125
		/end COMPU_METHOD
		/begin COMPU_METHOD F_1_p0_393
			""
			RAT_FUNC
			"%9.2"
			"Km"
			COEFFS 0 1 0 0 0 1
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v2844141_p0_394
			""
			RAT_FUNC
			"%9.2"
			"m"
			COEFFS 0 1 0 0 0 0.284414
		/end COMPU_METHOD
		/begin COMPU_METHOD F_7v629394_p0_395
			""
			RAT_FUNC
			"%9.2"
			"e-6"
			COEFFS 0 1 0 0 0 7.62939
		/end COMPU_METHOD
		/begin COMPU_METHOD F_65536_p0_396
			""
			RAT_FUNC
			"%9.2"
			"-"
			COEFFS 0 1 0 0 0 65536
		/end COMPU_METHOD
		/begin COMPU_METHOD F_65536_p0_397
			""
			RAT_FUNC
			"%9.2"
			"Pmh"
			COEFFS 0 1 0 0 0 65536
		/end COMPU_METHOD
		/begin COMPU_METHOD F_25_p0_398
			""
			RAT_FUNC
			"%9.2"
			"W"
			COEFFS 0 1 0 0 0 25
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v04376_p0_399
			""
			RAT_FUNC
			"%9.2"
			"-"
			COEFFS 0 1 0 0 0 0.04376
		/end COMPU_METHOD
		/begin COMPU_METHOD F_32_p0_400
			""
			RAT_FUNC
			"%9.2"
			"s"
			COEFFS 0 1 0 0 0 32
		/end COMPU_METHOD
		/begin COMPU_METHOD F_6v75_p0_401
			""
			RAT_FUNC
			"%9.2"
			"us"
			COEFFS 0 1 0 0 0 6.75
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v119209_p0_402
			""
			RAT_FUNC
			"%9.2"
			"e-6"
			COEFFS 0 1 0 0 0 0.119209
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v95367_p0_403
			""
			RAT_FUNC
			"%9.2"
			"e-6"
			COEFFS 0 1 0 0 0 0.95367
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0625_p0_404
			""
			RAT_FUNC
			"%9.2"
			"-"
			COEFFS 0 1 0 0 0 0.0625
		/end COMPU_METHOD
		/begin COMPU_METHOD F_1_p0_405
			""
			RAT_FUNC
			"%9.2"
			"rpm"
			COEFFS 0 1 0 0 0 1
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0031_p0_406
			""
			RAT_FUNC
			"%9.3"
			"%"
			COEFFS 0 1 0 0 0 0.0031
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v000015287_p0_407
			""
			RAT_FUNC
			"%9.5"
			"Kg/s"
			COEFFS 0 1 0 0 0 1.5287e-005
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0078125_m256_408
			""
			RAT_FUNC
			"%9.3"
			"N.m"
			COEFFS 0 1 256 0 0 0.0078125
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v125_p0_409
			""
			RAT_FUNC
			"%9.2"
			"K^0.5"
			COEFFS 0 1 0 0 0 0.125
		/end COMPU_METHOD
		/begin COMPU_METHOD F_7v8125_p0_410
			""
			RAT_FUNC
			"%9.2"
			"g/s/m2"
			COEFFS 0 1 0 0 0 7.8125
		/end COMPU_METHOD
		/begin COMPU_METHOD F_6400_p0_411
			""
			RAT_FUNC
			"%9.2"
			"%"
			COEFFS 0 1 0 0 0 6400
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v816_p0_412
			""
			RAT_FUNC
			"%9.2"
			"ms"
			COEFFS 0 1 0 0 0 0.816
		/end COMPU_METHOD
		/begin COMPU_METHOD F_80_p0_413
			""
			RAT_FUNC
			"%9.2"
			"mm3"
			COEFFS 0 1 0 0 0 80
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v392156_p0_414
			""
			RAT_FUNC
			"%9.2"
			"%"
			COEFFS 0 1 0 0 0 0.392156
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v0000095367_m40_415
			""
			RAT_FUNC
			"%9.6"
			"�C"
			COEFFS 0 1 40 0 0 9.53674e-006
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v15259_p0_416
			""
			RAT_FUNC
			"%9.2"
			"N/(kg.m)"
			COEFFS 0 1 0 0 0 0.15259
		/end COMPU_METHOD
		/begin COMPU_METHOD F_51v2_p0_417
			""
			RAT_FUNC
			"%9.2"
			"us"
			COEFFS 0 1 0 0 0 51.2
		/end COMPU_METHOD
		/begin COMPU_METHOD F_1_p0_418
			""
			RAT_FUNC
			"%9.2"
			"su"
			COEFFS 0 1 0 0 0 1
		/end COMPU_METHOD
		/begin COMPU_METHOD F_0v04166_p0_419
			""
			RAT_FUNC
			"%9.2"
			"su"
			COEFFS 0 1 0 0 0 0.04166
		/end COMPU_METHOD
		/begin COMPU_METHOD Id_0x00
			""
			RAT_FUNC
			"%9.2"
			"."
			COEFFS 0 1 0 0 0 1
		/end COMPU_METHOD
		/begin COMPU_METHOD Bool_ON_OFF
			""
			TAB_VERB
			"%8.4"
			"."
			COMPU_TAB_REF Bool_ON_OFF_table
		/end COMPU_METHOD
		/begin COMPU_VTAB Bool_ON_OFF_table
			""
			TAB_VERB
			2
			0 "OFF"
			1 "ON"
		/end COMPU_VTAB
		/begin RECORD_LAYOUT DATA_RECORD_UBYTE
			FNC_VALUES 1 UBYTE ROW_DIR DIRECT
		/end RECORD_LAYOUT
		/begin RECORD_LAYOUT DATA_RECORD_SBYTE
			FNC_VALUES 1 SBYTE ROW_DIR DIRECT
		/end RECORD_LAYOUT
		/begin RECORD_LAYOUT DATA_RECORD_UWORD
			FNC_VALUES 1 UWORD ROW_DIR DIRECT
		/end RECORD_LAYOUT
		/begin RECORD_LAYOUT DATA_RECORD_SWORD
			FNC_VALUES 1 SWORD ROW_DIR DIRECT
		/end RECORD_LAYOUT
		/begin RECORD_LAYOUT DATA_RECORD_ULONG
			FNC_VALUES 1 ULONG ROW_DIR DIRECT
		/end RECORD_LAYOUT
		/begin RECORD_LAYOUT DATA_RECORD_SLONG
			FNC_VALUES 1 SLONG ROW_DIR DIRECT
		/end RECORD_LAYOUT
		/begin RECORD_LAYOUT DATA_RECORD_FLOAT32_IEEE
			FNC_VALUES 1 FLOAT32_IEEE ROW_DIR DIRECT
		/end RECORD_LAYOUT
		/begin RECORD_LAYOUT AXIS_PTS_X_UBYTE
			AXIS_PTS_X 1 UBYTE INDEX_INCR DIRECT
		/end RECORD_LAYOUT
		/begin RECORD_LAYOUT AXIS_PTS_X_UWORD
			AXIS_PTS_X 1 UWORD INDEX_INCR DIRECT
		/end RECORD_LAYOUT
		/begin FUNCTION FICHES
			""
			/begin SUB_FUNCTION A_AC_AIRXX_XX_A_5_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_AC_CLIQX_A5_A_4_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_AC_COUPX_GP_A_1_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_AC_DCLXX_GP_A_1_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_AC_DYNCX_A7_A_3_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_AC_DYNRX_GP_A_2_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_AC_DYNUX_A5_A_3_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_AC_FILTD_XX_A_5_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_AC_PDAXX_XX_A_2_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_AC_REATX_GP_A_2_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_AC_RPART_GP_A_2_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_AC_SDFLH_XX_A_2_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_AC_TRPRS_A5_A_2_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_AG_AUTOX_ZC_A_1_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_AG_CALFX_XX_A_1_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_AN_CARTO_GP_A_9_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_AN_DEMXX_XX_A_3_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_AN_RALXX_AC_A_1_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_CD_ACTUA_A7_A_2_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_CD_CANIS_A5_A_2_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_CD_GMVTO_AC_A_3_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_CD_HO2DW_XX_A_4_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_CD_HO2UP_A7_A_2_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_CD_OSPDW_A7_A_2_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_CD_OSPUP_A7_A_2_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_CD_PMAIR_A7_A_3_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_CD_POEAU_A5_A_3_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_CD_POMPG_XX_A_1_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_CD_POMPV_AC_A_1_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_CD_POMPX_MP_A_3_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_CD_PTCGI_A7_A_1_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_CD_THERM_AC_A_3_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_CD_TSTAX_XX_A_1_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_CD_VVTXX_XX_A_5_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_DG_E2000_AC_DJ0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_DG_EOBDX_A7_A_8_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_DG_FRAME_AC_WI0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_DG_GPELE_XX_A_1_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_DG_MOUCH_A7_A_3_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_DG_ONCAN_XX_D_10_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_DG_PDSDF_XX_A_1_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_DG_RESER_XX_A_1_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_DG_TQSDF_AC_A_7_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_EF_ALTDF_XX_A_1_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_EF_CPMHX_A7_A_2_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_EF_VITVH_A7_A_3_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_EN_CLUXX_XX_A_5_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_EN_FREIN_XX_A_5_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_EN_MPMPV_AC_A_1_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_EN_PDAXX_AC_A_1_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_ET_AACXX_XX_A_2_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_ET_AIRXX_XX_A_2_2
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_ET_CLQXX_A3_A_4_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_ET_EAUXX_ZC_A_1_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_ET_PRSXX_XX_A_4_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_ET_PSURA_XX_A_3_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_ET_SO2DW_A7_A_6_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_ET_SO2UP_A7_A_5_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_EU_ABSCT_A7_A_1_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_EU_BVAXX_AC_A_8_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_EU_CLMXX_AC_A_1_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_EU_CONBV_A3_A_2_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_EU_ETGPL_XX_A_3_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_EU_MINES_XX_A_3_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_EU_MINGP_XX_A_2_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_EU_PDAXX_XX_A_3_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_EU_PTCXX_AC_A_1_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_EU_SDFTA_AC_A_3_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_EU_TQALT_AC_A_3_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_EU_VITVH_XX_A_3_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_FA_ABINJ_AC_A_1_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_FA_ABINJ_XX_DE1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_FA_ACCSA_XX_A_2_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_FA_ADACX_XX_A_2_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_FA_DEMXX_XX_A_1_2
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_FA_RVLVX_AC_A_2_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_FA_VEROU_V4_D_5_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_FU_ADACX_GP_A_3_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_FU_ALRTO_XX_A_2_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_FU_COMPX_AC_A_1_2
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_FU_ETAMO_84_D_8_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_FU_MILXX_AC_A_1_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_FU_NCYLX_XX_A_1_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_FU_PEDXX_AC_A_5_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_FU_POPED_XX_A_3_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_FU_REGXX_XX_A_3_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_FU_TYPGP_XX_A_1_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_GS_VARSV_AC_A_10_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_IA_DINJM_XX_A_2_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_IC_CYLFG_XX_A_7_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_IC_GADAP_XX_A_2_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_IC_POSTX_GP_A_1_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_IC_RMAXX_XX_A_1_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_ID_DEMXX_XX_A_3_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_ID_FLOOX_MP_A_2_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_ID_PRIJS_XX_A_3_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_IG_AUTOX_XX_A_3_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_IG_CALFG_XX_A_2_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_IG_CALFX_XX_A_1_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_IG_CINJX_GP_A_1_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_IG_DINJV_GP_A_5_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_IG_PHFNX_A5_A_2_2
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_IG_PHOUV_XX_A_2_2
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_IM_AIRXX_A5_A_3_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_IM_CANIS_PR_A_2_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_IM_CARTO_GP_A_2_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_IM_EAUXX_A7_A_4_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_IM_PAFDX_GP_A_8_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_IM_PSSRE_XX_A_1_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_IP_ATMOX_XX_A_2_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_IP_MOUIL_A7_A_4_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_IS_ACLMY_XX_A_2_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_IS_ADAPT_GP_A_1_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_IS_AUTBF_GP_A_3_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_IS_AUTBR_Z7_A_5_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_IS_DBMOY_A5_A_2_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_IS_DBOUC_GP_A_5_2
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_IS_O2DMY_XX_A_2_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_IS_RECOU_XX_A_3_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_OB_CATAX_GP_A_3_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_OB_CLVXX_XX_A_2_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_OB_CONDX_A7_A_4_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_OB_FUELX_GP_A_1_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_OB_GPOBD_GP_A_4_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_OB_MDMSF_GP_A_1_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_OB_MSFIR_GP_A_2_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_OB_OTENX_A7_A_10_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_OB_SAXXX_GP_A_1_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_OB_SO2XX_GP_A_4_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_OB_SQOBD_XX_A_8_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_OB_TLZCO_GP_A_1_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_OB_TLZMF_GP_A_1_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_PM_AUTMA_A7_A_8_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_PM_CANIS_A5_A_2_2
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_PM_CDCLX_A7_A_1_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_PM_CFGPL_XX_A_1_3
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_PM_CLQXX_A5_A_4_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_PM_DEMXX_XX_A_2_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_PM_DGPLX_XX_A_1_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_PM_EAIXX_XX_A_3_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_PM_ESGPL_XX_A_1_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_PM_ETAMO_XX_A_1_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_PM_GADAP_XX_A_1_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_PM_GPLES_XX_A_1_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_PM_MANXX_GP_A_2_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_PM_PHTRA_XX_A_1_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_PM_PMODE_XX_A_1_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_PM_PMVAC_XX_A_1_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_PM_RDEPX_XX_A_3_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_PM_ROULX_AC_A_1_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_RR_AUTOX_XX_A_3_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_RR_BARXX_XX_A_1_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_RR_DERVX_XX_A_2_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_RR_DMINX_AC_A_3_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_RR_INTXX_XX_A_2_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_RR_PROPX_MP_A_2_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_RR_RCMIN_AC_A_5_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_RR_RCOXX_XX_A_3_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_RR_SECRR_AC_A_1_2
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_RR_SLSXX_XX_A_3_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_RR_SUIVX_XX_A_1_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_RR_VARSX_XX_A_3_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_TQ_ARBCI_AC_A_1_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_TQ_ARBRL_AC_A_8_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_TQ_ASREG_XX_A_2_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_TQ_AVDYN_AC_A_3_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_TQ_AVFIN_GP_A_4_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_TQ_AVMAX_XX_A_4_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_TQ_AVMIN_GP_A_6_3
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_TQ_AVOPT_GP_A_2_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_TQ_CMIOP_GP_A_4_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_TQ_COCLQ_GP_A_3_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_TQ_CONSP_XX_A_10_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_TQ_CONWG_A5_A_2_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_TQ_CPLMO_GP_A_4_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_TQ_DMDCP_XX_A_1_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_TQ_DPURG_XX_A_1_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_TQ_FAACP_XX_A_9_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_TQ_FLUXS_XX_A_1_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_TQ_ISMTQ_XX_A_2_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_TQ_LIMFT_A5_A_1_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_TQ_OBJSP_XX_A_7_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_TQ_PCCON_XX_A_4_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_TQ_PERTM_AC_A_1_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_TQ_PRECT_A5_A_1_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_TQ_RAVBA_GP_A_3_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_TQ_RAVCR_XX_A_3_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_TQ_REQCP_XX_A_1_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_TQ_SURPR_A5_A_1_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_TQ_TKTQC_XX_A_3_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_TQ_TQFIN_XX_A_1_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_TQ_TQMAX_A7_A_1_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_TQ_TQMIN_XX_A_2_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_TQ_TQPRO_A7_A_2_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_TQ_TQRAT_XX_A_1_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_VF_BATXX_XX_A_3_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_VF_CLQXX_A3_A_4_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_VF_D1PER_XX_A_2_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_VF_DNDIF_XX_A_1_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_VF_PRSMY_A5_A_2_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_VF_PRSXX_XX_A_1_2
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_VF_REGXX_XX_A_2_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_VF_SO2DW_XX_A_2_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_VR_ACTAX_XX_A_3_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_VR_ALTDF_XX_A_1_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_VR_APCIB_A5_A_2_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_VR_APLCI_XX_A_3_2
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_VR_APLCO_XX_A_2_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_VR_ATMOX_A7_A_5_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_VR_BILBT_XX_A_2_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_VR_CLMXX_AC_A_1_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_VR_CONSR_AC_A_7_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_VR_CRDGC_XX_A_1_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_VR_CTLZX_XX_A_5_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_VR_CTRZX_XX_A_2_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_VR_DAIRM_XX_A_1_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_VR_GECGE_XX_A_3_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_VR_IMRAP_A3_A_3_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_VR_NOACX_AC_A_1_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_VR_NODCL_XX_A_2_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_VR_NTKOF_XX_A_1_2
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_VR_PAPAF_XX_A_2_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_VR_PDAXX_XX_A_7_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_VR_PEDAF_XX_A_4_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_VR_PHAAC_A7_A_2_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_VR_PLPED_XX_A_7_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_VR_PMVAC_XX_A_1_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_VR_PPRED_A7_A_1_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_VR_PTCXX_AC_A_1_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_VR_RAPBV_XX_A_3_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_VR_RECOC_GP_A_5_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_VR_REGMX_XX_A_1_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_VR_REGXX_XX_A_2_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_VR_REMPL_XX_A_2_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_VR_SECBP_A7_A_5_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_VR_SPAPX_XX_A_3_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_VR_TGAZX_A5_A_2_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_VR_TKOFX_XX_A_2_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_VR_TOILX_A7_A_1_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_VR_TQALT_A7_A_3_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_VR_VSNRA_XX_A_2_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_WC_BRAKE_XX_A_4_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_WC_GRBOX_XX_A_6_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_WC_OUTMX_XX_A_3_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_WC_SERVO_XX_A_5_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_WC_STFLW_XX_A_4_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_WC_SWTCH_XX_A_6_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_WC_VSINT_XX_A_4_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION B_AG_DWELL_A3_A_1_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION B_CD_HO2UP_AC_A_1_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION B_DG_KWP20_XX_DA2
			/end SUB_FUNCTION
			/begin SUB_FUNCTION B_DG_ONCAN_XX_D_4_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION B_EF_CPMHX_XX_A_2_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION B_EF_PAQDT_A3_A_1_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION B_EF_VITVH_A3_A_1_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION B_EN_CLUXX_AC_A_1_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION B_ET_CLQXX_XX_A_2_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION B_ET_PRSBF_A7_A_1_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION B_EU_FRAME_M2_DB0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION B_FU_FRAME_M2_D_4_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION B_FU_PFCAN_AC_D_6_0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION B_MU_CONFX_XX_DC0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION B_MU_DIAGR_XX_RD0
			/end SUB_FUNCTION
			/begin SUB_FUNCTION B_MU_PROTG_XX_DA1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION NT_60601/98/1030_11/
			/end SUB_FUNCTION
			/begin SUB_FUNCTION PANNES_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION PON_EEM_NT_03_0538_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION PON_EEM_NT_03_2052_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION PON_EEM_NT_03_2261_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION PON_EEM_NT_03_3032_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION PON_EEM_NT_03_3546_3
			/end SUB_FUNCTION
			/begin SUB_FUNCTION PON_EEM_NT_03_3702_2
			/end SUB_FUNCTION
			/begin SUB_FUNCTION PON_EEM_NT_03_4366_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION PON_EEM_NT_04_0723_2
			/end SUB_FUNCTION
			/begin SUB_FUNCTION PON_EEM_NT_04_0724_2
			/end SUB_FUNCTION
			/begin SUB_FUNCTION PON_EEM_NT_04_0725_2
			/end SUB_FUNCTION
			/begin SUB_FUNCTION PON_EEM_NT_04_0726_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION PON_EEM_NT_04_0727_2
			/end SUB_FUNCTION
			/begin SUB_FUNCTION PON_EEM_NT_04_0728_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION PON_EEM_NT_04_0943_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION PON_EEM_NT_04_0975_2
			/end SUB_FUNCTION
			/begin SUB_FUNCTION PON_EEM_NT_04_1147_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION PON_EEM_NT_04_1244_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION PON_EEM_NT_04_1280_2
			/end SUB_FUNCTION
			/begin SUB_FUNCTION PON_EEM_NT_04_1509_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION PON_EEM_NT_04_1692_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION PON_U47_NT_00_0599_3
			/end SUB_FUNCTION
			/begin SUB_FUNCTION PON_U47_NT_00_0611_7
			/end SUB_FUNCTION
			/begin SUB_FUNCTION PON_U47_NT_00_1080_5
			/end SUB_FUNCTION
			/begin SUB_FUNCTION PON_U47_NT_00_1099_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION PON_U47_NT_00_1478_2
			/end SUB_FUNCTION
			/begin SUB_FUNCTION PON_U47_NT_00_2168_3
			/end SUB_FUNCTION
			/begin SUB_FUNCTION PON_U47_NT_00_2221_4
			/end SUB_FUNCTION
			/begin SUB_FUNCTION PON_U47_NT_00_2253_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION PON_U47_NT_01_0096_4
			/end SUB_FUNCTION
			/begin SUB_FUNCTION PON_U47_NT_01_0373_5
			/end SUB_FUNCTION
			/begin SUB_FUNCTION PON_U47_NT_01_1018_2
			/end SUB_FUNCTION
			/begin SUB_FUNCTION PON_U47_NT_01_1019_2
			/end SUB_FUNCTION
			/begin SUB_FUNCTION PON_U47_NT_01_1285_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION PON_U47_NT_01_1333_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION PON_U47_NT_01_1334_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION PON_U47_NT_01_1419_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION PON_U47_NT_01_1594_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION PON_U47_NT_01_2030_2
			/end SUB_FUNCTION
			/begin SUB_FUNCTION PON_U47_NT_02_0442_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION PON_U47_NT_02_1170_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION PON_U47_NT_02_1173_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION PON_U47_NT_95_0885_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION PON_U47_NT_96_0505_2
			/end SUB_FUNCTION
			/begin SUB_FUNCTION PON_U47_NT_97_1537_3
			/end SUB_FUNCTION
			/begin SUB_FUNCTION PON_U47_NT_97_1679_3
			/end SUB_FUNCTION
			/begin SUB_FUNCTION PON_U47_NT_98_0135_2
			/end SUB_FUNCTION
			/begin SUB_FUNCTION PON_U47_NT_98_0966_4
			/end SUB_FUNCTION
			/begin SUB_FUNCTION PON_U47_NT_98_1557_2
			/end SUB_FUNCTION
			/begin SUB_FUNCTION PON_U47_NT_98_1860_3
			/end SUB_FUNCTION
			/begin SUB_FUNCTION PON_U47_NT_98_1861_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION PON_U47_NT_98_1867_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION PON_U47_NT_98_1938_3
			/end SUB_FUNCTION
			/begin SUB_FUNCTION PON_U47_NT_98_1943_3
			/end SUB_FUNCTION
			/begin SUB_FUNCTION PON_U47_NT_99_0689_1
			/end SUB_FUNCTION
			/begin SUB_FUNCTION PON_U47_NT_99_2423_5
			/end SUB_FUNCTION
			/begin SUB_FUNCTION PON_U47_NT_99_2510_9
			/end SUB_FUNCTION
		/end FUNCTION
		/begin FUNCTION FONCTIONS
			""
			/begin SUB_FUNCTION Injection
			/end SUB_FUNCTION
			/begin SUB_FUNCTION Miscellaneous_8
			/end SUB_FUNCTION
			/begin SUB_FUNCTION Misfire
			/end SUB_FUNCTION
			/begin SUB_FUNCTION Noyau
			/end SUB_FUNCTION
			/begin SUB_FUNCTION Miscellaneous
			/end SUB_FUNCTION
			/begin SUB_FUNCTION Phase_moteur
			/end SUB_FUNCTION
			/begin SUB_FUNCTION Reg_ralenti
			/end SUB_FUNCTION
			/begin SUB_FUNCTION Reinit
			/end SUB_FUNCTION
			/begin SUB_FUNCTION Sdf
			/end SUB_FUNCTION
			/begin SUB_FUNCTION z_Logiciel
			/end SUB_FUNCTION
			/begin SUB_FUNCTION Gpl
			/end SUB_FUNCTION
			/begin SUB_FUNCTION Development_z
			/end SUB_FUNCTION
			/begin SUB_FUNCTION Var_syst
			/end SUB_FUNCTION
			/begin SUB_FUNCTION Cliquetis
			/end SUB_FUNCTION
			/begin SUB_FUNCTION Diagnostic_9
			/end SUB_FUNCTION
			/begin SUB_FUNCTION Generale
			/end SUB_FUNCTION
			/begin SUB_FUNCTION Avance
			/end SUB_FUNCTION
			/begin SUB_FUNCTION Commandes
			/end SUB_FUNCTION
			/begin SUB_FUNCTION Config
			/end SUB_FUNCTION
			/begin SUB_FUNCTION Controle_couple
			/end SUB_FUNCTION
			/begin SUB_FUNCTION d_Diagnostic
			/end SUB_FUNCTION
			/begin SUB_FUNCTION Diagnostic
			/end SUB_FUNCTION
			/begin SUB_FUNCTION Divers
			/end SUB_FUNCTION
			/begin SUB_FUNCTION Fcts_annexes
			/end SUB_FUNCTION
			/begin SUB_FUNCTION Acquisitions
			/end SUB_FUNCTION
		/end FUNCTION
		/begin FUNCTION OBD
			""
			/begin SUB_FUNCTION OBD_MAP
			/end SUB_FUNCTION
			/begin SUB_FUNCTION OBD_GPL_MAP
			/end SUB_FUNCTION
			/begin DEF_CHARACTERISTIC
				Cxx_sa_n_min
				Cxx_lbup_asd_diag_nr
				Cxx_sa_tco_min
				Cxx_fsys_dly_1
				Cxx_mis_n_max_agb_clos_no
				Cxx_fsys_cor_fac_max_2
				Cxx_sa_n_dif_max
				Cxx_fsys_cor_fac_min_1
				Cxx_fsys_cor_fac_min_2
				Cxx_sa_n_max
				Cxx_lbup_asd_in_nr
				Cxx_sa_stop_diag_lbdw_thd
				Cxx_fsys_thd_2_eol_dly
				Cxx_fsys_thd_2_dly
				Cxx_fsys_n_min_thd
				Cxx_fsys_n_max_thd
				Cxx_fsys_eol_dly
				Cxx_fsys_eal_min_thd
				Cxx_fsys_eal_max_thd
				Cxx_fsys_dly_2
				Cxx_lbup_asd_sf_nr
				Cxx_sa_maf_max
				Cxx_fsys_cor_fac_eol_max
				Cxx_fsys_cor_fac_eol_min
				Cxx_fsys_cor_fac_max_1
				Cxx_sa_dec_nr
				Cxx_sa_eol_tco_min
				Cxx_sa_vb_min
				Cxx_sa_lbdw_dif_thd
				Cxx_sa_mes_dly
				Cxx_sa_maf_min
				Cxx_sa_map_dif_max
				Cxx_sa_map_fac
				Cxx_sa_map_max
				Cxx_sa_map_min
				Ctb_mis_tlz_cor_eal_lpg
				Cmp_mis_tlz_cor_cyl_0
				Cmp_mis_tlz_cor_cyl_0_lpg
				Cmp_mis_tlz_cor_cyl_1
				Cmp_mis_tlz_cor_cyl_1_lpg
				Cmp_mis_tlz_cor_cyl_2
				Cmp_mis_tlz_cor_cyl_2_lpg
				Cbx_mod_bch_diag_sa
				Cbx_conf_schd_diag_sa
				Cxx_min_diag_fsys_dly
				Cxx_min_diag_fsys_eol_dly
				Ctb_mis_tlz_cor_eal
				Ctb_mis_tlz_cor_n
				Ctb_mis_tlz_cor_n_lpg
				Cxx_mis_km_dly
				Cxx_clos_thr_tia_min
				Cxx_cata_asd_diag_nr
				Cxx_cata_asd_in_nr
				Cxx_cata_asd_sf_nr
				Cbx_conf_schd_diag_fsys
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION Appli
			""
			/begin SUB_FUNCTION A_Rvlv
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_DIV
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_MAP
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_SDF
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_S/T
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_OBD
			/end SUB_FUNCTION
			/begin SUB_FUNCTION A_Appli
			/end SUB_FUNCTION
		/end FUNCTION
		/begin FUNCTION MAP
			""
			/begin SUB_FUNCTION M_Rvlv
			/end SUB_FUNCTION
			/begin SUB_FUNCTION M_OBD
			/end SUB_FUNCTION
			/begin SUB_FUNCTION M_MAP
			/end SUB_FUNCTION
		/end FUNCTION
		/begin FUNCTION D�pollution
			""
			/begin SUB_FUNCTION Double_boucle_MAP
			/end SUB_FUNCTION
			/begin SUB_FUNCTION Chauffage_sonde_MAP
			/end SUB_FUNCTION
			/begin SUB_FUNCTION Purge_Canister_MAP
			/end SUB_FUNCTION
			/begin SUB_FUNCTION Double_boucle_GPL_MAP
			/end SUB_FUNCTION
			/begin SUB_FUNCTION R�gulation_Rich_MAP
			/end SUB_FUNCTION
			/begin SUB_FUNCTION R�gulation_Rich_GPL_MAP
			/end SUB_FUNCTION
			/begin SUB_FUNCTION Purge_Canister_GPL_MAP
			/end SUB_FUNCTION
			/begin SUB_FUNCTION Automate_MEA_GPL_MAP
			/end SUB_FUNCTION
			/begin SUB_FUNCTION Automate_MEA_MAP
			/end SUB_FUNCTION
			/begin SUB_FUNCTION Adaptatif_Rich_GPL_MAP
			/end SUB_FUNCTION
			/begin SUB_FUNCTION Adaptatif_Rich_MAP
			/end SUB_FUNCTION
		/end FUNCTION
		/begin FUNCTION Syst�me
			""
			/begin SUB_FUNCTION SDF_Acquisitions_sys
			/end SUB_FUNCTION
			/begin SUB_FUNCTION SDF_VVT_sys
			/end SUB_FUNCTION
			/begin SUB_FUNCTION VVT_sys
			/end SUB_FUNCTION
			/begin SUB_FUNCTION SDF_Voyant_MD
			/end SUB_FUNCTION
			/begin SUB_FUNCTION R�gul_Ralenti_sys
			/end SUB_FUNCTION
			/begin SUB_FUNCTION SDF_Voyant_autre
			/end SUB_FUNCTION
			/begin SUB_FUNCTION VSC_sys
			/end SUB_FUNCTION
			/begin SUB_FUNCTION SDF_sys
			/end SUB_FUNCTION
			/begin SUB_FUNCTION Verrou_sys
			/end SUB_FUNCTION
			/begin SUB_FUNCTION SDF_Sural_sys
			/end SUB_FUNCTION
			/begin SUB_FUNCTION Sural_sys
			/end SUB_FUNCTION
			/begin SUB_FUNCTION SDF_Etats_moteur_sys
			/end SUB_FUNCTION
			/begin SUB_FUNCTION RVLV_sys
			/end SUB_FUNCTION
			/begin SUB_FUNCTION SDF_LIS_sys
			/end SUB_FUNCTION
			/begin SUB_FUNCTION SDF_VVT_voyant_MD
			/end SUB_FUNCTION
			/begin SUB_FUNCTION SDF_Alim_sys
			/end SUB_FUNCTION
			/begin SUB_FUNCTION SDF_BVA_sys
			/end SUB_FUNCTION
			/begin SUB_FUNCTION SDF_Calculateur
			/end SUB_FUNCTION
			/begin SUB_FUNCTION SDF_CAN_sys
			/end SUB_FUNCTION
			/begin SUB_FUNCTION SDF_Configuration_sys
			/end SUB_FUNCTION
			/begin SUB_FUNCTION Services_diag_sys
			/end SUB_FUNCTION
			/begin SUB_FUNCTION SDF_Pression_sys
			/end SUB_FUNCTION
			/begin SUB_FUNCTION SDF_P�dale_sys
			/end SUB_FUNCTION
			/begin SUB_FUNCTION SDF_Papillon_sys
			/end SUB_FUNCTION
			/begin SUB_FUNCTION Sondes_sys
			/end SUB_FUNCTION
			/begin SUB_FUNCTION SDF_SC_sys
			/end SUB_FUNCTION
			/begin SUB_FUNCTION Etats_moteur_sys
			/end SUB_FUNCTION
			/begin SUB_FUNCTION Configuration_sys
			/end SUB_FUNCTION
			/begin SUB_FUNCTION Climatisation_sys
			/end SUB_FUNCTION
			/begin SUB_FUNCTION Papillon_sys
			/end SUB_FUNCTION
			/begin SUB_FUNCTION OBD_sys
			/end SUB_FUNCTION
			/begin SUB_FUNCTION LIS_sys
			/end SUB_FUNCTION
			/begin SUB_FUNCTION Injection_sys
			/end SUB_FUNCTION
			/begin SUB_FUNCTION P�dale_sys
			/end SUB_FUNCTION
			/begin SUB_FUNCTION Anti-K_sys
			/end SUB_FUNCTION
			/begin SUB_FUNCTION Airbag_sys
			/end SUB_FUNCTION
			/begin SUB_FUNCTION CTP_borne_DF_sys
			/end SUB_FUNCTION
			/begin SUB_FUNCTION Bobines_sys
			/end SUB_FUNCTION
			/begin SUB_FUNCTION Pression_sys
			/end SUB_FUNCTION
			/begin SUB_FUNCTION Purge_Canister_sys
			/end SUB_FUNCTION
			/begin SUB_FUNCTION CAN_sys
			/end SUB_FUNCTION
			/begin SUB_FUNCTION Reco_Cylindre_sys
			/end SUB_FUNCTION
			/begin SUB_FUNCTION BVA_sys
			/end SUB_FUNCTION
			/begin SUB_FUNCTION Acquisitions_sys
			/end SUB_FUNCTION
			/begin DEF_CHARACTERISTIC
				Cxx_c_id3
				Calib_mask_inhibe_sdf_
				Autorise_raz_eeprom
				Cbx_ac_mux
				Autorise_test_id_pour_raz_eeprom
				Calibration_debut
				Cxx_c_id11
				Cxx_c_id7
				Cxx_1_thr_lh_chk_lim_max
				Cxx_2_thr_lh_chk_lim_max
				Cxx_acc_bk
				Cxx_acc_frm_abst_nr
				Cxx_acc_neut
				Cxx_c_id5
				Cxx_acc_stt_cge_dly_2
				Ctd_slop_psi_fac
				Cxx_c_id10
				Ctd_ofs_psi_fac
				Cxx_c_id12
				Cxx_c_id13
				Cxx_c_id14
				Cxx_c_id15
				Cxx_c_id16
				Cxx_c_id2
				Cxx_c_id4
				Cxx_c_id6
				Cxx_c_id1
				Chauf_gpl_current_slewrate_neg
				Cbx_mvac_pump_conf
				Cbx_mux_pwst_prs_dsb
				Cbx_shift_diag_ena_typ
				Cbx_shift_mcut_diag_manu_inh
				Cbx_shift_pdl_chr_diag_manu_inh
				Cbx_shift_svkl_diag_manu_inh
				Cbx_shift_thr_chr_diag_manu_inh
				Cbx_thpl_conf
				Ctp_pred_map_prs_rat
				Cbx_wpmp_conf
				Cxx_agb_abst_nr_fail
				Chauf_gpl_current_slewrate_pos
				Chauf_gpl_current_voltage_maxi
				Chauf_gpl_current_voltage_mini
				Chauf_gpl_plus_slewrate_neg
				Chauf_gpl_plus_slewrate_pos
				Chauf_gpl_running_delay
				Ctb_pred_map_prs_rat
				Ctb_psi_fac_cor
				Cbx_tsta_conf
				Cxx_ecu_nr5
				Cxx_c_id8
				Cxx_dft_lght_on_inc
				Cxx_diag_nr
				Cxx_gear_ctr
				Cbx_l_pwl_conf
				Cxx_dft_lght_km_rst_wup
				Cxx_fac_n_grd
				Cxx_ctr_frm_csm_lpg
				Cxx_ecu_nr4
				Cxx_ecu_nr3
				Cxx_ecu_nr2
				Cxx_ecu_nr1
				Cxx_dyn_iga_dsb_n_thd
				Cxx_acc_stt_cge_dly_1
				Cxx_foot_up_lh_thresh
				Cxx_clu_fail_vs_thd
				Cxx_c_id9
				Cxx_c_nr1
				Cxx_c_nr2
				Cxx_cert_nr1
				Cxx_cert_nr2
				Cxx_cert_nr3
				Cxx_dft_lght_on_dec
				Cxx_cert_nr5
				Cxx_ctr_frm_csm_gas
				Cxx_hw_nr5
				Cxx_hw_nr4
				Cxx_csm_fil_fac
				Cxx_hw_nr3
				Cxx_hw_nr2
				Cxx_hw_nr1
				Cxx_cert_nr4
				Cxx_pfinc_mvac_pump_vb_sc
				Cxx_pfinc_mvac_sys
				Cxx_pfinc_obd_cata
				Cxx_pfinc_obd_lamb
				Cxx_pfinc_obd_sa
				Cxx_pfinc_oil_cc
				Cxx_toil_tco_cnt
				Cxx_tia_reprog_max
				Cxx_vers_nr2
				Cxx_pfinc_mvac_pump_scg
				Cxx_pfinc_pmh_cc
				Cxx_pfinc_mis_polu
				Cxx_pfinc_pmh_co
				Cxx_pfinc_pow_lbdw
				Cxx_pfinc_pow_lbup
				Cxx_pfinc_ptc
				Cxx_pfinc_ptc_rov_oc
				Cxx_pfinc_ptc_rov_scg
				Cxx_pfinc_ptc_rov_vb_sc
				Cxx_pfinc_reserve_3_oc
				Cxx_pfinc_reserve_3_scg
				Cxx_pfinc_reserve_3_vb_sc
				Cxx_pfinc_sa_ev_oc
				Cxx_pfinc_sa_ev_scg
				Cxx_pfinc_oil_co
				Cxx_pfinc_mdf2_oc
				Cxx_mfnrsta_bkup_mem
				Cxx_mfnrsta_alt_mux
				Cxx_mfnrsta_alt_load_in
				Cxx_mfnrsta_alt_ecu
				Cxx_pfinc_lpg_rcpt
				Cxx_pfinc_mastervac_cc
				Cxx_pfinc_mastervac_oc
				Cxx_pfinc_mdf1_oc
				Cxx_pfinc_mdf1_scg
				Cxx_mfnrsta_actr_rly_cut
				Cxx_pfinc_mvac_pump_oc
				Cxx_pfinc_mdf1_vb_sc
				Cxx_pfinc_sa_ev_vb_sc
				Cxx_mfnrsta_vs_eal
				Cxx_pfinc_mdf2_vb_sc
				Valeur_cpt_pp_trig_edic
				Cxx_pfinc_min_lpg_lvl
				Cxx_pfinc_mis_cata
				Cxx_pfinc_mis_cata_gas
				Cxx_pfinc_mis_fast
				Cxx_pfinc_mis_lih
				Cxx_pfinc_sa_vb_sc
				Cxx_pfinc_mis_polu_gas
				Cxx_mfnrsta_actr_rly
				Seuil_detection_gas_pump_oc
				Eep_inhib_nb_ecritures
				Dcntrzvl
				Val_tempo_connexion_pav_2
				Val_tempo_connexion_pav_1
				Val_tempo_connexion_gmv
				Val_tempo_connexion_ev_iae
				Cxx_pfinc_lbup_pump_crt
				Cxx_pfinc_mdf2_scg
				Time_out_max_com_spi
				Cxx_thd_can_ncyl_dly
				Cxx_pfinc_sa_oc
				Temps_diag_etat_bas_wpmp_disable
				Cxx_wpmp_cmd_vb_thd_maxi
				Temps_diag_disable
				Temps_cmd_appli_disable
				Cxx_sys_c_nr
				Cxx_svkl_oc_max_error
				Taux_misfire_souhaite_
				Cxx_svkl_oc_lh_pos_thresh
				Cxx_svkl_oc_diag_dsb_delay
				Cxx_supl_nr1
				Cxx_supl_nr2
				Cxx_supl_nr3
				Temps_max_sauvegarde_eeprom
				Cxx_vers_nr1
				Cxx_pfinc_sa_scg
				Cxx_svkl_oc_detect_delay
				Cxx_pfinc_swlk_mem
				Cxx_pfinc_tco_acq
				Cxx_pfinc_tco_chr
				Cxx_pfinc_thpl_oc
				Cxx_pfinc_thpl_scg
				Cxx_pfinc_thpl_vb_sc
				Cxx_pfinc_tlz_ad_b
				Cxx_wpmp_cmd_tco_thd_hys
				Delai_coupure_relais
				Cxx_wpmp_cmd_tco_thd_mini
				Delai_coupure_cmd_gpl
				Cxx_prog_nr2
				Cxx_ptc_lbup_conf
				Cxx_ptc_lih_pow
				Cxx_pwl_dly
				Cxx_sens_pdl_fil_max_grd
				Val_tempo_connexion_wpmp
				Val_tempo_connexion_thp_
				Val_tempo_connexion_ptc_rov
				Val_tempo_connexion_pmpair
				Cxx_wpmp_cmd_vb_thd_hys
				Cxx_prog_nr1
				Cxx_thr_sens_shift_diag_dly
				Cxx_mfnrsta_pmh_cc
				Cxx_pfdec_eng_temp_oc
				Cxx_pfdec_lbup_hot_vb_sc
				Cxx_mfnrsta_clu
				Cxx_pfdec_lbdw_pump_crt
				Cxx_pfinc_min_gas_lvl
				Cxx_pfdec_lbdw_hot_oc
				Cxx_pfdec_knk
				Cxx_pfdec_lpg_rcpt
				Cxx_pfdec_eng_whl
				Cxx_pfdec_mastervac_cc
				Cxx_mfnrsta_pmh_co
				Cxx_pfdec_eng_temp_vb_sc
				Cxx_pfdec_eng_temp_scg
				Cxx_mfnrsta_ptc
				Cxx_mfnrsta_ptc_rov_oc
				Cxx_mfnrsta_ptc_rov_scg
				Cxx_pfdec_mvac_pump_vb_sc
				Cxx_pfdec_fsys
				Cxx_pfdec_min_gas_lvl
				Cxx_pfdec_mvac_pump_scg
				Cxx_pfdec_mvac_pump_oc
				Cxx_pfdec_mis_polu_gas
				Cxx_pfdec_mis_polu
				Cxx_pfdec_mis_lih
				Cxx_pfdec_mis_fast
				Cxx_pfdec_mis_cata_gas
				Cxx_pfdec_lbup_pump_crt
				Cxx_pfdec_min_lpg_lvl
				Cxx_pfdec_crk_nr
				Cxx_pfdec_mdf2_vb_sc
				Cxx_pfdec_mdf2_scg
				Cxx_pfdec_mdf2_oc
				Cxx_pfdec_mdf1_vb_sc
				Cxx_pfdec_mdf1_scg
				Cxx_pfdec_mdf1_oc
				Cxx_pfdec_mastervac_oc
				Cxx_pfdec_mis_cata
				Cxx_mfnrsta_thpl_scg
				Cxx_mfnrsta_ptc_rov_vb_sc
				Cxx_mfnrsta_sa_scg
				Cxx_mfnrsta_sa_vb_sc
				Cxx_ok_ini_dly
				Cxx_nr_cyl_dsb_n_thd
				Cxx_n_min_out_cart_iga
				Cxx_n_max_clc_dsb
				Cxx_mfnrsta_sa_ev_vb_sc
				Cxx_mfnrsta_thpl_oc
				Cxx_mfnrsta_sa_ev_scg
				Cxx_mfnrsta_thpl_vb_sc
				Cxx_min_pwl_dly
				Cxx_mfnrsta_tia_high
				Cxx_mfnrsta_tia_low
				Cxx_mfnrsta_vs_parasite
				Cxx_mfnrsta_tlz_ad_b
				Cxx_mfnrsta_vs_mux
				Cxx_mfnrsta_swlk_mem
				Cxx_pfdec_alt_ecu
				Cxx_pfdec_crk
				Cxx_pfdec_cp_oc
				Cxx_pfdec_clu
				Cxx_pfdec_bkup_mem
				Cxx_pfdec_alt_mux
				Cxx_pfdec_alt_load_in
				Cxx_mfnrsta_reserve_3_oc
				Cxx_mfnrsta_sa_oc
				Cxx_mfnrsta_reserve_3_vb_sc
				Cxx_pfdec_lbup_hot_oc
				Cxx_pfdec_agb_gear
				Cxx_pfdec_agb_conv_stt
				Cxx_pfdec_actr_rly_cut
				Cxx_pfdec_actr_rly
				Cxx_pfdec_ac_prs
				Cxx_pdl_sens_shift_diag_dly
				Cxx_mfnrsta_sa_ev_oc
				Cxx_mfnrsta_reserve_3_scg
				Cxx_pfinc_actr_rly_cut
				Cxx_pfdec_thpl_vb_sc
				Cxx_pfinc_knk
				Cxx_pfdec_mvac_sys
				Cxx_pfinc_lbdw_hot_oc
				Cxx_pfinc_lbdw_hot_vb_sc
				Cxx_mfnrsta_crk_nr
				Cxx_mfnrsta_crk
				Cxx_pfinc_fsys
				Cxx_pfinc_lbup_hot_vb_sc
				Cxx_pfinc_agb_conv_stt
				Cxx_pfinc_actr_rly
				Cxx_pfinc_ac_prs
				Cxx_pfdec_vs_parasite
				Cxx_pfdec_vs_mux
				Cxx_pfdec_vs_eal
				Cxx_pfdec_tlz_ad_b
				Cxx_pfdec_tia_low
				Cxx_pfdec_tia_high
				Cxx_pfinc_lbup_hot_oc
				Cxx_pfinc_crk
				Cxx_mfnrsta_eng_temp_scg
				Cxx_mfnrsta_eng_temp_vb_sc
				Cxx_mfnrsta_eng_whl
				Cxx_mfnrsta_fsys
				Cxx_pfinc_eng_temp_vb_sc
				Cxx_pfinc_eng_temp_scg
				Cxx_pfinc_eng_temp_oc
				Cxx_pfdec_lbdw_hot_vb_sc
				Cxx_pfinc_crk_nr
				Cxx_pfinc_lbdw_pump_crt
				Cxx_pfinc_eng_whl
				Cxx_pfinc_cp_oc
				Cxx_pfinc_clu
				Cxx_pfinc_bkup_mem
				Cxx_pfinc_alt_mux
				Cxx_pfinc_alt_load_in
				Cxx_pfinc_alt_ecu
				Cxx_pfinc_agb_gear
				Cxx_mfnrsta_eng_temp_oc
				Cxx_pfdec_pow_lbup
				Cxx_pfdec_ptc_rov_vb_sc
				Cxx_mfnrsta_lpg_rcpt
				Cxx_pfdec_ptc_rov_scg
				Cxx_pfdec_ptc_rov_oc
				Cxx_pfdec_pow_lbdw
				Cxx_mfnrsta_mastervac_cc
				Cxx_mfnrsta_min_lpg_lvl
				Cxx_pfdec_pmh_co
				Cxx_pfdec_ptc
				Cxx_mfnrsta_lbup_pump_crt
				Cxx_mfnrsta_mdf2_vb_sc
				Cxx_mfnrsta_mdf2_scg
				Cxx_pfdec_thpl_scg
				Cxx_mfnrsta_mdf2_oc
				Cxx_mfnrsta_mdf1_vb_sc
				Cxx_mfnrsta_mdf1_scg
				Cxx_mfnrsta_mdf1_oc
				Cxx_mfnrsta_mastervac_oc
				Cxx_pfdec_obd_sa
				Cxx_pfdec_thpl_oc
				Cxx_pfdec_swlk_mem
				Cxx_pfdec_sa_vb_sc
				Cxx_pfdec_sa_scg
				Cxx_mfnrsta_lbdw_pump_crt
				Cxx_pfdec_sa_oc
				Cxx_pfdec_sa_ev_vb_sc
				Cxx_pfdec_reserve_3_oc
				Cxx_pfdec_obd_lamb
				Cxx_pfdec_sa_ev_scg
				Cxx_pfdec_sa_ev_oc
				Cxx_pfdec_oil_cc
				Cxx_pfdec_reserve_3_vb_sc
				Cxx_pfdec_oil_co
				Cxx_pfdec_pmh_cc
				Cxx_pfdec_reserve_3_scg
				Cxx_pfdec_obd_cata
				Cbx_air_pump_conf
				Cbx_agb_csm_tq_conf
				Cbx_clos_typ_prs_cnt
				Cbx_agb_clck_test_ena
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION GMP
			""
			/begin SUB_FUNCTION SDF_R�gul_Ralenti_MAP
			/end SUB_FUNCTION
			/begin SUB_FUNCTION Mouillage_MAP
			/end SUB_FUNCTION
			/begin SUB_FUNCTION SDF_MAP
			/end SUB_FUNCTION
			/begin SUB_FUNCTION R�gul_Ralenti_MAP
			/end SUB_FUNCTION
			/begin SUB_FUNCTION Chaud_MAP
			/end SUB_FUNCTION
			/begin SUB_FUNCTION SDF_LIS_MAP
			/end SUB_FUNCTION
			/begin SUB_FUNCTION SDF_D�part_MAP
			/end SUB_FUNCTION
			/begin SUB_FUNCTION SDF_GPL_MAP
			/end SUB_FUNCTION
			/begin SUB_FUNCTION SDF_Agr�ment_MAP
			/end SUB_FUNCTION
			/begin SUB_FUNCTION D�part_GPL_MAP
			/end SUB_FUNCTION
			/begin SUB_FUNCTION R�servoir_vide_GPL_MAP
			/end SUB_FUNCTION
			/begin SUB_FUNCTION Transition_gaz_GPL_MAP
			/end SUB_FUNCTION
			/begin SUB_FUNCTION Reco_Cylindre_GPL_MAP
			/end SUB_FUNCTION
			/begin SUB_FUNCTION Reco_Cylindre_MAP
			/end SUB_FUNCTION
			/begin SUB_FUNCTION R�gul_Ralenti_GPL_MAP
			/end SUB_FUNCTION
			/begin SUB_FUNCTION D�part_MAP
			/end SUB_FUNCTION
			/begin SUB_FUNCTION Agr�ment_GPL_MAP
			/end SUB_FUNCTION
			/begin SUB_FUNCTION Agr�ment_MAP
			/end SUB_FUNCTION
		/end FUNCTION
		/begin FUNCTION Base
			""
			/begin SUB_FUNCTION Structure_Couple_MAP
			/end SUB_FUNCTION
			/begin SUB_FUNCTION R�glage_de_Base_MAP
			/end SUB_FUNCTION
			/begin SUB_FUNCTION Anti-K_MAP
			/end SUB_FUNCTION
			/begin SUB_FUNCTION VVT_MAP
			/end SUB_FUNCTION
			/begin SUB_FUNCTION R�glage_de_Base_GPL_MAP
			/end SUB_FUNCTION
			/begin SUB_FUNCTION SDF_SC_MAP
			/end SUB_FUNCTION
			/begin SUB_FUNCTION SDF_R�glage_de_Base_MAP
			/end SUB_FUNCTION
			/begin SUB_FUNCTION SDF_Sural_MAP
			/end SUB_FUNCTION
			/begin SUB_FUNCTION Structure_Couple_GPL_MAP
			/end SUB_FUNCTION
		/end FUNCTION
		/begin FUNCTION A_AC_AIRXX_XX_A_5_0
			"correction d'avance en fonction de la temperature"
			/begin DEF_CHARACTERISTIC
				Ctb_n6
				Cmp_tia_iga_cor
				Ctp_map_tia_iga_cor
				Cxx_tia_iga_cor_prs
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_AC_CLIQX_A5_A_4_0
			"correction d'avance due au cliquetis"
			/begin DEF_CHARACTERISTIC
				Cxx_knk_fast_cor_iga_thd
				Cxx_knk_fast_cor_dec_ctr
				Cxx_knk_slow_cor_prs_dif
				Cxx_knk_slow_cor_dec_ctr
				Cxx_knk_slow_cor_iga_inc
				Cxx_knk_1cyl_slow_cor_max
				Cxx_knk_2cyl_slow_dif_max
				Cxx_knk_fast_cor_iga_max
				Cxx_knk_slow_cor_iga_max
				Ctp_n_knk_fast_inc_iga
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_AC_COUPX_GP_A_1_0
			"correction d'avance avant coupure"
			/begin DEF_CHARACTERISTIC
				Ctp_tqr_cut
				Ctp_tqr_cut_lpg
				Cxx_cut_tqr_thd_prs_lpg
				Cxx_cut_tqr_thd_prs
				Cxx_cut_tqr_thd_n_lpg
				Cxx_cut_tqr_thd_n
				Cxx_cut_fac_step_dec
				Cxx_tqr_clu_ac_ofs
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_AC_DCLXX_GP_A_1_0
			"correction d'avance en pied lev�"
			/begin DEF_CHARACTERISTIC
				Ctp_tqr_ct_fmt
				Cxx_ct_fac_step_dec
				Cxx_ct_fac_step_inc
				Ctp_tqr_ct
				Cxx_tqr_ct_thd_prs
				Cxx_tqr_ct_thd_prs_lpg
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_AC_DYNCX_A7_A_3_0
			"condition d'avance dynamique universelle"
			/begin DEF_CHARACTERISTIC
				Cxx_stab_dyn_prs_up_thd
				Cxx_cart_dyn_iga_tco_thd
				Cxx_cart_dyn_iga_vs
				Cbx_cylr_dyn_iga_off
				Cxx_stab_dyn_prs_l_thd
				Cxx_is_dyn_iga_n_ofs
				Cxx_stab_dyn_dif_prs_thd
				Cxx_n_lim_is_dyn_iga_dly
				Cxx_stab_dyn_iga_n_thd
				Ctd_gear_cart_dyn_n_thd
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_AC_DYNRX_GP_A_2_0
			"Correction d'avance dynamique au ralenti"
			/begin DEF_CHARACTERISTIC
				Ctp_n_dri_dyn_iga_fac5
				Cxx_max_stop_dyn_iga4
				Cxx_max_run_dyn_iga
				Cxx_max_stop_dyn_iga
				Cxx_max_stop_dyn_iga5
				Cxx_max_run_dyn_iga5
				Ctp_n_dri_dyn_iga_fac
				Ctp_n_dri_dyn_iga_fac_lpg
				Ctp_n_dri_dyn_iga_fac1
				Ctp_n_dri_dyn_iga_fac2
				Ctp_n_dri_dyn_iga_fac4
				Ctp_n_neut_dyn_iga_fac1
				Ctp_n_neut_dyn_iga_fac3
				Ctp_n_neut_dyn_iga_fac4
				Ctp_n_neut_dyn_iga_fac5
				Ctp_n_neut_dyn_iga_fac6
				Ctp_n_neut_dyn_iga_fac
				Cxx_max_stop_dyn_iga3
				Ctp_n_dri_dyn_iga_fac3
				Cxx_stop_dyn_iga_ofs_lpg
				Cxx_max_stop_dyn_iga2
				Cxx_max_run_dyn_iga_lpg
				Cxx_max_stop_ac_dyn_iga1
				Cxx_max_stop_dyn_iga_lpg
				Ctp_n_neut_dyn_iga_fac2
				Cxx_max_run_ac_dyn_iga1
				Cxx_max_run_dyn_iga_fac
				Cxx_stop_dyn_iga_ofs
				Cxx_run_dyn_iga_ofs
				Cxx_max_run_dyn_iga4
				Cxx_run_dyn_iga_ofs_lpg
				Cxx_max_stop_dyn_iga1
				Cxx_max_stop_ac_dyn_iga
				Cxx_max_run_dyn_iga3
				Cxx_max_run_dyn_iga2
				Cxx_max_run_dyn_iga1
				Cxx_max_run_ac_dyn_iga
				Cxx_run_ac_dyn_iga_fac
				Cxx_stop_ac_dyn_iga_fac
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_AC_DYNUX_A5_A_3_0
			"correction d'avance dynamique universelle"
			/begin DEF_CHARACTERISTIC
				Cxx_fast_tq_max_lim30
				Cxx_aj_fast_tq_tco_thd
				Cxx_gear_cge_tq_max_ofs
				Cmp_gear_cge_tq_min_ofs
				Cmp_n_prs_aj_fast_tq_fac
				Cxx_stab_aj_fast_tq_fac
				Cxx_fast_tq_min_lim30
				Cxx_fast_tq_min_lim20
				Cxx_fast_tq_min_lim10
				Ctb_n_gear_cge
				Cxx_aj_fast_tq_dsb_n_thd
				Cxx_fast_tq_max_lim10
				Ctp_prs_fast_tq_max_lim
				Ctp_prs_fast_tq_min_lim
				Ctp_fast_tq_cold_min_lim
				Ctd_gear_aj_fast_tq_fac
				Cxx_fast_tq_max_lim20
				Cxx_stab_aj_fast_tq_ofs
				Ctp_n_aj_fast_tq_dif_thd
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_AC_FILTD_XX_A_5_0
			"filtrage pour l'avance dynamique universelle"
			/begin DEF_CHARACTERISTIC
				Cxx_dyn_iga_fil_ini_n_ofs
				Cxx_dyn_iga_mv_clc_dly
				Cxx_dyn_iga_gear_val
				Cxx_min_dyn_gear_cge_ofs
				Cxx_dyn_iga_pdl_rel
				Cxx_dyn_iga_pdl_rel_hys
				Cxx_dyn_iga_vs_hys
				Cxx_stab_dyn_iga_fil_fac
				Cxx_dyn_iga_fil_n_ofs
				Cxx_dyn_iga_vs
				Cxx_dyn_iga_mv_n_fac
				Cxx_sta_n_fil_fac
				Cxx_dyn_iga_mv_n_thd
				Cxx_min_dyn_iga_tq
				Cxx_is_dyn_iga_fil_fac
				Cxx_max_dyn_iga_tq
				Cxx_dyn_iga_dsb_n_thd
				Ctd_gear_dyn_iga_fil
				Cxx_sta_dyn_iga_mv_n_fac
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_AC_PDAXX_XX_A_2_0
			"Retrait avance PDA"
			/begin DEF_CHARACTERISTIC
				Ctp_pwst_iga_cor_max_lim
				Cxx_pwst_iga_cor_cge_t
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_AC_REATX_GP_A_2_0
			"correction d'avance au reattelage"
			/begin DEF_CHARACTERISTIC
				Ctp_tqr_swi_lpg
				Cxx_tqr_rtn_nr_tdc_gear2
				Cxx_tqr_rtn_nr_tdc_gear1
				Cxx_tqr_rtn_nr_tdc
				Cxx_tqr_swi_nr_tdc
				Cxx_tqr_nr_tdc_gear1
				Cxx_tqr_swi_rtn_nr_tdc
				Cxx_tqr_nr_tdc
				Cxx_swi_cor_n_thd
				Cxx_tqr_rtn_nr_tdc_lpg
				Cxx_tqr_max
				Cxx_tqr_max_lpg
				Ctp_tqr_swi_fmt
				Ctp_tqr_swi
				Cxx_tqr_step_dec
				Cxx_tqr_step_dec_gear1
				Cxx_tqr_swi_step_inc
				Cxx_tqr_max_gear1
				Cxx_tqr_max_gear1_lpg
				Cxx_tqr_swi_rtn_nr_tdc1
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_AC_RPART_GP_A_2_0
			"correction d'avance au r�attelage"
			/begin DEF_CHARACTERISTIC
				Cxx_cyl4_ti_dstb_iga_is
				Cbx_rich_dstb_iga_cor
				Cxx_cyl3_ti_dstb_iga_is
				Cxx_cyl2_ti_dstb_iga_is
				Cxx_cyl1_ti_dstb_iga_is
				Cxx_cyl4_ti_dstb_iga_lpg
				Cxx_cyl3_ti_dstb_iga_lpg
				Cxx_cyl3_ti_dstb_iga
				Cxx_cyl2_ti_dstb_iga_lpg
				Cxx_cyl2_ti_dstb_iga
				Cxx_cyl1_ti_dstb_iga
				Cxx_cyl1_ti_dstb_iga_lpg
				Cxx_cyl4_ti_dstb_iga
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_AC_SDFLH_XX_A_2_1
			"correction d'avance au passage en limp home"
			/begin DEF_CHARACTERISTIC
				Cxx_lih_iga_max_cor_rtn_t
				Cxx_lih_iga_max_cor
				Ctp_lih_iga_prmt_cor
				Cxx_lih_iga_cor_dec_t
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_AC_TRPRS_A5_A_2_0
			"correction d'avance sur transitoire de pression"
			/begin DEF_CHARACTERISTIC
				Cxx_prs_pred_prs_dif_thd
				Cxx_n_iga_tco_thd
				Ctd_n_iga_pred_prs_thd
				Ctd_n_prs_trs_cor_iga
				Ctd_n_iga_prs_thd
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_AG_AUTOX_ZC_A_1_0
			"automate de gestion de l'avance nominale"
			/begin DEF_CHARACTERISTIC
				Cxx_n_ofs_cart_iga_stop2
				Cxx_n_ofs_in_sta_iga
				Cxx_n_ofs_is_iga_stop_vh3
				Cxx_n_ofs_is_iga_stop_vh1
				Cxx_n_ofs_is_iga_run_vh1
				Cxx_iga_is_deci_in_n_thd
				Cxx_iga_is_deci_in_dly
				Cxx_n_ofs_is_iga_stop_vh2
				Cxx_n_ofs_cart_iga_stop
				Cxx_n_ofs_is_iga_stop_vh
				Cxx_n_min_out_cart_iga
				Cxx_n_cmp_n_is_sp_in_sta
				Cxx_n_ofs_cart_iga_run_vh
				Cxx_n_ofs_is_iga_run_vh
				Cxx_n_ofs_out_sta_iga
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_AG_CALFX_XX_A_1_0
			"calcul final de l'avance"
			/begin DEF_CHARACTERISTIC
				Cxx_n_lim_sta_iga_dec
				Cxx_sta_iga_dec
				Cxx_n_lim_sta_iga_inc
				Cxx_sta_iga_dec_tdc_nr
				Cxx_gear1_iga_dec_tdc_nr
				Cxx_iga_dec_tdc_nr
				Cxx_gear_iga_dec
				Cxx_gear1_iga_dec
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_AN_CARTO_GP_A_9_0
			"calcul de l'avance cartographique"
			/begin DEF_CHARACTERISTIC
				Cmp_n_tq_cart_l_iga_cor
				Cbx_wup_fil_tq_dsb
				Ctb_iga_cata_wup_ctr
				Ctp_h_l_iga_cata_wup
				Ctb_rel_tq_wup
				Ctb_n_wup
				Cxx_cart_iga_fil_dec
				Cmp_n_tq_lpg_wup_iga_cor
				Cmp_n_tq_cart_iga_cor1
				Cmp_n_tq_cart_h_iga_cor
				Cxx_cart_iga_fil_cold_inc
				Cxx_cart_iga_fil_inc
				Cmp_n_eal_lpg_cor_iga
				Cxx_vvtc_min_iga_cor
				Cxx_vvtc_h_trt
				Ctp_vvtc_angl_iga_fac1
				Ctp_vvtc_angl_iga_fac2
				Cmp_n_eal_vvtc_iga
				Cmp_n_eal_vvtc_on_iga
				Cmp_n_eal_vvtc_off_iga
				Ctp_n_kd_iga_cor
				Cmp_eal_tco_cart_iga_cor
				Cmp_n_tq_lpg_wup_iga_cor1
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_AN_DEMXX_XX_A_3_1
			"calcul de l'avance au d�marrage"
			/begin DEF_CHARACTERISTIC
				Ctp_n_hot_eng_sta_iga
				Ctp_tco_lim_sta_iga
				Ctp_n_cold_eng_sta_iga
				Cxx_hot_sta_iga_tco_thd
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_AN_RALXX_AC_A_1_1
			"calcul de l'avance ralenti"
			/begin DEF_CHARACTERISTIC
				Ctp_cold_neut_is_iga_cor1
				Ctp_cold_drag_red_is_iga_cor
				Ctp_neut_cata_is_iga_cor1
				Ctp_neut_cata_is_iga_cor
				Ctp_dri_cata_is_iga_cor
				Ctp_tq_agb_is_iga_lpg
				Ctp_tq_agb_is_iga
				Ctp_cold_neut_is_iga_cor
				Cxx_cold_sta_tco
				Ctp_drag_red_cata_is_iga_cor
				Ctp_cold_dri_is_iga_cor
				Ctp_tco_dri_is_iga_lpg
				Ctp_tco_is_bas_iga_lpg
				Ctp_tco_dri_agb_is_iga
				Ctp_ac_pow_is_iga
				Ctp_ac_pow_dri_is_iga
				Cxx_is_iga_cor_fil_step
				Cxx_is_iga_sp_max_ofs
				Cxx_is_iga_prop_sp_fac
				Ctp_tco_is_bas_iga
				Ctb_csm_agb_tq
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_CD_ACTUA_A7_A_2_0
			"commande du relais actuateurs"
			/begin DEF_CHARACTERISTIC
				Cbx_l_pwl_conf
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_CD_CANIS_A5_A_2_0
			"gestion de la purge canister par rco"
			/begin DEF_CHARACTERISTIC
				Cxx_cp_pwm_step_1
				Cxx_cp_pwm_step_5
				Cxx_cp_pwm_min_1
				Cmp_prs_n_pwm_cp
				Cxx_cp_hys_n_frq
				Cxx_cp_n_frq
				Cxx_cp_flr_min_2
				Cxx_cp_flr_min_1
				Cxx_cp_frq_2
				Cxx_cp_frq_1
				Cxx_cp_pwm_cor_max
				Cxx_cp_pwm_min_2
				Cxx_cp_pwm_max_1
				Cxx_cp_fac_pwm
				Cxx_cp_pwm_step_3
				Cxx_cp_pwm_max_4
				Cxx_cp_pwm_step_4
				Cxx_cp_pwm_max_3
				Cxx_cp_pwm_sp2
				Cxx_cp_pwm_sp4
				Cxx_cp_pwm_sp1
				Cxx_cp_pwm_sp3
				Cxx_cp_pwm_step_2
				Cxx_cp_pwm_max_2
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_CD_GMVTO_AC_A_3_0
			"Formatage de la commande GMV intersyst�me"
			/begin DEF_CHARACTERISTIC
				Cxx_tco_fail_cmd_mdf_dly
				Val_tempo_connexion_gmv
				Cxx_mdf1_on_tco_thd
				Cxx_mdf1_off_tco_thd
				Cxx_run_mdf1_off_tco_thd
				Cxx_ac_dsb_tco_thd
				Cbx_agb_mdf2_conf
				Cxx_ac_ena_tco_thd
				Cxx_mdf2_off_tco_thd
				Cxx_mdf2_on_tco_thd
				Cxx_mon_stop_tco_thd
				Cxx_cmd_mdf_dly
				Cxx_tco_mdf_dly
				Cxx_mdf1_clu_dly
				Cxx_mdf1_clu_off_dly
				Cxx_mdf_1_cmd_ena_thd_tco
				Cxx_mdf1_on_tco_thd_hys
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_CD_HO2DW_XX_A_4_0
			"chauffage de la sonde � oxyg�ne aval"
			/begin DEF_CHARACTERISTIC
				Cxx_lbdw_hot_cmd_dly2
				Cbx_lbdw
				Cxx_lbdw_hot_cmd_vs_hys
				Ctp_tco_lbdw_hot_dly
				Cbx_lbdw_typ
				Cxx_lbdw_hot_pwm1_dly2
				Cxx_lbdw_hot_pwm_per1
				Cxx_lbdw_hot_cmd_dly1
				Ctp_n_lbdw_hot_dsb_map
				Cxx_lbdw_hot_pwm1_dly1
				Cxx_lbdw_hot_pwm_dly_inc
				Cxx_lbdw_hot_cmd_map_hys
				Cxx_lbdw_hot_pwm_per2
				Cxx_lbdw_hot_dsb_vs
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_CD_HO2UP_A7_A_2_1
			"chauffage de la sonde � oxyg�ne amont"
			/begin DEF_CHARACTERISTIC
				Cxx_lbup_tco_rest_thd
				Ctb_t_lbup_hot_rest
				Ctb_t_lbup_hot_sta
				Ctd_t_rat_lbup_rest
				Ctd_t_rat_lbup_sta
				Ctp_tco_lbup_hot_dly
				Cxx_lbup_cold_sta_rat
				Cxx_lbup_dft_pwm
				Cxx_lbup_max_vb_thd
				Cxx_lbup_rms_v
				Cxx_lbup_hot_pwm_dly_inc
				Cbx_lbup_hot_cho
				Cxx_lbup_min_vb_thd
				Cxx_lbup_hot_cmd_vs_hys
				Cxx_lbup_hot_pwm_per2
				Cxx_lbup_hot_cmd_dly1
				Cxx_lbup_hot_cmd_map_hys
				Cxx_lbup_hot_dsb_vs
				Cbx_lbup_dwpt_per_ena
				Cxx_lbup_hot_pwm_per1
				Ctp_n_lbup_hot_dsb_map
				Cxx_lbup_hot_pwm1_dly1
				Cxx_lbup_hot_pwm1_dly2
				Cbx_lbup_typ
				Cxx_lbup_hot_cmd_dly2
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_CD_OSPDW_A7_A_2_0
			"command of the pumping current for the downstream"
			/begin DEF_CHARACTERISTIC
				Cxx_lbdw_pump_crt_dly
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_CD_OSPUP_A7_A_2_0
			"commande du courant de pompage de la sonde amont"
			/begin DEF_CHARACTERISTIC
				Cxx_lbup_pump_crt_dly
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_CD_PMAIR_A7_A_3_1
			"automate de pompe � air"
			/begin DEF_CHARACTERISTIC
				Ctp_air_pump_sta_tdc_thd
				Cxx_air_pump_stop_dly
				Cxx_sa_diag_lbdw_thd
				Ctp_air_pump_stop_tdc_thd
				Val_tempo_connexion_pmpair
				Cxx_sa_dly_is_cor
				Cxx_sa_alt_dly_is_cor
				Cxx_air_pump_sta_dly
				Cbx_air_pump_conf
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_CD_POEAU_A5_A_3_0
			"gestion de la pompe � eau"
			/begin DEF_CHARACTERISTIC
				Val_tempo_connexion_wpmp
				Cxx_wpmp_max_t
				Cxx_wpmp_max_tco_t
				Cxx_wpmp_tco_hys
				Cxx_wpmp_tco_thd
				Cbx_wpmp_conf
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_CD_POMPG_XX_A_1_0
			"coupure pompe a essence en gpl"
			/begin DEF_CHARACTERISTIC
				Cbx_min_lvl_pump_cut_ena
				Cxx_lpg_pump_run_cdn_dly
				Cxx_lpg_gas_pump_wup_dly
				Cxx_lpg_gas_pump_cut_dly
				Cxx_lpg_aper_pump_run_dly
				Cxx_lpg_aper_dly
				Cbx_lpg_aper_pump_run_ena
				Cxx_lpg_aper_n_thd
				Cbx_lpg_gas_pump_cut_ena
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_CD_POMPV_AC_A_1_0
			"commande de la pompe � vide"
			/begin DEF_CHARACTERISTIC
				Cxx_mvac_pump_max_run_t
				Cxx_mvac_pump_dft_aftr_run_t
				Cxx_mvac_pump_dft_max_run_t
				Val_tempo_connexion_pav_2
				Val_tempo_connexion_pav_1
				Cxx_mvac_pump_aftr_run_t
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_CD_POMPX_MP_A_3_0
			"commande du relais pompe � essence"
			/begin DEF_CHARACTERISTIC
				Cxx_gas_pump_sta_dly
				Cxx_sta_gas_pump_n_thd
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_CD_PTCGI_A7_A_1_0
			"commande ptc du circuit de r�aspiration des vapeur"
			/begin DEF_CHARACTERISTIC
				Cxx_ptc_rov_tia_hys
				Cxx_ptc_rov_tia_thd
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_CD_THERM_AC_A_3_0
			"Commande des thermoplongeurs"
			/begin DEF_CHARACTERISTIC
				Val_tempo_connexion_thp_
				Cbx_thpl_conf
				Ctp_thpl_el_csm_vb
				Ctp_thpl_tco
				Cxx_thpl_tco_hys
				Cxx_thpl_pos_el_csm_fac
				Cxx_thpl_fil_vb_fac
				Cxx_thpl_dsb_max_dly
				Cxx_thpl_off_dly
				Cxx_thpl_pos_el_csm_thd
				Cxx_thpl_neg_el_csm_thd
				Cxx_thpl_neg_el_csm_fac
				Cxx_thpl_vb_aftr_sta_dly
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_CD_TSTAX_XX_A_1_1
			"gestion du thermostat pilot�"
			/begin DEF_CHARACTERISTIC
				Cbx_tsta_conf
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_CD_VVTXX_XX_A_5_0
			"gestion du d�caleur d'arbre � cames"
			/begin DEF_CHARACTERISTIC
				Cxx_vvt_cmd_min_vb
				Cxx_in_hot_temp_thd
				Cxx_vvtc_act_temp_h_hys
				Ctp_vvtc_act_temp_h_thd
				Ctb_vvt_n1
				Cxx_cmd_vvt_req_off_tdc
				Cxx_iga_vvt_req_off_tdc
				Cxx_vvt_off_thd
				Cxx_vvt_on_thd
				Cxx_iga_vvt_req_on_tdc
				Cxx_inj_vvt_req_on_tdc
				Cbx_bch_tco_toil_2
				Cxx_vvt_conf
				Cxx_in_hot_temp_hys
				Cxx_vvt_req_on_tdc
				Cxx_hot_vb_thd
				Cxx_vvt_cmd_min_tco
				Cxx_inj_vvt_req_off_tdc
				Cxx_vvt_req_off_tdc
				Cmp_n_prs_vvt
				Cxx_bch_in_angl
				Cbx_bch_in_angl
				Ctb_vvt_n2
				Cmp_n_tq_vvtc_hot_in_angl
				Ctb_tq
				Cxx_vvtc_act_ena_n_hys
				Cxx_vvtc_act_ena_n_thd
				Cxx_vvtc_dsb_ena_fil_inc
				Cbx_bch_tco_toil
				Cxx_cmd_vvt_req_on_tdc
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_DG_E2000_AC_DJ0
			"param�trage reformul� des services diagnostic esse"
			/begin DEF_CHARACTERISTIC
				Fcallon
				Fcinjoff
				Pap_poson
				Pap_posoff
				Table_nb_cycle_test_actionneur_
				Autorisation_test_power_latch_
				Fcinjon
				Test_stat_duree_ho2_
				Test_stat_duree_divers_2_
				Test_stat_duree_divers_1_
				Test_stat_duree_actionneurs_
				Temps_apres_test_actionneur_
				Fcinjcyc
				Fcallcyc
				Table_temps_test_actionneur
				Fcallof
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_DG_EOBDX_A7_A_8_0
			"service de communication obd"
			/begin DEF_CHARACTERISTIC
				Cxx_obd_conf_mod_9_2
				Cxx_c_id12
				Cxx_c_id11
				Cxx_c_id10
				Cxx_c_id1
				Cxx_c_id13
				Cxx_obd_conf_mod_9_3
				Cxx_c_id4
				Cxx_obd_conf_mod_9_4
				Cxx_c_id14
				Cxx_c_id15
				Cxx_c_id16
				Cxx_c_id3
				Cxx_c_id9
				Cxx_c_id6
				Cxx_c_id5
				Cxx_c_id8
				Cxx_obd_conf_mod_9_1
				Cxx_c_id2
				Cxx_obd_conf_mod_1_4
				Cxx_obd_conf_obd
				Cxx_c_id7
				Cxx_obd_conf_mod_1_1
				Cxx_obd_conf_mod_1_3
				Cxx_obd_conf_mod_1_5
				Cxx_obd_conf_mod_1_6
				Cxx_obd_conf_mod_1_7
				Cxx_obd_conf_mod_1_8
				Cxx_obd_conf_mod_2_1
				Cxx_obd_conf_mod_6_4
				Cxx_obd_conf_lamb
				Cxx_obd_conf_mod_1_2
				Cxx_obd_conf_mod_2_2
				Cxx_obd_conf_diag_schd
				Cxx_obd_conf_diag_prmt
				Cxx_obd_conf_mod_6_3
				Cxx_obd_conf_mod_6_2
				Cxx_obd_conf_mod_6_1
				Cxx_obd_conf_mod_2_4
				Cxx_obd_conf_mod_2_3
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_DG_FRAME_AC_WI0
			"Description des trames diagnostic sur DIAG K et CA"
			/begin DEF_CHARACTERISTIC
				Cxx_supl_nr1
				Cxx_hw_nr2
				Cxx_cert_nr4
				Cxx_supl_nr3
				Cxx_cert_nr2
				Cxx_supl_nr2
				Cxx_cert_nr5
				Cxx_hw_nr1
				Cxx_hw_nr3
				Cxx_hw_nr5
				Cxx_cert_nr1
				Cxx_diag_nr
				Cxx_hw_nr4
				Cxx_ecu_nr3
				Cxx_cert_nr3
				Cxx_ecu_nr2
				Cxx_etun_nr
				Cxx_ecu_nr1
				Cxx_ecu_nr4
				Cxx_ecu_nr5
				Cxx_c_nr2
				Cxx_prog_nr1
				Cxx_prog_nr2
				Cxx_vers_nr1
				Cxx_vers_nr2
				Cxx_c_nr1
				Cxx_sys_c_nr
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_DG_GPELE_XX_A_1_0
			"gestionnaire de pannes electriques"
			/begin DEF_CHARACTERISTIC
				Cbx_inj_srs1_dsb_vvtc_1
				Cbx_inj_srs2_dsb_vvtc_1
				Cbx_inj_srs2_dsb_vvtc_0
				Cbx_inj_srs2_dsb_5
				Cbx_inj_srs2_dsb_4
				Cbx_inj_srs2_dsb_3
				Cbx_inj_srs2_dsb_2
				Cbx_inj_srs2_dsb_0
				Cbx_inj_srs1_dsb_5
				Cbx_inj_srs1_dsb_4
				Cbx_inj_srs1_dsb_3
				Cbx_inj_srs1_dsb_2
				Cbx_inj_srs1_dsb_1
				Cbx_inj_srs1_dsb_0
				Cbx_inj_srs2_dsb_1
				Cbx_inj_srs1_dsb_vvtc_0
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_DG_MOUCH_A7_A_3_1
			"comptage des kilom�tres voyant allum�"
			/begin DEF_CHARACTERISTIC
				Cxx_dft_lght_on_inc
				Cxx_dft_lght_km_rst_wup
				Cxx_dft_lght_on_dec
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_DG_ONCAN_XX_D_10_0
			"diagnosis on can"
			/begin DEF_CHARACTERISTIC
				Tmnp3
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_DG_PDSDF_XX_A_1_1
			"pedal diagnosis for safety. diagnostic sdf de la p"
			/begin DEF_CHARACTERISTIC
				Cxx_rams_max_ct_pdl
				Cxx_rams_min_ct_pdl
				Cxx_rams_pdl_dif
				Cxx_rams_ct_pdl_psn
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_DG_RESER_XX_A_1_0
			"diagnostic de reservoir gpl vide"
			/begin DEF_CHARACTERISTIC
				Cxx_lpg_prs_fil_fac
				Cxx_min_lpg_cl_n_thd
				Cxx_lpg_stall_dly
				Cxx_prs_dif_lpg_cdn_thd
				Cxx_min_lpg_fl_n_thd
				Cxx_min_lpg_cl_prs_thd
				Cxx_lpg_max_nr_lpg_stall
				Cxx_lpg_diag_ti_fac_thd
				Cxx_lpg_fl_lean_diag_dly
				Cxx_lpg_cl_lean_diag_dly
				Cbx_lpg_prs_diag_ena
				Cbx_lpg_min_lvl_diag_ena
				Cxx_min_lpg_fl_prs_thd
				Cxx_lpg_prs_diag_dly
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_DG_TQSDF_AC_A_7_1
			"Torque request diagnosis for safety"
			/begin DEF_CHARACTERISTIC
				Cxx_rams_tkof_n_thd
				Cmp_rams_map_n_esti_tqe
				Nxx_rams_pow_tq_trs_ac
				Cxx_rams_pwst_tq_loss
				Cxx_rams_esti_tq_fail_thd
				Cxx_rams_tq_req_fail_thd
				Cxx_rams_tkof_tqe_cor
				Ctp_rams_l_vs_pdl_fac
				Cxx_rams_ovt_dly
				Cxx_rams_tq_dec_mask_t
				Ctp_rams_n_tqi_dyn_lim
				Cxx_rams_max_tq_dec
				Ctp_rams_h_vs_pdl_fac
				Ctb_rams_tq_req
				Ctp_rams_rvr_pdl_fac
				Cxx_rams_pdl_max_psn_thd
				Cxx_rams_ena_diag_gear
				Cxx_rams_ena_diag_tkof_tq
				Cbx_rams_lpg_lpg_mod_ena
				Cmp_rams_lpg_esti_tqe
				Cbx_rams_ena_diag_ma
				Cbx_rams_tq_loss_ad_dsb
				Cxx_rams_ena_diag_dly_3
				Cxx_rams_fmt_pdl_vs_thd
				Cxx_rams_ena_diag_n_thd
				Cxx_rams_ena_diag_tco_thd
				Cbx_rams_ovt_act
				Cmp_rams_frn_tq_loss
				Cmp_rams_pump_tq_loss
				Ctp_rams_driv_tq_fil_acel
				Ctp_rams_driv_tq_fil_decl
				Ctp_rams_esti_tqe_neg_err
				Cxx_rams_fail_dec
				Cxx_rams_fl_tqr_thd2
				Cxx_rams_fl_tqr_thd1
				Cmp_rams_pdl_n_abv_tqe
				Ctp_rams_esti_tqe_pos_err
				Cxx_rams_fail_dec_dly
				Cxx_rams_ena_diag_dly_2
				Cxx_rams_ena_diag_dly_1
				Ctp_rams_tq_req_pos_err
				Ctp_rams_tq_req_neg_err
				Ctp_rams_n_ovt_tqi_ofs
				Ctp_rams_n_max_tqi
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_EF_ALTDF_XX_A_1_0
			"acquisition alternateur filaire."
			/begin DEF_CHARACTERISTIC
				Cxx_l_alt_temp_mv
				Cbx_df_in_fil_ena
				Cxx_h_alt_v_temp_fac
				Cxx_l_alt_temp_ref
				Cxx_h_alt_v_ref
				Cxx_l_alt_v_ref
				Cxx_h_alt_temp_ref
				Cxx_l_alt_v_temp_fac
				Cxx_alt_temp_tco_ofs
				Cxx_l_alt_temp_min_v
				Cxx_alt_crt_esti_dly
				Cxx_h_alt_temp_mv
				Cxx_alt_v_fil_fac
				Cxx_h_alt_temp_min_v
				Cxx_h_alt_ind
				Cxx_h_alt_vb_ofs
				Cxx_l_alt_vb_ofs
				Cbx_alt_v_fil_ena
				Cxx_max_alt_pwm
				Cxx_min_alt_pwm
				Cxx_l_alt_temp_max_grd
				Cxx_l_alt_ind
				Cxx_h_alt_r_mv
				Cxx_l_alt_r_mv
				Cxx_h_alt_temp_fac
				Cxx_l_alt_temp_fac
				Cxx_h_alt_temp_max_grd
				Cxx_alt_rat_fail_dly
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_EF_CPMHX_A7_A_2_1
			"acquisition signal dent"
			/begin DEF_CHARACTERISTIC
				Cxx_h_thd_prs_sp_fail
				Cxx_h_dif_prs_dsb_sp
				Cxx_thd_syn_fail_per
				Cxx_h_thd_dif_prs_dsb_sp
				Cxx_l_thd_dif_prs_dsb_sp
				Cxx_nr_vld_crk_fail1
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_EF_VITVH_A7_A_3_0
			"acquisition vitesse vehicule"
			/begin DEF_CHARACTERISTIC
				Ctp_max_dif_clc_vs
				Cxx_vs_thd_vs_sens_vld
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_EN_CLUXX_XX_A_5_0
			"formatage de l'information contact embrayage"
			/begin DEF_CHARACTERISTIC
				Cxx_clu_fail_vs_thd
				Cxx_gear_cge_dly
				Cxx_gear_ctr
				Cxx_gear_vs_thd
				Cxx_gear_cge_vs_dly
				Cxx_gear_cge_eal_thd
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_EN_FREIN_XX_A_5_0
			"axquisition pedale de frein"
			/begin DEF_CHARACTERISTIC
				Cbx_brk_pdl_conf
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_EN_MPMPV_AC_A_1_0
			"acquisition etat du mano-contact de pompe a vide"
			/begin DEF_CHARACTERISTIC
				Cbx_clos_typ_prs_cnt
				Cbx_mvac_pump_conf
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_EN_PDAXX_AC_A_1_0
			"acquisition pressostat de da"
			/begin DEF_CHARACTERISTIC
				Cxx_pwst_prs_tco_thd
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_ET_AACXX_XX_A_2_0
			"acquisition de l'angle vvt"
			/begin DEF_CHARACTERISTIC
				Cxx_fil_fac_vvtc_dif
				Cxx_h_vvtc_fil_fac
				Cxx_l_vvtc_fil_fac
				Cxx_vvtc_in_sp_fil_fac
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_ET_AIRXX_XX_A_2_2
			"acquisition de la temp�rature d'air"
			/begin DEF_CHARACTERISTIC
				Cxx_tia_tco_fail_sta_tia
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_ET_CLQXX_A3_A_4_0
			"acquisition cliquetis"
			/begin DEF_CHARACTERISTIC
				Ctp_n_knk_fil_fac_1_4
				Ctp_n_knk_fil_fac_2_3
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_ET_EAUXX_ZC_A_1_0
			"acquisition temp�rature d'eau"
			/begin DEF_CHARACTERISTIC
				Cxx_tco_mdl_max
				Ctb_tco_mdl
				Ctp_tco_dif_max
				Ctp_tco_mdl_tdc_nr
				Cxx_tco_mon_dly
				Cxx_mem_tco_fail_max_tco
				Cxx_tco_inc_tdc_nr
				Cxx_tia_tco_fail_sta_tco
				Ctb_tco_dif_max
				Cxx_tco_chr_fil_dly
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_ET_PRSXX_XX_A_4_1
			"diagnostic fonctionnel de la pression collecteur"
			/begin DEF_CHARACTERISTIC
				Cxx_spg_fail_ctr
				Ctb_wet_cor_map
				Ctb_map
				Cxx_min_mes_prs_fail_sens
				Cxx_max_mes_prs_fail_sens
				Cxx_rel_thd_thr_prs_h_err
				Cxx_l_thd_prs_l_fail
				Cxx_min_n_test_acq
				Cxx_dif_mes_esti_prs_err
				Cxx_max_val_dif_prs_acq
				Cxx_nr_tdc_dif_prs_fail
				Cxx_h_thd_prs_h_fail
				Ctp_n_map_fil_fac
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_ET_PSURA_XX_A_3_0
			"acquisition de la pression de suralimentation"
			/begin DEF_CHARACTERISTIC
				Cxx_tq_stab_thd
				Cxx_spg_diag_dsb
				Cxx_spg_diag_max_tia
				Cxx_spg_diag_min_tia
				Cxx_spg_dly
				Cxx_spg_fail_l_thd
				Cxx_spg_fail_up_thd
				Cxx_spg_min
				Cxx_spg_sys_diag_dly
				Cxx_thr_psn_dif_thd
				Ctb_spg_n
				Ctp_n_spg_dft_mod
				Cxx_min_amp
				Cxx_spg_n_thd
				Ctb_alti
				Cxx_max_amp
				Cbx_up_thr_prs_sens
				Cmp_tq_n_spg_fail_thd
				Ctb_tq_stat_ref
				Ctp_n_amp_spg_dif_cut
				Cxx_stab_spg_dif_thd
				Cxx_amp_spg_dif_fac
				Cmp_spg_alti_cor
				Cxx_fil_thr_psn_dif_thd
				Ctp_spg_l_hys
				Cxx_amp_is_dly
				Cxx_amp_inj_cut_dly
				Ctp_spg_up_hys
				Ctp_spg_tia_cor
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_ET_SO2DW_A7_A_6_1
			"acquisition sonde � oxyg�ne aval"
			/begin DEF_CHARACTERISTIC
				Cxx_down_diag_oc_hot_t
				Cbx_lbdw_osp_typ
				Cxx_eol_lbdw_oc_air_wht
				Cxx_lbdw_no_oc_det_ctr
				Cxx_lbdw_pump_crt_v_thd
				Cxx_lbdw_osp_scg_v
				Cxx_lbdw_osp_sc_vb_v
				Cxx_lbdw_osp_oc_det_h_v
				Cxx_lbdw_pump_crt_t
				Cxx_lbdw_scg_v
				Cxx_lbdw_oc_air_wht
				Cxx_lbdw_hot_stt_t
				Cxx_down_eol_oc_det_v
				Cxx_lbdw_sc_vb_v
				Cxx_down_eol_diag_hot_t
				Cxx_lbdw_oc_h_v
				Cxx_air_wht_fmt_fac
				Cxx_lbdw_scg_t
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_ET_SO2UP_A7_A_5_1
			"acquisition sonde � oxyg�ne amont"
			/begin DEF_CHARACTERISTIC
				Cxx_lbup_hot_stt_t
				Cxx_lbup_no_oc_det_ctr
				Cxx_trs_thd
				Cxx_lbup_scg_det_v
				Cxx_diag_trs_h_thd_lpg
				Cxx_lbup_oc_t
				Cxx_lbup_scg_t
				Cxx_lbup_pump_crt_t
				Cxx_lbup_osp_scg_det_v
				Cbx_lbup_osp_typ
				Cxx_cp_trs_h_thd_lpg
				Cxx_lbup_osp_sc_vb_det_v
				Cxx_lbdw_osp_oc_det_l_v
				Cxx_lean_rich_trs_dly
				Cxx_lbup_pump_crt_v_thd
				Cxx_cp_trs_l_thd
				Cxx_lbup_sc_vb_det_v
				Cxx_cp_trs_h_thd
				Cxx_diag_trs_h_thd
				Cxx_diag_trs_l_thd
				Cxx_cp_trs_l_thd_lpg
				Cxx_lbup_oc_det_h_v
				Cxx_lbup_v_thd
				Cxx_lbup_oc_det_l_v
				Cxx_trs_thd_lpg
				Cxx_lbup_osp_oc_det_h_v
				Cxx_lbup_osp_oc_det_l_v
				Cxx_diag_trs_l_thd_lpg
				Cxx_rich_lean_trs_dly
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_EU_ABSCT_A7_A_1_0
			"acquisition informations contr�le de trajectoire m"
			/begin DEF_CHARACTERISTIC
				Cxx_asr_ctr
				Cxx_asr_msr_abst_dly
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_EU_BVAXX_AC_A_8_0
			"Acquisition boite automatique multiplexee"
			/begin DEF_CHARACTERISTIC
				Ctp_tco_agb_dri_dly
				Cxx_agb_tq_max_ofs
				Ctp_tco_agb_neut_tq
				Cxx_agb_min_is_n
				Cbx_agb_is_n_req
				Cbx_agb_csm_tq_conf
				Ctb_agb_sli
				Ctb_agb_sli_tq_eng_n
				Ctb_agb_toil
				Ctp_agb_toil_cor
				Cmp_agb_sli_tq
				Ctp_tco_agb_neut_dly
				Cxx_agb_abst_nr_fail
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_EU_CLMXX_AC_A_1_0
			"acquisition climatisation multiplexee"
			/begin DEF_CHARACTERISTIC
				Cxx_ac_abst_nr_fail
				Cbx_ac_mux
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_EU_CONBV_A3_A_2_1
			"acquisition etat convertisseur bva multiplex�e"
			/begin DEF_CHARACTERISTIC
				Cxx_agb_conv_trs_dly
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_EU_ETGPL_XX_A_3_0
			"acquisition etat gpl multiplexe"
			/begin DEF_CHARACTERISTIC
				Cxx_lpg_abst_nr_fail
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_EU_MINES_XX_A_3_1
			"acquisition mini carburant multiplexee"
			/begin DEF_CHARACTERISTIC
				Cxx_no_min_gas_lvl_dly
				Cxx_min_gas_lvl_dly
				Cxx_ip_abst_nr_fail
				Cxx_min_gas_dly
				Cxx_no_min_gas_dly
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_EU_MINGP_XX_A_2_0
			"acquisition etat gpl multiplex�e"
			/begin DEF_CHARACTERISTIC
				Cxx_no_min_lpg_lvl_dly
				Cxx_min_lpg_lvl_dly
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_EU_PDAXX_XX_A_3_0
			"d�tection de connexion du pressostat logiciel de d"
			/begin DEF_CHARACTERISTIC
				Cbx_mux_pwst_prs_dsb
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_EU_PTCXX_AC_A_1_0
			"acquisition informations ptc multiplex�es"
			/begin DEF_CHARACTERISTIC
				Cxx_ptc_lih_pow
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_EU_SDFTA_AC_A_3_0
			"surete des echanges transmission auto/moteur"
			/begin DEF_CHARACTERISTIC
				Cxx_i_agb_driv_tq_thd
				Cxx_agb_clck_max_val
				Cxx_max_fast_agb_tq
				Cbx_agb_clck_test_ena
				Cxx_dft_agb_tq_sp_lim
				Cxx_max_gear_cge_dly
				Cxx_min_agb_tq_sp
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_EU_TQALT_AC_A_3_0
			"treatment of the alternator acquisition"
			/begin DEF_CHARACTERISTIC
				Cxx_alt_crt_l_n
				Cxx_alt_crt_h_n
				Cxx_alt_crt_ofs
				Cxx_alt_load_nok
				Cxx_n_alt_rat
				Cxx_alt_crt_fmt_fac
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_EU_VITVH_XX_A_3_1
			"acquisition vitesse vehicule multiplex�e"
			/begin DEF_CHARACTERISTIC
				Cxx_abs_abst_nr_fail
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_FA_ABINJ_AC_A_1_0
			"coupure injection par airbag"
			/begin DEF_CHARACTERISTIC
				Cbx_crsh_typ_phs_1
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_FA_ABINJ_XX_DE1
			"coupure injection par airbag"
			/begin DEF_CHARACTERISTIC
				Crash2ca
				Tmcrash
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_FA_ACCSA_XX_A_2_0
			"operating safety of acc / engine exchanges"
			/begin DEF_CHARACTERISTIC
				Cxx_acc_frm_abst_nr
				Cxx_acc_bk
				Cxx_acc_neut
				Cxx_acc_stt_cge_dly_1
				Cxx_acc_stt_cge_dly_2
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_FA_ADACX_XX_A_2_0
			"commande de la sortie consommation"
			/begin DEF_CHARACTERISTIC
				Cxx_inj_csm
				Cxx_csm_fil_fac
				Cxx_adac_ti_csm_fac
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_FA_DEMXX_XX_A_1_2
			"Engine start disabling"
			/begin DEF_CHARACTERISTIC
				Cxx_gas_pump_dly
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_FA_RVLVX_AC_A_2_1
			"Interface controle moteur avec fonction v�hicule R"
			/begin DEF_CHARACTERISTIC
				Cbx_sys_wf_conf
				Cxx_acel_pdl_kd_in_thd
				Cxx_acel_pdl_kd_out_thd
				Cxx_n_min_cru_sl_dsb
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_FA_VEROU_V4_D_5_0
			"verrou logiciel 4"
			/begin DEF_CHARACTERISTIC
				Serievl
				Specifreq
				Cnrztvl
				Tmwlvl
				Tmotopro
				Cbx_swlk_dsb
				Tmclear
				Tmattski
				Tmattrps
				Dcntrzvl
				Tmatscan
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_FU_ADACX_GP_A_3_0
			"formatage de l'information adac intersysteme"
			/begin DEF_CHARACTERISTIC
				Cxx_ctr_frm_csm_gas
				Cxx_adac_ti_ofs
				Cxx_ctr_frm_csm_lpg
				Cxx_adac_ti_ofs_lpg
				Cxx_adac_csm_mux_lpg
				Cxx_adac_csm_mux
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_FU_ALRTO_XX_A_2_0
			"commande voyant alerte tempera. eau au tdb par mux"
			/begin DEF_CHARACTERISTIC
				Cxx_dft_lght_on_tco_thd
				Cxx_dft_lght_off_tco_thd
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_FU_COMPX_AC_A_1_2
			"gestion du compresseur de climatisation par le mux"
			/begin DEF_CHARACTERISTIC
				Cxx_clu_acc
				Cxx_is_dclu_acc
				Cxx_acel_is_req_dclu_acc
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_FU_ETAMO_84_D_8_0
			"Etats moteur pour l'UCH"
			/begin DEF_CHARACTERISTIC
				Srgmnvsc
				Tmatsta
				Tmatdem
				Tmouto
				Tmdefva
				Rgmnvsc
				Tmatvsc
				Trgmyvsc
				Trgmxvsc
				Tmmxvsc
				Tmmyvsc
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_FU_MILXX_AC_A_1_0
			"commande du voyant mil par le mux"
			/begin DEF_CHARACTERISTIC
				Cxx_mux_thr_n_mil_test
				Cxx_mux_test_mil_dly
				Cbx_mux_conf_mil
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_FU_NCYLX_XX_A_1_0
			"formatage du numero de cylindre intersysteme"
			/begin DEF_CHARACTERISTIC
				Cxx_nr_cyl_dsb_n_thd
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_FU_PEDXX_AC_A_5_0
			"formatage info volonte conducteur intersysteme"
			/begin DEF_CHARACTERISTIC
				Cxx_pdl_frm_inc
				Cxx_mux_pdl_h_thd
				Ctb_rel_pdl_psn
				Cxx_clc_pdl_max_psn_thd
				Cxx_clc_ct_pdl_psn_thd
				Cxx_clc_ct_pdl_psn_hys
				Ctb_eng_tq
				Cxx_fmt_pdl_l_vs_thd
				Cxx_fmt_pdl_h_vs_thd
				Cxx_mux_pdl_frm_thd1
				Cmp_n_pdl_fac_frm_pdl
				Cxx_pdl_frm_dec
				Cxx_mux_pdl_frm_thd2
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_FU_POPED_XX_A_3_0
			"formatage de la position pedale conducteur"
			/begin DEF_CHARACTERISTIC
				Cxx_mux_pdl_psn_fac
				Cxx_mux_pdl_psn_ofs
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_FU_REGXX_XX_A_3_0
			"formatage du regime intersysteme"
			/begin DEF_CHARACTERISTIC
				Cxx_mux_min_n
				Cxx_n_mux_emt_max
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_FU_TYPGP_XX_A_1_0
			"formatage du type de melange gaz intersysteme"
			/begin DEF_CHARACTERISTIC
				Cxx_typ_lpg_thd1
				Cxx_typ_lpg_thd2
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_GS_VARSV_AC_A_10_0
			"gestion des variables sauvegard�es"
			/begin DEF_CHARACTERISTIC
				Cxx_min_thd_trt2_ini
				Cbx_mv_fac_ini_req
				Cbx_mv_ofs_ini_req
				Cbx_ad_ini_req
				Cbx_tlz_ad_cor_val_req
				Cbx_ad_dft_ini_req
				Cbx_spg_i_ini_req
				Cbx_is_dft_ini_req
				Cbx_thr_dft_ini_req
				Cbx_tot_dft_ini_req
				Cbx_tq_dft_ini_req
				Cxx_tlz_ad_b1_fil_ini
				Cxx_tlz_ad_b2_fil_ini
				Cbx_trz_ad_b1_fil_req
				Cxx_tlz_ad_cor_fil_ini
				Cxx_tlz_ad_cor_val_ini
				Cxx_max_thd_trt2_ini
				Cxx_lih_thd_trt2_ini
				Cbx_max_ti_b2_ini_req
				Cbx_lsm_dft_ini_req
				Cbx_max_ti_b0_ini_req
				Cxx_lih_thd_trt1_ini
				Cbx_lsm_ctr_ini_req
				Cbx_trz_ad_b2_val_req
				Cbx_trz_ad_b1_val_req
				Cbx_trz_ad_b2_fil_req
				Cbx_tlz_ad_cor_fil_req
				Cbx_tlz_ad_b1_fil_req
				Cbx_tlz_ad_b2_fil_req
				Cbx_is_ini_req
				Cbx_max_ti_b3_ini_req
				Cbx_min_ti_b0_ini_req
				Cbx_tq_ini_req
				Cbx_lsb_ini_req
				Cbx_min_ti_b4_ini_req
				Cbx_min_ti_b3_ini_req
				Cbx_min_ti_b2_ini_req
				Cbx_min_ti_b1_ini_req
				Cbx_max_ti_b4_ini_req
				Cbx_is_min_ad_pwm_req
				Cxx_min_b4_ini
				Cxx_min_b3_ini
				Cxx_min_b2_ini
				Cxx_min_b1_ini
				Cxx_max_b4_ini
				Cxx_max_b3_ini
				Cxx_max_b2_ini
				Cxx_max_b1_ini
				Cxx_max_b0_ini
				Cxx_mv_ti_ad_fac_ini
				Cbx_ad1_zon3_ini_req
				Cbx_cam_dft_ini_req
				Cbx_obd_fail_dft_ini_req
				Cbx_fail_dft_ini_req
				Cbx_max_ti_b1_ini_req
				Cxx_mv_ti_ad_ofs_ini
				Cxx_min_thd_trt1_ini
				Cbx_knk_dft_ini_req
				Cxx_min_b0_ini
				Cxx_ti_ad1_zon0_ini
				Cxx_ti_ad1_zon4_ini
				Cxx_ti_ad1_zon3_ini
				Cxx_ti_ad1_zon2_ini
				Cxx_ti_ad1_zon1_ini
				Cbx_ad1_zon0_ini_req
				Cbx_ad1_zon4_ini_req
				Cbx_ad1_zon2_ini_req
				Cxx_trz_b_ini
				Cxx_ok_ini_dly
				Cxx_trz_ad_b2_val_ini
				Cxx_mv_ad_lsm_ctr_ini
				Cxx_trz_ad_b1_val_ini
				Cxx_max_thd_trt1_ini
				Cxx_trz_ad_b2_fil_ini
				Cxx_trz_ad_b1_fil_ini
				Cxx_is_min_ad_pwm_ini
				Cbx_ad1_zon1_ini_req
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_IA_DINJM_XX_A_2_0
			"calcul du temps mort de l'injecteur"
			/begin DEF_CHARACTERISTIC
				Ctp_vb_inj_dly_cor
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_IC_CYLFG_XX_A_7_0
			"lpg/cng flow request calculation"
			/begin DEF_CHARACTERISTIC
				Cxx_dstb_inj4_ti_fac_lpg
				Cxx_dstb_inj3_ti_fac_lpg
				Cxx_dstb_inj1_ti_fac_lpg
				Cxx_dstb_inj2_ti_fac_lpg
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_IC_GADAP_XX_A_2_1
			"adaptation de richesse"
			/begin DEF_CHARACTERISTIC
				Cxx_lpg_zon_5_ad_prs_min
				Cxx_lpg_ena_ad_prs_max_thd
				Cxx_lpg_zon_4_ad_prs_min
				Ctb_lpg_ad_fac
				Cxx_lpg_zon_3_ad_prs_min
				Cxx_lpg_zon_2_ad_prs_min
				Cxx_lpg_ena_ad_prs_min_thd
				Cxx_lpg_ad_h_thd
				Cxx_lpg_ad_fac_fac
				Cxx_lpg_ad_cl_ti_fac_thd
				Ctb_lpg_ad_zon_prs
				Ctd_lpg_typ_id
				Cxx_lpg_ad_l_thd
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_IC_POSTX_GP_A_1_0
			"calcul du t.i. de post injection"
			/begin DEF_CHARACTERISTIC
				Cxx_aftr_inj_map_dif
				Cxx_aftr_inj_n_thd
				Ctp_tco_aftr_ti_fac
				Cxx_aftr_inj_map_fac
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_IC_RMAXX_XX_A_1_0
			"coupure en surregime"
			/begin DEF_CHARACTERISTIC
				Cxx_inj_stop_n_ofs
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_ID_DEMXX_XX_A_3_0
			"calcul du tems d'injection au demarrage"
			/begin DEF_CHARACTERISTIC
				Ctp_tco_dec_sta_ti
				Ctp_tco_sta_ti
				Ctp_n_sta_ti
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_ID_FLOOX_MP_A_2_0
			"fonction denoyage"
			/begin DEF_CHARACTERISTIC
				Ctp_ufld_tco_thd
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_ID_PRIJS_XX_A_3_0
			"preinjection en sequentiel"
			/begin DEF_CHARACTERISTIC
				Ctp_tco_pinj_t
				Cxx_tco_fail_pinj_t
				Cxx_alti_pinj_cor_fac
				Cxx_rest_pinj_cor_fac
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_IG_AUTOX_XX_A_3_0
			"automate de gestion des injections"
			/begin DEF_CHARACTERISTIC
				Ctp_tco_sta_out_sfg_dly
				Cbx_sfg_bch
				Cxx_sfg_seq_trs_n_thd
				Cxx_sfg_seq_trs_ctr
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_IG_CALFG_XX_A_2_0
			"lpg/cng flow request calculation"
			/begin DEF_CHARACTERISTIC
				Ctp_lpg_typ_adac_fmt_fac
				Cxx_lpg_tco_ti_cor_fac
				Cxx_lpg_flow_fmt_fac
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_IG_CALFX_XX_A_1_1
			"calcul du temps d'injection efficace"
			/begin DEF_CHARACTERISTIC
				Cxx_inj_dly
				Fftibm
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_IG_CINJX_GP_A_1_1
			"calcul du temps d'injection vrai"
			/begin DEF_CHARACTERISTIC
				Cbx_bch_inj3_cut_req
				Cbx_bch_inj2_cut_req
				Cbx_bch_inj1_cut_req
				Cbx_wet_bch_mod
				Ctp_n_inj_cut_dly
				Cbx_wet_ti_cut_bch_mod
				Cbx_bch_inj4_cut_req
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_IG_DINJV_GP_A_5_0
			"calcul du temps d' injection vrai"
			/begin DEF_CHARACTERISTIC
				Cxx_dstb_inj3_ti_fac
				Ctp_tco_rich_cylr
				Cxx_cylr_tco_thd
				Cbx_min_ti
				Cxx_dstb_inj1_ti_fac
				Cxx_dstb_inj1_ti_fac_is
				Cxx_dstb_inj2_ti_fac_is
				Cxx_dstb_inj3_ti_fac_is
				Cxx_dstb_inj4_ti_fac_is
				Ctp_ol_is_rich_cylr
				Cxx_dstb_inj4_ti_fac
				Cxx_dstb_inj2_ti_fac
				Cxx_alti_prs2_fac
				Ctp_cl_is_rich_cylr
				Cxx_min_cp_ti
				Cxx_sfg_seq_trs_ti_fac
				Cxx_asd_rich_cylr
				Cxx_min_ti
				Cxx_cylr_cp_ti_fac
				Cmp_prs_n_lean_cylr
				Cmp_prs_n_rich_cylr
				Ctp_cl_is_lean_cylr
				Ctp_ol_is_lean_cylr
				Ctp_tco_lean_cylr
				Cxx_asd_lean_cylr
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_IG_PHFNX_A5_A_2_2
			"calcul de la phase de fin d'injection"
			/begin DEF_CHARACTERISTIC
				Ctp_polu_inj_clos_angl
				Cxx_fil_inj_clos_dec
				Cxx_perf_inj_tco_thd
				Ctp_perf_inj_clos_angl
				Cxx_fil_inj_clos_inc
				Cxx_inj_clos_angl_bch
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_IG_PHOUV_XX_A_2_2
			"calcul de la phase de debut d'injection"
			/begin DEF_CHARACTERISTIC
				Cxx_sta_inj_sta_angl
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_IM_AIRXX_A5_A_3_0
			"correction fonction temperature air"
			/begin DEF_CHARACTERISTIC
				Cmp_n_eal_tia_fil_fac
				Ctp_n_tia_fac
				Ctp_prs_tia_fac
				Ctp_tia_inj_cor
				Cxx_tia_fac
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_IM_CANIS_PR_A_2_1
			"correction de richesse due au canister"
			/begin DEF_CHARACTERISTIC
				Cxx_cp_fac_rel
				Cxx_cp_max_ad
				Cxx_cp_inc_ad
				Cxx_cp_grd_fac
				Cxx_cp_rel_step_lamb_fac
				Ctb_cp_ad_fil
				Cxx_cp_step_lamb_fac
				Cxx_cp_fil_cl_ti_fac
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_IM_CARTO_GP_A_2_1
			"calculation of the volumetric efficiency correctio"
			/begin DEF_CHARACTERISTIC
				Cmp_vvt_fill_efv_cor_fac1
				Cmp_vvt_fill_efv_cor_fac2
				Cxx_vvt_fill_efv_cam_ofs
				Cmp_n_map_fill_efv_vvt
				0
				Cmp_n_map_fill_efv_lpg
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_IM_EAUXX_A7_A_4_1
			"correction fonction de la temp�rature d'eau"
			/begin DEF_CHARACTERISTIC
				Ctb_eal_eai
				Cxx_rich_tia_thd
				Ctb_n_eai
				Ctp_ti_cor_eai_fil_ctr
				Ctp_tco_eai_ti_fac_cor
				Cxx_min_pwl_dly
				Cxx_aper_rich_sta_tco_thd
				Cxx_aper_rich_sta_tia_thd
				Cxx_rich_sta_tco_thd
				Cmp_n_prs_eai_ti_cor
				Cxx_tco_ti_fil_nr2
				Cxx_sta_tco_ti_dec_fac
				Ctp_tco_sta_rich_dec
				Cxx_rest_mod_dsb_tco_thd
				Cxx_pwl_dly
				Ctp_tco_ti_fac1
				Ctp_tco_ti_fac3
				Ctp_tco_sta_ti_fac
				Cxx_tco_ti_fil_nr
				Cxx_sta_tco_ti_rest_fac
				Cxx_sta_rich_dec_nr
				Ctp_tia_sta_ti_fac
				Cxx_rest_mod_dsb_max_dly
				Cmp_n_prs_lean_ti_cor
				Ctp_tco_lean_ti_fac_cor
				Cmp_n_prs_tco_ti_fac2
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_IM_PAFDX_GP_A_8_0
			"richness setpoint calculation"
			/begin DEF_CHARACTERISTIC
				Ctb_n_ol
				Cmp_n_map_fl_rich_sp
				Cmp_n_map_ol_rich_sp_lpg
				Ctb_map_ol
				Cxx_tkof_fl_rich_fac_lpg
				Cxx_tkof_fl_rich_fac
				Ctp_n_kd_rich_fac_lpg
				Ctp_n_kd_rich_fac
				Cxx_tco_kd_rich_cor_fac
				Cmp_n_eal_fl_rich_sp
				Cbx_kd_rich_cor_prs_conf
				Ctb_map_fl
				Ctb_eal_fl
				Cxx_knk_iga_cor
				Cmp_n_map_ol_rich_sp
				Cxx_cold_loop_kd_rich_fac
				Cmp_n_eal_fl_rich_sp_lpg
				Cxx_rich_cor_ena_n_thd
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_IM_PSSRE_XX_A_1_1
			"correction difference de pression nez injecteur"
			/begin DEF_CHARACTERISTIC
				Ctb_prs_dif
				Cmp_prs_dif_ti_cor
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_IP_ATMOX_XX_A_2_0
			"correction de la richesse altitude"
			/begin DEF_CHARACTERISTIC
				Cxx_alti_inj_cor
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_IP_MOUIL_A7_A_4_0
			"calcul de la correction mouillage de parois"
			/begin DEF_CHARACTERISTIC
				Cbx_wet_prs_eal_swi_mod
				Ctp_wet_ini_acel_cor_ofs
				Cxx_wet_tdc_ctr_rat
				Cxx_wet_ti_cut_tdc_nr
				Cxx_wet_ti_cut_nr
				Cxx_wet_bch_vol_fac
				Cxx_wet_tb_cor_fac
				Cxx_wet_decl_bch_cor_fac
				Cxx_wet_ini_acel_sta_t
				Cxx_wet_ini_acel_ofs_t
				Ctp_wet_decl_fil_fac
				Ctp_wet_vol_dif_thd_acel
				Ctp_wet_vol_dif_thd_decl
				Ctp_wet_vol_dif_thd_sta
				Ctp_wet_vol_dif_thd_ini
				Ctp_wet_tb_acel_vol_fac
				Cxx_wet_min_air_stab_thd
				Cbx_wet_stat_cor_bch_mod
				Ctb_wet_tdc_rat_ctr
				Ctp_wet_vol_dif_thd_sta_t
				Cxx_wet_acel_bch_cor_fac
				Cbx_wet_tb_cor_bch_mod
				Ctp_wet_tb_decl_vol_fac
				Cmp_wet_eal_vol_fac_tco60
				Cxx_wet_decl_bch_fil_fac
				Ctb_wet_n
				Cmp_wet_eal_vol_fac_tco00
				Cmp_wet_eal_vol_fac_tco40
				Cmp_wet_eal_vol_fac_tco80
				Cmp_wet_eal_fil_fac_tco00
				Cmp_wet_eal_fil_fac_tco20
				Cmp_wet_eal_fil_fac_tco40
				Cmp_wet_eal_fil_fac_tco60
				Cmp_wet_eal_fil_fac_tco80
				Cmp_wet_prs_vol_fac_tco00
				Cmp_wet_prs_fil_fac_tco80
				Cxx_wet_acel_bch_fil_fac
				Cmp_wet_eal_vol_fac_tco20
				Cmp_wet_prs_vol_fac_tco20
				Ctp_wet_decl_cor_fac
				Ctp_wet_acel_cor_fac
				Cmp_wet_prs_fil_fac_tco60
				Cmp_wet_prs_fil_fac_tco40
				Cmp_wet_prs_fil_fac_tco20
				Cmp_wet_prs_fil_fac_tco00
				Cmp_wet_prs_vol_fac_tco80
				Cmp_wet_prs_vol_fac_tco60
				Cmp_wet_prs_vol_fac_tco40
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_IS_ACLMY_XX_A_2_1
			"calcul de la valeur moyenne d'alfacl pour l'obd"
			/begin DEF_CHARACTERISTIC
				Cxx_cl_ti_obd_fil_fac
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_IS_ADAPT_GP_A_1_1
			"automate d'adaptation de richesse"
			/begin DEF_CHARACTERISTIC
				Cxx_max_cld_fac_thd
				Ctp_min_mv_cld_ad
				Cxx_min_cld_fac_thd
				Cxx_min_cld_ofs_thd
				Cxx_ad_off_ti_ad_ofs
				Cxx_is_hot_ti_cl_dly
				Cxx_max_cld_ofs_thd
				Ctd_ti_ad_ofs_cor
				Cxx_ti_ad_prs_l_thd
				Cxx_ti_ad_prs_up_thd
				Cxx_ti_ad_tco_thd
				Cxx_ad_lamb_swi_ctr
				Ctp_max_mv_cld_ad
				Cxx_ti_ad_prs_trs_thd
				Ctd_ti_b_cor
				Cxx_is_hot_tco_thd
				Cxx_zon_dif_min_hys
				Cxx_ti_ad_max_n
				Ctd_ti_ad_fac_cor
				Cxx_min_ad_fac_thd
				Cxx_min_ad_ofs_thd
				Cxx_ad_off_ti_ad_fac
				Cxx_prs_zon
				Cxx_prs_zon0
				Cxx_max_imd_ti_ad_fac
				Cxx_max_imd_ti_ad_ofs
				Cxx_max_mv_ti_ad_ofs
				Cxx_cld_ad_nr
				Cxx_min_imd_ti_ad_fac
				Cxx_min_mv_ti_ad_fac
				Cxx_min_imd_ti_ad_ofs
				Cxx_max_mv_ti_ad_fac
				Cxx_min_mv_ti_ad_ofs
				Cxx_min_dif_ti_b
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_IS_AUTBF_GP_A_3_0
			"automate de boucle fermee"
			/begin DEF_CHARACTERISTIC
				Ctp_prs_ti_ofs1
				Cxx_is_ti_p_cor_lpg
				Cxx_min_cl_ti_fac
				Cxx_max_cl_ti_fac
				Cxx_is_dstb_ti_ofs_cor
				Ctp_prs_ti_ofs2
				Cxx_lamb_swi_ctr_ini_lpg
				Cxx_is_ti_i_cor
				Ctp_n_ti_p_cor
				Cxx_ti_p_prs_thd_lpg
				Cxx_ti_p_prs_thd
				Cxx_appl_ti_ofs_ctr_lpg
				Cxx_appl_ti_ofs_ctr
				Cxx_acel_fast_slop
				Cxx_decl_fast_slop
				Cxx_fast_slop_h_thd
				Cxx_ti_ofs_vs_thd
				Cxx_is_dstb_ti_ofs_cor1
				Cxx_ti_ofs_vs_thd_lpg
				Cxx_is_ti_i_cor_lpg
				Cxx_fast_slop_l_thd
				Cxx_max_ti_p_cor_lpg
				Ctp_decl_n_ti_p_cor
				Ctp_n_l_ti_i_cor_lpg
				Ctp_n_ti_p_cor_lpg
				Ctp_prs_l_ti_i_cor_lpg
				Ctp_prs_ti_ofs1_lpg
				Ctp_prs_ti_ofs2_lpg
				Cxx_dstb_ti_ofs_cor_lpg
				Cxx_dstb_ti_p_cor_lpg
				Cxx_fil_cl_ti_fac
				Cxx_l_ti_slop_thd_lpg
				Cxx_l_ti_slop_thd
				Cxx_ti_i_cor_fac_lpg
				Cxx_is_ti_p_cor
				Cxx_ti_i_cor_fac
				Cxx_max_ti_p_cor
				Cxx_lamb_swi_ctr_ini
				Cxx_dstb_ti_p_cor
				Cxx_dstb_ti_ofs_cor
				Ctp_prs_l_ti_i_cor
				Ctp_n_l_ti_i_cor
				Cxx_fil_cl_ti_fac_lpg
				Cxx_is_ti_i_cor_lean
				Cxx_l_ti_slop_thd_lean2
				Cxx_l_ti_slop_thd_lean1
				Cxx_is_ti_p_cor_lean1
				Cxx_max_fast_slop_ctr
				Cxx_decl_fast_slop_lean
				Cxx_cl_lean_ctr
				Cxx_acel_fast_slop_lean
				Ctp_prs_l_ti_i_cor_lean
				Ctp_acel_n_ti_p_cor
				Ctp_n_ti_p_cor_lean1
				Ctp_n_l_ti_i_cor_lean
				Ctp_cl_lean_stop
				Ctp_cl_lean_sta
				Ctp_fast_slop_out
				Ctp_fast_slop_in
				Ctp_n_ti_p_cor_lean2
				Cxx_is_ti_p_cor_lean2
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_IS_AUTBR_Z7_A_5_0
			"automate de la boucle de richesse"
			/begin DEF_CHARACTERISTIC
				Cxx_max_is_ocl_t
				Cxx_l_v_lamb_thd
				Cxx_is_ocl_tco_thd
				Cxx_h_dly_ocl_tco_thd
				Cxx_fl_n_thd_hys
				Cxx_fl_n_thd
				Cxx_fl_ena_n_thd
				Cxx_dly_ocl_up_n_thd
				Cxx_mv_ad_dly
				Cxx_fl_bfr_cl_ctr
				Cxx_ol_ti_fac_inc
				Cxx_rich_cl_alti_fac
				Cxx_rich_cl_tco_thd
				Cxx_rich_ol_ti_thd
				Cxx_sta_fl_off_dly
				Cxx_sta_fl_off_dly_lpg
				Cxx_up_v_lamb_thd
				Cxx_dly_ocl_tco_thd
				Cxx_ol_ti_fac_dec
				Cxx_cl_off_n_thd
				Cbx_ol_cl_sp_conf
				Ctp_n_dly_ofs_dly
				Cbx_fl_kd_thr_conf
				Cmp_n_eal_fl_thd
				Cmp_n_eal_fl_thd_lpg
				Cmp_n_prs_fl_thd
				Ctb_tco_cl_off
				Ctp_eal_fl_ocl_ofs
				Cxx_cl_stop_prs_thd
				Ctp_map_fl_ocl_ofs
				Cxx_dly_ocl_l_n_thd
				Ctp_n_dly_ofs_dly_lpg
				Ctp_tco_cl_off_dly
				Cxx_bfr_cl_ctr
				Cxx_bfr_cl_ctr_lpg
				Cxx_cl_run_prs_thd
				Cxx_cl_t_fac
				Cxx_ct_pdl_tco_thd
				Cxx_dly_ocl_alti_thd
				Cxx_dly_ocl_knk_thd
				Ctp_iga_prs_fl_thd
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_IS_DBMOY_A5_A_2_0
			"adapatif de la double boucle de richesse"
			/begin DEF_CHARACTERISTIC
				Cxx_min_n_fil_ofs2
				Cxx_diag_fil_ti_ofs2_fac2
				Cxx_min_tco_fil_ofs2
				Cxx_max_tco_fil_ofs2
				Cxx_min_prs_fil_ofs2
				Cxx_max_prs_fil_ofs2
				Cxx_dyn_prs_fil_ofs2
				Cbx_ti_cl2_conf
				Cxx_max_n_fil_ofs2
				Cxx_fil_ti_ofs2_fac
				Cxx_cl2_act_ctr
				Cxx_diag_fil_ti_ofs2_fac1
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_IS_DBOUC_GP_A_5_2
			"double boucle de richesse"
			/begin DEF_CHARACTERISTIC
				Cxx_max_ti_ofs1
				Cxx_cl2_asd_map_thd
				Ctp_tco_cl2_ena_ctr_lpg
				Cmp_prs_n_lamb_v_lpg
				Cxx_cl2_map_thd
				Ctp_tco_cl2_ena_ctr
				Cxx_max_is_ti_ofs2
				Cxx_max_diag_ti_ofs1
				Cxx_min_diag_ti_ofs2
				Cmp_prs_n_lamb_v
				Cxx_cl2_n_thd
				Cxx_min_ti_ofs2
				Cxx_ti_p2_cor_fac
				Cxx_ti_i2_cor_fac
				Cxx_min_is_ti_ofs2
				Cxx_cl2_ena_ctr
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_IS_O2DMY_XX_A_2_0
			"calcul tension de sonde aval filtr�e db boucle"
			/begin DEF_CHARACTERISTIC
				Cxx_lbdw_fil_fac
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_IS_RECOU_XX_A_3_1
			"fuelling transcient management"
			/begin DEF_CHARACTERISTIC
				Ctp_lpg_gas_trs_cor_ini
				Ctp_lpg_trs_cor_stop
				Ctp_lpg_gas_trs_cor_dec
				Ctb_lpg_temp_09
				Cxx_tdc_nr_bfr_gas_lpg
				Cxx_tdc_nr_bfr_lpg_gas
				Cxx_lpg_rich_cl_tco_thd
				Ctp_lpg_temp_wup_cyc_nr
				Ctp_gas_lpg_trs_cor_inc
				Ctp_lpg_temp_wup_cor_fac
				Cxx_lpg_wup_cor_inc
				Ctp_gas_lpg_trs_cor_ini
				Ctp_lpg_gas_trs_cor_inc
				Cxx_gas_lpg_trs_cyc_nr
				Ctp_prs_lpg_trs_cor_min
				Ctp_prs_gas_trs_cor_min
				Cxx_lpg_gas_trs_cyc_nr
				Cxx_lpg_wup_cor_dec
				Ctp_gas_trs_cor_stop
				Ctp_gas_lpg_trs_cor_dec
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_OB_CATAX_GP_A_3_0
			"diagnostic du catalyseur"
			/begin DEF_CHARACTERISTIC
				Cxx_cata_ol_apl
				Cxx_cata_ofs_pos_1
				Cxx_cata_ofs_ol_lbdw_fil
				Cxx_cata_ofs_neg_2
				Cxx_cata_ofs_neg_1
				Cxx_cata_ol_per_dly_mes
				Cxx_cata_n_max
				Cxx_cata_tco_min
				Cxx_cata_maf_min
				Cxx_cata_n_min
				Cxx_cata_ol_per_dly_stab
				Cxx_cata_ol_test_max_nr
				Cxx_cata_ol_thd_lbdw_fil
				Cxx_cata_tb_ofs
				Cxx_cata_win_max
				Cxx_cata_win_min
				Cbx_cata_diag_stg_bch_mod
				Cxx_cata_ofs_pos_2
				Cxx_cata_maf_mes_max
				Cxx_cata_tb_fac
				Cxx_cata_asd_cl_stab_dly
				Cxx_cata_maf_max
				Cxx_cata_ol_per_dly
				Ctp_cata_ol_per_dly_maf
				Cbx_mod_bch_diag_cata
				Cxx_cata_asd_diag_nr
				Cxx_cata_asd_in_nr
				Cxx_cata_asd_maf_dif_max
				Cxx_cata_asd_maf_max
				Cxx_cata_asd_maf_mes_max
				Cxx_cata_asd_maf_min
				Cxx_cata_hys_n
				Cxx_cata_in_nr
				Cxx_cata_asd_n_min
				Ctp_cata_lbdw_max_maf
				Cxx_cata_asd_sf_nr
				Cxx_cata_asd_tco_min
				Cxx_cata_cl_stab_dly_min
				Cxx_cata_hys_maf
				Cxx_cata_maf_dif_max
				Cxx_cata_asd_n_max
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_OB_CLVXX_XX_A_2_0
			"calculation of load value for obd"
			/begin DEF_CHARACTERISTIC
				Ctp_amp_0_amp_rat
				Cxx_max_eng_eal
				Ctb_amp_0_amp_rat_alti
			/end DEF_CHARACTERISTIC
		/end FUNCTION
		/begin FUNCTION A_OB_CONDX_A7_A_4_0
			"conditions des diagnostics eobd"
			/begin DEF_CHARACTERISTIC
				Cbx_lamb_rams_pdl_vf
				Cbx_mis_cata_rams_pdl_vf
				Cbx_cata_rams_pdl_vf
				Cbx_fsys_rams_pdl_vf
				Cbx_mis_polu_rams_pdl_vf
				Cbx_schd_pow_lbup_vf
				Cbx_fsys_pow_lbup_vf
				Cbx_mis_cata_pow_lbup_vf
				Cbx_mis_polu_pow_lbup_vf
				Cbx_lamb_pow_lbup_vf
				Cbx_schd_rams_pdl_vf
				Cbx_fsys_pow_lbdw_vf
				Cbx_schd_pow_lbdw_vf
				Cbx_cata_pow_lbup_vf
				Cbx_lamb_spg_vf
				Cbx_cata_spg_vf
				Cbx_mis_polu_spg_vf
				Cbx_mis_cata_spg_vf
				Cbx_fsys_spg_vf
				Cbx_schd_spg_vf
				Cbx_lamb_spg_sys_vf
				Cbx_cata_spg_sys_vf
				Cbx_mis_cata_pow_lbdw_vf
				Cbx_mis_cata_spg_sys_vf
				Cbx_mis_cata_obd_cata_vf
				Cbx_fsys_spg_sys_vf
				Cbx_schd_spg_sys_vf
				Cbx_lamb_cp_mfo
				Cbx_mis_polu_spg_sys_vf
				Cbx_mis_polu_mis_cata_vf
				Cbx_schd_obd_cata_vf
				Cbx_mis_polu_mis_polu_vf
				Cbx_cata_mis_polu_vf
				Cbx_lamb_mis_polu_vf
				Cbx_schd_mis_cata_vf
				Cbx_fsys_mis_polu_vf
				Cbx_mis_cata_mis_cata_vf
				Cbx_schd_mis_polu_vf
				Cbx_cata_mis_cata_vf
				Cbx_lamb_mis_cata_vf
				Cbx_schd_min_gas_lvl_vf
				Cbx_fsys_min_gas_lvl_vf
				Cbx_mis_cata_min_gas_lvl_vf
				Cbx_mis_polu_min_gas_lvl_vf
				Cbx_fsys_mis_cata_vf
				Cbx_lamb_obd_lamb_vf
				Cbx_cata_pow_lbdw_vf
				Cbx_lamb_pow_lbdw_vf
				Cbx_schd_obd_lamb_vf
				Cbx_fsys_obd_lamb_vf
				Cbx_mis_cata_obd_lamb_vf
				Cbx_mis_cata_mis_polu_vf
				Cbx_cata_obd_lamb_vf
				Cbx_mis_polu_pow_lbdw_vf
				Cbx_cata_cp_mfo
				Cbx_fsys_obd_cata_vf
				Cbx_cata_igc_1_mfo
				Cbx_mis_polu_obd_cata_vf
				Cbx_cata_obd_cata_vf
				Cbx_lamb_obd_cata_vf
				Cbx_mis_polu_obd_lamb_vf
				Cbx_mis_polu_inj3_mfo
				Cbx_schd_gas_pump_mfo
				Cbx_lamb_inj1_mfo
				Cbx_cata_inj1_mfo
				Cbx_mis_polu_inj1_mfo
				Cbx_mis_cata_inj1_mfo
				Cbx_fsys_inj1_mfo
				Cbx_schd_inj1_mfo
				Cbx_lamb_inj2_mfo
				Cbx_cata_inj2_mfo
				Cbx_mis_polu_inj2_mfo
				Cbx_mis_cata_inj2_mfo
				Cbx_fsys_inj2_mfo
				Cbx_schd_inj2_mfo
				Cbx_fsys_igc_4_mfo
				Cbx_mis_polu_inj4_mfo
				Cbx_fsys_lbup_vf
				Cbx_cata_min_gas_lvl_vf
				Cbx_cata_lbdw_mfo
				Cbx_lamb_lbdw_mfo
				Cbx_schd_inj4_mfo
				Cbx_lamb_inj3_mfo
				Cbx_mis_cata_inj4_mfo
				Cbx_cata_inj3_mfo
				Cbx_cata_inj4_mfo
				Cbx_lamb_inj4_mfo
				Cbx_schd_inj3_mfo
				Cbx_fsys_inj3_mfo
				Cbx_mis_cata_inj3_mfo
				Cbx_mis_cata_igc_4_mfo
				Cbx_fsys_inj4_mfo
				Cbx_cata_igc_2_mfo
				Cbx_mis_cata_cp_mfo
				Cbx_fsys_cp_mfo
				Cbx_schd_cp_mfo
				Cbx_mis_polu_lbdw_mfo
				Cbx_lamb_gas_pump_mfo
				Cbx_cata_gas_pump_mfo
				Cbx_mis_polu_gas_pump_mfo
				Cbx_mis_cata_gas_pump_mfo
				Cbx_fsys_gas_pump_mfo
				Cbx_lamb_igc_1_mfo
				Cbx_mis_polu_igc_1_mfo
				Cbx_mis_cata_igc_1_mfo
				Cbx_fsys_igc_1_mfo
				Cbx_schd_igc_4_mfo
				Cbx_cata_igc_3_mfo
				Cbx_mis_polu_igc_4_mfo
				Cbx_cata_igc_4_mfo
				Cbx_lamb_igc_4_mfo
				Cbx_schd_igc_3_mfo
				Cbx_fsys_igc_3_mfo
				Cbx_schd_igc_1_mfo
				Cbx_mis_polu_igc_3_mfo
				Cbx_lamb_igc_2_mfo
				Cbx_lamb_igc_3_mfo
				Cbx_schd_igc_2_mfo
				Cbx_fsys_igc_2_mfo
				Cbx_mis_cata_igc_2_mfo
				Cbx_mis_polu_igc_2_mfo
				Cbx_mis_polu_cp_mfo
				Cbx_mis_cata_igc_3_mfo
				Cbx_mis_polu_lbup_vf
				Cbx_lamb_lbdw_vf
				Cbx_cata_lbdw_vf
				Cbx_mis_polu_lbdw_vf
				Cbx_mis_cata_lbdw_vf
				Cbx_fsys_lbdw_vf
				Cbx_schd_lbdw_vf
				Cbx_lamb_lbdw_hot_vf
				Cbx_cata_lbdw_hot_vf
				Cbx_mis_polu_lbdw_hot_vf
				Cbx_mis_cata_lbdw_hot_vf
				Cbx_fsys_lbdw_hot_vf
				Cbx_schd_lbdw_hot_vf
				Cbx_lamb_lbup_hot_vf
				Cbx_cata_lbup_vf
				Cbx_mis_cata_inj4_vf
				Cbx_mis_cata_lbup_vf
				Cbx_mis_polu_knk_mfo
				Cbx_schd_lbup_vf
				Cbx_mis_cata_lbdw_mfo
				Cbx_cata_lbup_hot_vf
				Cbx_mis_polu_lbup_hot_vf
				Cbx_mis_cata_lbup_hot_vf
				Cbx_fsys_lbup_hot_vf
				Cbx_schd_lbup_hot_vf
				Cbx_lamb_tco_vf
				Cbx_cata_tco_vf
				Cbx_mis_polu_tco_vf
				Cbx_mis_cata_tco_vf
				Cbx_lamb_lbup_vf
				Cbx_mis_polu_inj2_vf
				Cbx_schd_igc_3_vf
				Cbx_lamb_igc_4_vf
				Cbx_cata_igc_4_vf
				Cbx_mis_polu_igc_4_vf
				Cbx_mis_cata_igc_4_vf
				Cbx_fsys_igc_4_vf
				Cbx_schd_igc_4_vf
				Cbx_lamb_inj1_vf
				Cbx_cata_inj1_vf
				Cbx_mis_polu_inj1_vf
				Cbx_mis_cata_inj1_vf
				Cbx_fsys_inj1_vf
				Cbx_schd_inj1_vf
				Cbx_schd_inj4_vf
				Cbx_mis_polu_inj3_vf
				Cbx_lamb_tia_vf
				Cbx_mis_polu_inj4_vf
				Cbx_cata_inj4_vf
				Cbx_lamb_inj4_vf
				Cbx_schd_inj3_vf
				Cbx_lamb_inj2_vf
				Cbx_mis_cata_inj3_vf
				Cbx_cata_inj2_vf
				Cbx_cata_inj3_vf
				Cbx_lamb_inj3_vf
				Cbx_schd_inj2_vf
				Cbx_fsys_inj2_vf
				Cbx_mis_cata_inj2_vf
				Cbx_fsys_inj4_vf
				Cbx_fsys_inj3_vf
				Cbx_fsys_eng_whl_vf
				Cbx_fsys_tco_vf
				Cbx_mis_polu_crk_vf
				Cbx_mis_cata_crk_vf
				Cbx_fsys_crk_vf
				Cbx_schd_crk_vf
				Cbx_lamb_crk_nr_vf
				Cbx_cata_crk_nr_vf
				Cbx_mis_polu_crk_nr_vf
				Cbx_mis_cata_crk_nr_vf
				Cbx_fsys_crk_nr_vf
				Cbx_schd_crk_nr_vf
				Cbx_lamb_eng_whl_vf
				Cbx_cata_eng_whl_vf
				Cbx_lamb_crk_vf
				Cbx_fsys_knk_vf
				Cbx_schd_map_vf
				Cbx_fsys_map_vf
				Cbx_mis_cata_map_vf
				Cbx_mis_polu_map_vf
				Cbx_cata_map_vf
				Cbx_mis_polu_eng_whl_vf
				Cbx_schd_knk_vf
				Cbx_mis_cata_eng_whl_vf
				Cbx_mis_cata_knk_vf
				Cbx_mis_polu_knk_vf
				Cbx_cata_knk_vf
				Cbx_lamb_knk_vf
				Cbx_schd_eng_whl_vf
				Cbx_schd_air_vf
				Cbx_lamb_map_vf
				Cbx_mis_cata_wgc_vf
				Cbx_lamb_min_gas_lvl_vf
				Cbx_cata_tia_vf
				Cbx_mis_polu_tia_vf
				Cbx_mis_cata_tia_vf
				Cbx_fsys_tia_vf
				Cbx_schd_tia_vf
				Cbx_lamb_vs_vf
				Cbx_cata_vs_vf
				Cbx_mis_polu_vs_vf
				Cbx_mis_cata_vs_vf
				Cbx_fsys_vs_vf
				Cbx_schd_vs_vf
				Cbx_lamb_wgc_vf
				Cbx_cata_crk_vf
				Cbx_mis_cata_agb_rcpt_vf
				Cbx_fsys_air_vf
				Cbx_mis_cata_air_vf
				Cbx_mis_polu_air_vf
				Cbx_cata_air_vf
				Cbx_lamb_air_vf
				Cbx_cata_wgc_vf
				Cbx_fsys_agb_rcpt_vf
				Cbx_mis_polu_wgc_vf
				Cbx_mis_polu_agb_rcpt_vf
				Cbx_cata_agb_rcpt_vf
				Cbx_lamb_agb_rcpt_vf
				Cbx_schd_wgc_vf
				Cbx_fsys_wgc_vf
				Cbx_schd_tco_vf
				Cbx_schd_agb_rcpt_vf
				Cbx_mis_polu_sa_pf
				Cbx_fsys_vvt_intake_mfo
				Cbx_lamb_oil_pf
				Cbx_cata_oil_pf
				Cbx_mis_polu_oil_pf
				Cbx_mis_cata_oil_pf
				Cbx_fsys_oil_pf
				Cbx_schd_oil_pf
				Cbx_lamb_pmh_pf
				Cbx_cata_pmh_pf
				Cbx_mis_polu_pmh_pf
				Cbx_mis_cata_pmh_pf
				Cbx_fsys_pmh_pf
				Cbx_schd_pmh_pf
				Cbx_fsys_reserve_3_pf
				Cbx_mis_polu_vvt_intake_vf
				Cbx_lamb_knk_mfo
				Cbx_mis_polu_vvt_intake_mfo
				Cbx_cata_vvt_intake_mfo
				Cbx_lamb_vvt_intake_mfo
				Cbx_schd_vvt_intake_vf
				Cbx_lamb_sa_pf
				Cbx_mis_cata_vvt_intake_vf
				Cbx_cata_sa_pf
				Cbx_cata_vvt_intake_vf
				Cbx_lamb_vvt_intake_vf
				Cbx_schd_sa_pf
				Cbx_fsys_sa_pf
				Cbx_mis_cata_sa_pf
				Cbx_mis_cata_reserve_3_pf
				Cbx_fsys_vvt_intake_vf
				Cbx_cata_spg_sys_mfo
				Cbx_fsys_pow_lbup_mfo
				Cbx_schd_pow_lbup_mfo
				Cbx_lamb_rams_pdl_mfo
				Cbx_cata_rams_pdl_mfo
				Cbx_mis_polu_rams_pdl_mfo
				Cbx_mis_cata_rams_pdl_mfo
				Cbx_fsys_rams_pdl_mfo
				Cbx_schd_rams_pdl_mfo
				Cbx_lamb_spg_mfo
				Cbx_cata_spg_mfo
				Cbx_mis_polu_spg_mfo
				Cbx_mis_cata_spg_mfo
				Cbx_fsys_spg_mfo
				Cbx_schd_reserve_3_pf
				Cbx_cata_rams_pf
				Cbx_mis_polu_reserve_3_pf
				Cbx_cata_reserve_3_pf
				Cbx_lamb_reserve_3_pf
				Cbx_schd_rams_pf
				Cbx_fsys_rams_pf
				Cbx_schd_spg_mfo
				Cbx_mis_polu_rams_pf
				Cbx_lamb_spg_sys_mfo
				Cbx_lamb_rams_pf
				Cbx_schd_spg_sys_mfo
				Cbx_fsys_spg_sys_mfo
				Cbx_mis_cata_spg_sys_mfo
				Cbx_mis_polu_spg_sys_mfo
				Cbx_schd_vvt_intake_mfo
				Cbx_mis_cata_rams_pf
				Cbx_schd_sa_mfo
				Cbx_mis_cata_vvt_intake_mfo
				Cbx_mis_polu_thpl_pf
				Cbx_mis_cata_thpl_pf
				Cbx_fsys_thpl_pf
				Cbx_schd_thpl_pf
				Cbx_lamb_sa_vf
				Cbx_cata_sa_vf
				Cbx_mis_polu_sa_vf
				Cbx_mis_cata_sa_vf
				Cbx_fsys_sa_vf
				Cbx_schd_sa_vf
				Cbx_lamb_sa_mfo
				Cbx_mis_polu_sa_mfo
				Cbx_lamb_thpl_pf
				Cbx_schd_ptc_rov_pf
				Cbx_cata_sa_mfo
				Cbx_schd_mcut_sens1_pf
				Cbx_fsys_mcut_sens1_pf
				Cbx_mis_cata_mcut_sens1_pf
				Cbx_mis_polu_mcut_sens1_pf
				Cbx_mis_cata_sa_mfo
				Cbx_lamb_mcut_sens1_pf
				Cbx_fsys_sa_mfo
				Cbx_fsys_ptc_rov_pf
				Cbx_mis_cata_ptc_rov_pf
				Cbx_mis_polu_ptc_rov_pf
				Cbx_cata_ptc_rov_pf
				Cbx_lamb_ptc_rov_pf
				Cbx_schd_mdf2_pf
				Cbx_cata_mcut_sens1_pf
				Cbx_mis_polu_el_wind_rcpt_pf
				Cbx_schd_acr_pf
				Cbx_fsys_mdf1_pf
				Cbx_lamb_ac_rcpt_pf
				Cbx_cata_ac_rcpt_pf
				Cbx_mis_polu_ac_rcpt_pf
				Cbx_mis_cata_ac_rcpt_pf
				Cbx_fsys_ac_rcpt_pf
				Cbx_schd_ac_rcpt_pf
				Cbx_lamb_acr_pf
				Cbx_cata_acr_pf
				Cbx_mis_polu_acr_pf
				Cbx_mis_cata_acr_pf
				Cbx_fsys_acr_pf
				Cbx_cata_thpl_pf
				Cbx_mis_polu_mdf1_pf
				Cbx_fsys_mdf2_pf
				Cbx_mis_cata_mdf2_pf
				Cbx_mis_polu_mdf2_pf
				Cbx_cata_mdf2_pf
				Cbx_lamb_mdf2_pf
				Cbx_lamb_el_wind_rcpt_pf
				Cbx_mis_cata_mdf1_pf
				Cbx_cata_el_wind_rcpt_pf
				Cbx_cata_mdf1_pf
				Cbx_lamb_mdf1_pf
				Cbx_schd_el_wind_rcpt_pf
				Cbx_fsys_el_wind_rcpt_pf
				Cbx_mis_cata_el_wind_rcpt_pf
				Cbx_cata_pow_lbup_mfo
				Cbx_schd_mdf1_pf
				Cbx_mis_cata_agb_rcpt_mfo
				Cbx_mis_cata_pow_lbup_mfo
				Cbx_cata_vs_mfo
				Cbx_mis_polu_vs_mfo
				Cbx_mis_cata_vs_mfo
				Cbx_fsys_vs_mfo
				Cbx_schd_vs_mfo
				Cbx_lamb_wgc_mfo
				Cbx_cata_wgc_mfo
				Cbx_mis_polu_wgc_mfo
				Cbx_mis_cata_wgc_mfo
				Cbx_fsys_wgc_mfo
				Cbx_schd_wgc_mfo
				Cbx_lamb_agb_rcpt_mfo
				Cbx_schd_tia_mfo
				Cbx_mis_cata_air_mfo
				Cbx_fsys_crk_mfo
				Cbx_mis_cata_crk_mfo
				Cbx_mis_polu_crk_mfo
				Cbx_cata_crk_mfo
				Cbx_lamb_crk_mfo
				Cbx_cata_agb_rcpt_mfo
				Cbx_fsys_air_mfo
				Cbx_mis_polu_agb_rcpt_mfo
				Cbx_mis_polu_air_mfo
				Cbx_cata_air_mfo
				Cbx_lamb_air_mfo
				Cbx_schd_agb_rcpt_mfo
				Cbx_fsys_agb_rcpt_mfo
				Cbx_fsys_tia_mfo
				Cbx_schd_air_mfo
				Cbx_mis_polu_lbup_hot_mfo
				Cbx_schd_lbdw_mfo
				Cbx_lamb_lbdw_hot_mfo
				Cbx_cata_lbdw_hot_mfo
				Cbx_mis_polu_lbdw_hot_mfo
				Cbx_mis_cata_lbdw_hot_mfo
				Cbx_fsys_lbdw_hot_mfo
				Cbx_schd_lbdw_hot_mfo
				Cbx_lamb_lbup_mfo
				Cbx_cata_lbup_mfo
				Cbx_mis_polu_lbup_mfo
				Cbx_mis_cata_lbup_mfo
				Cbx_fsys_lbup_mfo
				Cbx_schd_lbup_mfo
				Cbx_lamb_vs_mfo
				Cbx_mis_polu_tco_mfo
				Cbx_mis_cata_tia_mfo
				Cbx_mis_polu_tia_mfo
				Cbx_cata_tia_mfo
				Cbx_lamb_tia_mfo
				Cbx_schd_tco_mfo
				Cbx_lamb_lbup_hot_mfo
				Cbx_mis_cata_tco_mfo
				Cbx_cata_lbup_hot_mfo
				Cbx_cata_tco_mfo
				Cbx_lamb_tco_mfo
				Cbx_schd_lbup_hot_mfo
				Cbx_fsys_lbup_hot_mfo
				Cbx_mis_cata_lbup_hot_mfo
				Cbx_cata_crk_nr_mfo
				Cbx_fsys_tco_mfo
				Cbx_lamb_obd_lamb_mfo
				Cbx_mis_cata_mis_cata_mfo
				Cbx_fsys_mis_cata_mfo
				Cbx_schd_mis_cata_mfo
				Cbx_lamb_mis_polu_mfo
				Cbx_cata_mis_polu_mfo
				Cbx_mis_polu_mis_polu_mfo
				Cbx_mis_cata_mis_polu_mfo
				Cbx_fsys_mis_polu_mfo
				Cbx_schd_mis_polu_mfo
				Cbx_lamb_obd_cata_mfo
				Cbx_cata_obd_cata_mfo
				Cbx_mis_polu_obd_cata_mfo
				Cbx_mis_cata_obd_cata_mfo
				Cbx_schd_crk_mfo
				Cbx_lamb_pow_lbdw_mfo
				Cbx_fsys_lbdw_mfo
				Cbx_lamb_pow_lbup_mfo
				Cbx_schd_pow_lbdw_mfo
				Cbx_fsys_pow_lbdw_mfo
				Cbx_mis_cata_pow_lbdw_mfo
				Cbx_fsys_obd_cata_mfo
				Cbx_cata_pow_lbdw_mfo
				Cbx_schd_obd_cata_mfo
				Cbx_schd_obd_lamb_mfo
				Cbx_fsys_obd_lamb_mfo
				Cbx_mis_cata_obd_lamb_mfo
				Cbx_mis_polu_obd_lamb_mfo
				Cbx_cata_obd_lamb_mfo
				Cbx_lamb_mis_cata_mfo
				Cbx_mis_polu_pow_lbdw_mfo
				Cbx_cata_eng_whl_mfo
				Cbx_mis_polu_mis_cata_mfo
				Cbx_cata_knk_mfo
				Cbx_fsys_igc_3_vf
				Cbx_schd_eng_whl_mfo
				Cbx_fsys_eng_whl_mfo
				Cbx_mis_cata_knk_mfo
				Cbx_mis_polu_eng_whl_mfo
				Cbx_fsys_knk_mfo
				Cbx_lamb_eng_whl_mfo
				Cbx_schd_crk_nr_mfo
				Cbx_fsys_crk_nr_mfo
				Cbx_mis_cata_crk_nr_mfo
				Cbx_mis_polu_crk_nr_mfo
				Cbx_mis_polu_pow_lbup_mfo
				Cbx_mis_cata_eng_whl_mfo
				Cbx_schd_map_mfo
				Cbx_lamb_crk_nr_mfo
				Cbx_schd_min_gas_lvl_mfo
				Cbx_fsys_min_gas_lvl_mfo
				Cbx_mis_cata_min_gas_lvl_mfo
				Cbx_mis_polu_min_gas_lvl_mfo
				Cbx_mis_cata_vta_intake_pf
				Cbx_lamb_min_gas_lvl_mfo
				Cbx_cata_mis_cata_mfo
				Cbx_fsys_map_mfo
				Cbx_mis_cata_map_mfo
				Cbx_mis_polu_map_mfo
				Cbx_cata_map_mfo
				Cbx_lamb_map_mfo
				Cbx_schd_knk_mfo
				Cbx_cata_min_gas_lvl_mfo
				Cbx_cata_eng_temp_pf
				Cbx_schd_crk_pf
				Cbx_lamb_crk_nr_pf
				Cbx_cata_crk_nr_pf
				Cbx_mis_polu_crk_nr_pf
				Cbx_mis_cata_crk_nr_pf
				Cbx_fsys_crk_nr_pf
				Cbx_schd_crk_nr_pf
				Cbx_lamb_cru_pf
				Cbx_cata_cru_pf
				Cbx_mis_polu_cru_pf
				Cbx_mis_cata_cru_pf
				Cbx_fsys_cru_pf
				Cbx_schd_knk_pf
				Cbx_lamb_eng_temp_pf
				Cbx_mis_polu_crk_pf
				Cbx_mis_polu_eng_temp_pf
				Cbx_mis_cata_eng_temp_pf
				Cbx_fsys_eng_temp_pf
				Cbx_schd_eng_temp_pf
				Cbx_lamb_eng_whl_pf
				Cbx_cata_eng_whl_pf
				Cbx_mis_polu_eng_whl_pf
				Cbx_mis_cata_eng_whl_pf
				Cbx_fsys_eng_whl_pf
				Cbx_schd_eng_whl_pf
				Cbx_lamb_gas_pump_pf
				Cbx_cata_gas_pump_pf
				Cbx_mis_polu_gas_pump_pf
				Cbx_schd_cru_pf
				Cbx_cata_alt_pf
				Cbx_fsys_actr_rly_pf
				Cbx_schd_actr_rly_pf
				Cbx_lamb_agb_pf
				Cbx_cata_agb_pf
				Cbx_mis_polu_agb_pf
				Cbx_mis_cata_agb_pf
				Cbx_fsys_agb_pf
				Cbx_schd_agb_pf
				Cbx_lamb_air_pf
				Cbx_cata_air_pf
				Cbx_mis_polu_air_pf
				Cbx_mis_cata_air_pf
				Cbx_fsys_air_pf
				Cbx_fsys_crk_pf
				Cbx_cata_cp_pf
				Cbx_schd_gas_pump_pf
				Cbx_cata_crk_pf
				Cbx_lamb_crk_pf
				Cbx_schd_cp_pf
				Cbx_fsys_cp_pf
				Cbx_schd_air_pf
