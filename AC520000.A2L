			"Verlog_en_serie"
			VALUE
			0x70D1E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Seuil_2_bobines_circ_ouvert_jumo
			"Seuil_2_bobines_circ_ouvert_jumo"
			VALUE
			0x71E6A
			DATA_RECORD_UWORD
			319995.1172
			F_4v8828125_p0_11
			0
			319995.1172
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Seuil_bobine_cc_bat
			"Seuil_bobine_cc_bat"
			VALUE
			0x71E6C
			DATA_RECORD_UWORD
			319995.1172
			F_4v8828125_p0_11
			0
			319995.1172
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Seuil_detection_bob_oc
			"Seuil_detection_bob_oc"
			VALUE
			0x71E36
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Seuil_detection_gas_pump_oc
			"Seuil_detection_gas_pump_oc"
			VALUE
			0x736B0
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Seuil_detection_panne_horloge_
			"Seuil_detection_panne_horloge"
			VALUE
			0x79014
			DATA_RECORD_UWORD
			262140
			F_4_p0_149
			0
			262140
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Seuil_max_reg_detect_cliq
			"Seuil_max_reg_detect_cliq"
			VALUE
			0x72580
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Seuil_maxi_vbatt_activ_vvt_adm
			"Seuil_maxi_vbatt_activ_vvt_adm"
			VALUE
			0x7B0D4
			DATA_RECORD_UBYTE
			8.16
			F_0v032_p8_130
			8
			16.16
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Seuil_maxi_vbatt_activ_wastegate
			"Seuil_maxi_vbatt_activ_wastegate"
			VALUE
			0x7ADEC
			DATA_RECORD_UBYTE
			8.16
			F_0v032_p8_130
			8
			16.16
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Seuil_min_reg_detect_cliq
			"Seuil_min_reg_detect_cliq"
			VALUE
			0x72581
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Seuil_min_top_roulant_
			"Seuil_min_top_roulant"
			VALUE
			0x79030
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Seuil_mini_vbatt_activ_vvt_adm
			"Seuil_mini_vbatt_activ_vvt_adm"
			VALUE
			0x7B0D5
			DATA_RECORD_UBYTE
			8.16
			F_0v032_p8_130
			8
			16.16
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Seuil_mini_vbatt_activ_wastegate
			"Seuil_mini_vbatt_activ_wastegate"
			VALUE
			0x7ADED
			DATA_RECORD_UBYTE
			8.16
			F_0v032_p8_130
			8
			16.16
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Seuil_regime_diag_bobine_
			"Seuil_regime_diag_bobine"
			VALUE
			0x71E37
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Seuil_regime_tension_bat_basse_
			"Seuil_regime_tension_bat_basse"
			VALUE
			0x71DEC
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Seuil_tension_inf_diag_bobine_
			"Seuil_tension_inf_diag_bobine"
			VALUE
			0x71E6E
			DATA_RECORD_UWORD
			8.191875
			F_0v000125_p8_7
			8
			16.191875
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Seuil_tension_panne_basse_vbr_
			"Seuil_tension_panne_basse_vbr"
			VALUE
			0x71DED
			DATA_RECORD_UBYTE
			8.16
			F_0v032_p5_296
			5
			13.16
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Seuil_vit_min_diag_periode_
			"Seuil_vit_min_diag_periode"
			VALUE
			0x79031
			DATA_RECORD_UBYTE
			255
			F_1_p0_58
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Specifreq
			"Dmd_special_skey"
			VALUE
			0x70D15
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Srgdmux
			"Seuil_regime_srv_liaison"
			VALUE
			0x71F24
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Srgmnvsc
			"Seuil_regime_moteur_mini_vsc"
			VALUE
			0x720EA
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ssm_default_closed_throttle_pos_
			"Ssm_default_closed_throttle_pos"
			VALUE
			0x733BC
			DATA_RECORD_UWORD
			6399.88596
			F_0v097656_p0_5
			0
			6399.88596
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ssm_default_limp_home_pos_
			"Ssm_default_limp_home_pos"
			VALUE
			0x733BE
			DATA_RECORD_UWORD
			6399.88596
			F_0v097656_p0_5
			0
			6399.88596
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ssm_default_open_throttle_pos_
			"Ssm_default_open_throttle_pos"
			VALUE
			0x733C0
			DATA_RECORD_UWORD
			6399.88596
			F_0v097656_p0_5
			0
			6399.88596
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ssm_default_throttle_position_
			"Ssm_default_throttle_position"
			VALUE
			0x733C2
			DATA_RECORD_UWORD
			6399.88596
			F_0v097656_p0_5
			0
			6399.88596
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ssm_pedal_pos_normal_manu_inh
			"Ssm_pedal_pos_normal_manu_inh"
			VALUE
			0x78FFB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ssm_pedal_pos_single_1_manu_enab
			"Ssm_pedal_pos_single_1_manu_enab"
			VALUE
			0x78FFC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ssm_pedal_pos_single_2_manu_enab
			"Ssm_pedal_pos_single_2_manu_enab"
			VALUE
			0x78FFD
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ssm_throt_pos_single_1_manu_enab
			"Ssm_throt_pos_single_1_manu_enab"
			VALUE
			0x78FFE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ssm_throt_pos_single_2_manu_enab
			"Ssm_throt_pos_single_2_manu_enab"
			VALUE
			0x78FFF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ssm_throttle_pos_normal_manu_inh
			"Ssm_throttle_pos_normal_manu_inh"
			VALUE
			0x79000
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Table_deb_clq_num_regime
			"Table_deb_clq_num_regime"
			CURVE
			0x72582
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				20
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n_knk
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Table_dec_clq_num_pression
			"Table_dec_clq_num_pression"
			CURVE
			0x72596
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
			/begin AXIS_DESCR COM_AXIS
				Vxx_map
				F_3v7_p103_37
				17
				103
				242582.5
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_map
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Table_dwell_dem_
			"Table_dwell_dem"
			CURVE
			0x71E70
			DATA_RECORD_UWORD
			209.712
			F_0v0032_p0_8
			0
			209.712
			/begin AXIS_DESCR FIX_AXIS
				Tension_batterie_brute_
				F_0v023583984_p0_196
				16
				5.990331936
				23.98491173
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 254 50 16
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Table_facteur_form_clq_num_cyl1
			"Table_facteur_form_clq_num_cyl1"
			MAP
			0x72654
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				20
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n_knk
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_map
				F_3v7_p103_37
				17
				103
				242582.5
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_map
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Table_facteur_form_clq_num_cyl2
			"Table_facteur_form_clq_num_cyl2"
			MAP
			0x728FC
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				20
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n_knk
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_map
				F_3v7_p103_37
				17
				103
				242582.5
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_map
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Table_facteur_form_clq_num_cyl3
			"Table_facteur_form_clq_num_cyl3"
			MAP
			0x72BA4
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				20
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n_knk
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_map
				F_3v7_p103_37
				17
				103
				242582.5
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_map
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Table_facteur_form_clq_num_cyl4
			"Table_facteur_form_clq_num_cyl4"
			MAP
			0x72E4C
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				20
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n_knk
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_map
				F_3v7_p103_37
				17
				103
				242582.5
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_map
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Table_freq_centrale_clq
			"Table_freq_centrale_clq"
			CURVE
			0x730F4
			DATA_RECORD_UWORD
			18.48044938
			D_2_0v0004_p0v054_181
			0.03806913355
			18.51851852
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				20
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n_knk
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Table_long_clq_num_regime
			"Table_long_clq_num_regime"
			CURVE
			0x725A7
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				20
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n_knk
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Table_nb_cycle_test_actionneur_
			"Table_nb_cycle_test_actionneur"
			CURVE
			0x79059
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				NO_INPUT_QUANTITY
				Id_0x00
				17
				0
				16
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 1 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Table_temperature_air
			"Table_temperature_air"
			CURVE
			0x70D9A
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
			/begin AXIS_DESCR COM_AXIS
				Temperature_air_brute_
				F_0v0048828125_p0_281
				17
				0
				319.9951172
				MAX_GRAD 100.0
				AXIS_PTS_REF Table_bkpt_temperature_air
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Table_temperature_eau
			"Table_temperature_eau"
			CURVE
			0x7B197
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
			/begin AXIS_DESCR COM_AXIS
				Temperature_eau_brute_
				F_0v0048828125_p0_281
				33
				0
				319.9951172
				MAX_GRAD 100.0
				AXIS_PTS_REF Table_bkpt_temperature_eau
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Table_temps_test_actionneur
			"Table_temps_test_actionneur"
			MAP
			0x7906A
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				NO_INPUT_QUANTITY
				Id_0x00
				2
				0
				1
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 1 2
			/end AXIS_DESCR
			/begin AXIS_DESCR FIX_AXIS
				NO_INPUT_QUANTITY
				Id_0x00
				17
				0
				16
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 1 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Taux_misfire_souhaite_
			"Taux_misfire_souhaite"
			VALUE
			0x71E38
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Temperature_air_acqui_max_
			"Temperature_air_acqui_max"
			VALUE
			0x70DCE
			DATA_RECORD_UWORD
			319994.298
			F_4v8828_p0_298
			0
			319994.298
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Temperature_air_acqui_min_
			"Temperature_air_acqui_min"
			VALUE
			0x70DD0
			DATA_RECORD_UWORD
			319994.298
			F_4v8828_p0_298
			0
			319994.298
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Temperature_eau_acqui_max_
			"Temperature_eau_acqui_max"
			VALUE
			0x7B204
			DATA_RECORD_UWORD
			319994.298
			F_4v8828_p0_298
			0
			319994.298
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Temperature_eau_acqui_min_
			"Temperature_eau_acqui_min"
			VALUE
			0x7B206
			DATA_RECORD_UWORD
			319994.298
			F_4v8828_p0_298
			0
			319994.298
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Temps_apres_test_actionneur_
			"Temps_apres_test_actionneur"
			VALUE
			0x7908C
			DATA_RECORD_UBYTE
			16320
			F_64_p0_145
			0
			16320
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Temps_avant_autorise_diagnostic
			"Temps_avant_autorise_diagnostic"
			VALUE
			0x736B1
			DATA_RECORD_UBYTE
			65.28
			F_0v256_p0_299
			0
			65.28
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Temps_cmd_appli_disable
			"Temps_cmd_appli_disable"
			VALUE
			0x736B4
			DATA_RECORD_UWORD
			209712
			F_3v2_p0_152
			0
			209712
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Temps_config_asic
			"Temps_config_asic"
			VALUE
			0x725BB
			DATA_RECORD_UBYTE
			1044.48
			F_4v096_p0_12
			0
			1044.48
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Temps_diag_disable
			"Temps_diag_disable"
			VALUE
			0x736B6
			DATA_RECORD_UWORD
			209712
			F_3v2_p0_152
			0
			209712
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Temps_diag_etat_bas_wpmp_disable
			"Temps_diag_etat_bas_wpmp_disable"
			VALUE
			0x736B2
			DATA_RECORD_UBYTE
			4080
			F_16_p0_10
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Temps_max_sauvegarde_eeprom
			"Temps_max_sauvegarde_eeprom"
			VALUE
			0x78D5A
			DATA_RECORD_UBYTE
			32640
			F_128_p0_125
			0
			32640
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tension_alim_capteur_maxi_
			"Tension_alim_capteur_maxi"
			VALUE
			0x70DD6
			DATA_RECORD_UWORD
			321.1215
			F_0v0049_p0_301
			0
			321.1215
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tension_alim_capteur_maxi_sdf_
			"Tension_alim_capteur_maxi_sdf"
			VALUE
			0x70DD8
			DATA_RECORD_UWORD
			321.1215
			F_0v0049_p0_301
			0
			321.1215
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tension_alim_capteur_mini_
			"Tension_alim_capteur_mini"
			VALUE
			0x70DDA
			DATA_RECORD_UWORD
			321.1215
			F_0v0049_p0_301
			0
			321.1215
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tension_alim_capteur_mini_sdf_
			"Tension_alim_capteur_mini_sdf"
			VALUE
			0x70DDC
			DATA_RECORD_UWORD
			321.1215
			F_0v0049_p0_301
			0
			321.1215
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tension_alim_par_defaut
			"Tension_alim_par_defaut"
			VALUE
			0x70DDE
			DATA_RECORD_UWORD
			321.1215
			F_0v0049_p0_301
			0
			321.1215
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tension_batterie_lis_thresh_hyst
			"Tension_batterie_lis_thresh_hyst"
			VALUE
			0x76FB0
			DATA_RECORD_UWORD
			1545.576391
			F_0v023583984_p0_196
			0
			1545.576391
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tension_batterie_lis_thresh_maxi
			"Tension_batterie_lis_thresh_maxi"
			VALUE
			0x76FB2
			DATA_RECORD_UWORD
			1545.576391
			F_0v023583984_p0_196
			0
			1545.576391
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tension_batterie_lis_thresh_mini
			"Tension_batterie_lis_thresh_mini"
			VALUE
			0x76FB4
			DATA_RECORD_UWORD
			1545.576391
			F_0v023583984_p0_196
			0
			1545.576391
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Test_stat_duree_actionneurs_
			"Test_stat_duree_actionneurs"
			VALUE
			0x7908D
			DATA_RECORD_UBYTE
			2040
			F_8_p0_56
			0
			2040
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Test_stat_duree_divers_1_
			"Test_stat_duree_divers_1"
			VALUE
			0x7908E
			DATA_RECORD_UBYTE
			2040
			F_8_p0_56
			0
			2040
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Test_stat_duree_divers_2_
			"Test_stat_duree_divers_2"
			VALUE
			0x7908F
			DATA_RECORD_UBYTE
			2040
			F_8_p0_56
			0
			2040
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Test_stat_duree_ho2_
			"Test_stat_duree_ho2"
			VALUE
			0x79090
			DATA_RECORD_UBYTE
			2040
			F_8_p0_56
			0
			2040
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tiban
			"Temps_injection_banc"
			VALUE
			0x76F9A
			DATA_RECORD_UWORD
			262.14
			F_0v004_p0_201
			0
			262.14
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Time_nca
			"Time_nca"
			VALUE
			0x784AE
			DATA_RECORD_UWORD
			6143.90625
			F_0v09375_p0_282
			0
			6143.90625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Time_nct
			"Time_nct"
			VALUE
			0x7849E
			DATA_RECORD_UBYTE
			127.5
			F_0v5_p0_304
			0
			127.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Time_out_max_com_spi
			"Time_out_max_com_spi"
			VALUE
			0x79016
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tmatdem
			"Tempo_attente_arret_dem"
			VALUE
			0x71F2E
			DATA_RECORD_UBYTE
			32640
			F_128_p0_125
			0
			32640
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tmatscan
			"Temps_max_antiscanning"
			VALUE
			0x70D18
			DATA_RECORD_UBYTE
			25500
			F_100_p0_305
			0
			25500
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tmatsta
			"Tempo_attente_stop_starter"
			VALUE
			0x71F30
			DATA_RECORD_UBYTE
			2040
			F_8_p0_56
			0
			2040
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tmattrps
			"Temps_max_attent_repons"
			VALUE
			0x70D19
			DATA_RECORD_UBYTE
			2550
			F_10_p0_306
			0
			2550
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tmattski
			"Temps_max_attent_skey"
			VALUE
			0x70D1A
			DATA_RECORD_UBYTE
			2550
			F_10_p0_306
			0
			2550
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tmatvsc
			"Tempo_attente_emis_entraine"
			VALUE
			0x71F2F
			DATA_RECORD_UBYTE
			2040
			F_8_p0_56
			0
			2040
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tmclear
			"Temps_max_seq_clear"
			VALUE
			0x70D1D
			DATA_RECORD_UBYTE
			2550
			F_10_p0_306
			0
			2550
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tmcnx
			"Delai_autoris_detct_connex_mux"
			VALUE
			0x71EFF
			DATA_RECORD_UBYTE
			2040
			F_8_p0_56
			0
			2040
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tmcrash
			"Duree_autori_apres_crash"
			VALUE
			0x720C0
			DATA_RECORD_UWORD
			67107.84
			F_1v024_p0_119
			0
			67107.84
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tmdefva
			"Time_out_si_first_dem"
			VALUE
			0x71F3B
			DATA_RECORD_UBYTE
			32640
			F_128_p0_125
			0
			32640
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tmdiamux
			"Valeur_tempo_srv_liaison"
			VALUE
			0x71F3D
			DATA_RECORD_UBYTE
			32640
			F_128_p0_125
			0
			32640
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tmmxvsc
			"Tempo_regime_max_vsc"
			VALUE
			0x71F31
			DATA_RECORD_UBYTE
			32640
			F_128_p0_125
			0
			32640
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tmmyvsc
			"Tempo_regime_moyen_vsc"
			CURVE
			0x71F32
			DATA_RECORD_UBYTE
			8160
			F_32_p0_122
			0
			8160
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tco
				F_0v625_m40_25
				9
				-40
				120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tmnp3
			"Tmnp3"
			VALUE
			0x72120
			DATA_RECORD_UWORD
			524280
			F_8_p0_56
			0
			524280
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tmonitat
			"Timer_srv_at_diag_off"
			VALUE
			0x72118
			DATA_RECORD_UBYTE
			16320
			F_64_p0_145
			0
			16320
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tmotopro
			"Temps_max_fonct_mot_vl"
			VALUE
			0x70D1B
			DATA_RECORD_UBYTE
			2550
			F_10_p0_306
			0
			2550
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tmouto
			"Table_time_out_fct_eau"
			CURVE
			0x71F25
			DATA_RECORD_UBYTE
			32640
			F_128_p0_125
			0
			32640
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tco
				F_0v625_m40_25
				9
				-40
				120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tmwlvl
			"Temps_max_pwl_vl"
			VALUE
			0x70D1C
			DATA_RECORD_UBYTE
			25500
			F_100_p0_305
			0
			25500
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_1_closed_pos_max_
			"Tpac_1_closed_pos_max"
			VALUE
			0x733C4
			DATA_RECORD_UWORD
			6399.88596
			F_0v097656_p0_5
			0
			6399.88596
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_1_closed_pos_min_
			"Tpac_1_closed_pos_min"
			VALUE
			0x733C6
			DATA_RECORD_UWORD
			6399.88596
			F_0v097656_p0_5
			0
			6399.88596
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_1_limp_home_max_
			"Tpac_1_limp_home_max"
			VALUE
			0x733C8
			DATA_RECORD_UWORD
			6399.88596
			F_0v097656_p0_5
			0
			6399.88596
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_1_limp_home_min_
			"Tpac_1_limp_home_min"
			VALUE
			0x733CA
			DATA_RECORD_UWORD
			6399.88596
			F_0v097656_p0_5
			0
			6399.88596
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_1_open_pos_max_
			"Tpac_1_open_pos_max"
			VALUE
			0x733CC
			DATA_RECORD_UWORD
			6399.88596
			F_0v097656_p0_5
			0
			6399.88596
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_1_open_pos_min_
			"Tpac_1_open_pos_min"
			VALUE
			0x733CE
			DATA_RECORD_UWORD
			6399.88596
			F_0v097656_p0_5
			0
			6399.88596
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_2_closed_pos_max_
			"Tpac_2_closed_pos_max"
			VALUE
			0x733D0
			DATA_RECORD_UWORD
			6399.88596
			F_0v097656_p0_5
			0
			6399.88596
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_2_closed_pos_min_
			"Tpac_2_closed_pos_min"
			VALUE
			0x733D2
			DATA_RECORD_UWORD
			6399.88596
			F_0v097656_p0_5
			0
			6399.88596
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_2_limp_home_max_
			"Tpac_2_limp_home_max"
			VALUE
			0x733D4
			DATA_RECORD_UWORD
			6399.88596
			F_0v097656_p0_5
			0
			6399.88596
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_2_limp_home_min_
			"Tpac_2_limp_home_min"
			VALUE
			0x733D6
			DATA_RECORD_UWORD
			6399.88596
			F_0v097656_p0_5
			0
			6399.88596
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_2_open_pos_max_
			"Tpac_2_open_pos_max"
			VALUE
			0x733D8
			DATA_RECORD_UWORD
			6399.88596
			F_0v097656_p0_5
			0
			6399.88596
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_2_open_pos_min_
			"Tpac_2_open_pos_min"
			VALUE
			0x733DA
			DATA_RECORD_UWORD
			6399.88596
			F_0v097656_p0_5
			0
			6399.88596
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_attenuation_gain_map_
			"Tpac_attenuation_gain_map"
			CURVE
			0x7325F
			DATA_RECORD_UBYTE
			0.99603
			F_0v003906_p0_308
			0
			0.99603
			/begin AXIS_DESCR COM_AXIS
				Tpac_distance_to_limp_home_
				F_0v09765625_p0_71
				5
				0
				24.90234375
				MAX_GRAD 100.0
				AXIS_PTS_REF Tpac_throttle_pos_bkpt_
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_battery_voltage_gain_map_
			"Tpac_battery_voltage_gain_map"
			CURVE
			0x733DC
			DATA_RECORD_UWORD
			9.764715
			F_0v000149_p0_309
			0
			9.764715
			/begin AXIS_DESCR FIX_AXIS
				Tension_batterie_brute_
				F_0v023583984_p0_196
				9
				0
				24.14999962
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 128 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_check_limp_home_delay
			"Tpac_check_limp_home_delay"
			VALUE
			0x73264
			DATA_RECORD_UBYTE
			8160
			F_32_p0_122
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_consigne_accost
			"Tpac_consigne_accost"
			VALUE
			0x733EE
			DATA_RECORD_UWORD
			6399.902344
			F_0v09765625_p0_71
			0
			6399.902344
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_deriv_filt_input_gain_1_
			"Tpac_deriv_filt_input_gain_1"
			VALUE
			0x733F0
			DATA_RECORD_UWORD
			1310.7
			F_0v02_p0_310
			0
			1310.7
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_deriv_filt_input_gain_2_
			"Tpac_deriv_filt_input_gain_2"
			VALUE
			0x733F2
			DATA_RECORD_UWORD
			1310.7
			F_0v02_p0_310
			0
			1310.7
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_deriv_filt_input_gain_3_
			"Tpac_deriv_filt_input_gain_3"
			VALUE
			0x733F4
			DATA_RECORD_UWORD
			1310.7
			F_0v02_p0_310
			0
			1310.7
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_deriv_filt_input_gain_4_
			"Tpac_deriv_filt_input_gain_4"
			VALUE
			0x733F6
			DATA_RECORD_UWORD
			1310.7
			F_0v02_p0_310
			0
			1310.7
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_deriv_filt_input_gain_h_1
			"Tpac_deriv_filt_input_gain_h_1"
			VALUE
			0x733F8
			DATA_RECORD_UWORD
			1310.7
			F_0v02_p0_310
			0
			1310.7
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_deriv_filt_input_gain_h_2
			"Tpac_deriv_filt_input_gain_h_2"
			VALUE
			0x733FA
			DATA_RECORD_UWORD
			1310.7
			F_0v02_p0_310
			0
			1310.7
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_deriv_filt_input_gain_h_3
			"Tpac_deriv_filt_input_gain_h_3"
			VALUE
			0x733FC
			DATA_RECORD_UWORD
			1310.7
			F_0v02_p0_310
			0
			1310.7
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_deriv_filt_input_gain_h_4
			"Tpac_deriv_filt_input_gain_h_4"
			VALUE
			0x733FE
			DATA_RECORD_UWORD
			1310.7
			F_0v02_p0_310
			0
			1310.7
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_deriv_filt_output_gain
			"Tpac_deriv_filt_output_gain"
			VALUE
			0x73400
			DATA_RECORD_UWORD
			1.04856
			F_0v000016_p0_311
			0
			1.04856
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_deriv_filt_output_gain_h
			"Tpac_deriv_filt_output_gain_h"
			VALUE
			0x73402
			DATA_RECORD_UWORD
			1.04856
			F_0v000016_p0_311
			0
			1.04856
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_deriv_gain_map
			"Tpac_deriv_gain_map"
			CURVE
			0x73404
			DATA_RECORD_UWORD
			39976.35
			F_0v61_p0_312
			0
			39976.35
			/begin AXIS_DESCR COM_AXIS
				Vxx_cor_thr_pos_mes
				F_0v097656_p0_5
				16
				0
				6399.88596
				MAX_GRAD 100.0
				AXIS_PTS_REF Tpac_position_bkpt_map
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_dithering_filter_coef_
			"Tpac_dithering_filter_coef"
			VALUE
			0x73265
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_dyn_test_bed_duration_map
			"Tpac_dyn_test_bed_duration_map"
			CURVE
			0x73266
			DATA_RECORD_UBYTE
			32.64
			F_0v128_p0_75
			0
			32.64
			/begin AXIS_DESCR FIX_AXIS
				Tpac_test_bed_table_counter
				Id_0x00
				16
				0
				15
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 1 16
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_dyn_test_bed_mode
			"Tpac_dyn_test_bed_mode"
			VALUE
			0x73276
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_dyn_test_bed_offset_map
			"Tpac_dyn_test_bed_offset_map"
			CURVE
			0x73277
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Tpac_test_bed_table_counter
				Id_0x00
				16
				0
				15
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 1 16
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_dyn_test_bed_pattern_number
			"Tpac_dyn_test_bed_pattern_number"
			VALUE
			0x73287
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_dyn_test_bed_rel_ref_map
			"Tpac_dyn_test_bed_rel_ref_map"
			CURVE
			0x732E0
			DATA_RECORD_SWORD
			6399.902344
			F_0v09765625_p0_71
			-3200
			3199.902344
			/begin AXIS_DESCR FIX_AXIS
				Tpac_test_bed_table_counter
				Id_0x00
				16
				0
				15
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 1 16
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_dyn_test_bed_type_ref_map
			"Tpac_dyn_test_bed_type_ref_map"
			CURVE
			0x73288
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
			/begin AXIS_DESCR FIX_AXIS
				Tpac_test_bed_table_counter
				Id_0x00
				16
				0
				15
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 1 16
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_error_to_velocity_gain_
			"Tpac_error_to_velocity_gain"
			CURVE
			0x73298
			DATA_RECORD_UBYTE
			163.2
			F_0v64_p0_315
			0
			163.2
			/begin AXIS_DESCR COM_AXIS
				NO_INPUT_QUANTITY
				F_0v097656_p0_5
				16
				0
				6399.88596
				MAX_GRAD 100.0
				AXIS_PTS_REF Tpac_position_bkpt_map
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_exit_accost_stab_dly
			"Tpac_exit_accost_stab_dly"
			VALUE
			0x732A8
			DATA_RECORD_UBYTE
			2040
			F_8_p0_56
			0
			2040
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_exit_thrusts_delay
			"Tpac_exit_thrusts_delay"
			VALUE
			0x732A9
			DATA_RECORD_UBYTE
			8160
			F_32_p0_122
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_exit_thrusts_stab_dly
			"Tpac_exit_thrusts_stab_dly"
			VALUE
			0x732AA
			DATA_RECORD_UBYTE
			2040
			F_8_p0_56
			0
			2040
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_feed_forward_hysteresis_
			"Tpac_feed_forward_hysteresis"
			VALUE
			0x732AB
			DATA_RECORD_UBYTE
			24.90234375
			F_0v09765625_p0_71
			0
			24.90234375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_feed_forward_low_
			"Tpac_feed_forward_low"
			VALUE
			0x7323C
			DATA_RECORD_SBYTE
			16320
			F_64_p0_317
			-8192
			8128
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_feed_forward_up_
			"Tpac_feed_forward_up"
			VALUE
			0x7323D
			DATA_RECORD_SBYTE
			16320
			F_64_p0_317
			-8192
			8128
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_ff_closed_gain
			"Tpac_ff_closed_gain"
			VALUE
			0x732AC
			DATA_RECORD_UBYTE
			510
			F_2_p0_318
			0
			510
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_ff_closed_offset
			"Tpac_ff_closed_offset"
			VALUE
			0x7323E
			DATA_RECORD_SBYTE
			16320
			F_64_p0_317
			-8192
			8128
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_ff_hyst_manu_inh
			"Tpac_ff_hyst_manu_inh"
			VALUE
			0x732AD
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_ff_lh_high_gain
			"Tpac_ff_lh_high_gain"
			VALUE
			0x732AE
			DATA_RECORD_UBYTE
			16320
			F_64_p0_319
			0
			16320
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_ff_lh_low_gain
			"Tpac_ff_lh_low_gain"
			VALUE
			0x732AF
			DATA_RECORD_UBYTE
			16320
			F_64_p0_319
			0
			16320
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_ff_open_gain
			"Tpac_ff_open_gain"
			VALUE
			0x732B0
			DATA_RECORD_UBYTE
			510
			F_2_p0_318
			0
			510
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_ff_open_offset
			"Tpac_ff_open_offset"
			VALUE
			0x7323F
			DATA_RECORD_SBYTE
			16320
			F_64_p0_317
			-8192
			8128
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_high_thrust_detect_dly
			"Tpac_high_thrust_detect_dly"
			VALUE
			0x732B1
			DATA_RECORD_UBYTE
			2088.96
			F_8v192_p0_248
			0
			2088.96
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_inhibit_delay
			"Tpac_inhibit_delay"
			VALUE
			0x732B2
			DATA_RECORD_UBYTE
			8160
			F_32_p0_122
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_integral_failure_delay_
			"Tpac_integral_failure_delay"
			VALUE
			0x732B3
			DATA_RECORD_UBYTE
			510
			F_2_p0_249
			0
			510
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_integral_failure_thresh_
			"Tpac_integral_failure_thresh"
			VALUE
			0x73424
			DATA_RECORD_UWORD
			20.4796875
			F_0v0003125_p0_307
			0
			20.4796875
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_integral_gain_map_
			"Tpac_integral_gain_map"
			CURVE
			0x73426
			DATA_RECORD_UWORD
			9830.25
			F_0v15_p0_321
			0
			9830.25
			/begin AXIS_DESCR COM_AXIS
				Vxx_cor_thr_pos_mes
				F_0v097656_p0_5
				16
				0
				6399.88596
				MAX_GRAD 100.0
				AXIS_PTS_REF Tpac_position_bkpt_map
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_integral_init_bf_map
			"Tpac_integral_init_bf_map"
			CURVE
			0x73446
			DATA_RECORD_UWORD
			40959.375
			F_0v625_m20480_132
			-20480
			20479.375
			/begin AXIS_DESCR COM_AXIS
				Vxx_cor_thr_pos_mes
				F_0v097656_p0_5
				16
				0
				6399.88596
				MAX_GRAD 100.0
				AXIS_PTS_REF Tpac_position_bkpt_map
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_integral_init_map
			"Tpac_integral_init_map"
			CURVE
			0x73466
			DATA_RECORD_UWORD
			20.4796875
			F_0v0003125_p0_307
			0
			20.4796875
			/begin AXIS_DESCR COM_AXIS
				Tpac_abs_integral
				F_0v0003125_p0_307
				9
				0
				20.4796875
				MAX_GRAD 100.0
				AXIS_PTS_REF Tpac_norm_integral_bkpt
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_integral_limiter_map
			"Tpac_integral_limiter_map"
			CURVE
			0x7348A
			DATA_RECORD_UWORD
			40959.375
			F_0v625_p0_258
			0
			40959.375
			/begin AXIS_DESCR COM_AXIS
				Vxx_fil_thr_psn_sp
				F_0v097656_p0_5
				9
				0
				6399.88596
				MAX_GRAD 100.0
				AXIS_PTS_REF Tpac_integral_limiter_bkpt_map
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_integral_limiter_mode
			"Tpac_integral_limiter_mode"
			VALUE
			0x732B4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_integral_limiter_neg_map
			"Tpac_integral_limiter_neg_map"
			CURVE
			0x7349C
			DATA_RECORD_UWORD
			40959.375
			F_0v625_p0_258
			0
			40959.375
			/begin AXIS_DESCR COM_AXIS
				Vxx_fil_thr_psn_sp
				F_0v097656_p0_5
				9
				0
				6399.88596
				MAX_GRAD 100.0
				AXIS_PTS_REF Tpac_integral_limiter_bkpt_map
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_learn_limp_home_delay
			"Tpac_learn_limp_home_delay"
			VALUE
			0x732B5
			DATA_RECORD_UBYTE
			8160
			F_32_p0_122
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_limp_home_area
			"Tpac_limp_home_area"
			VALUE
			0x732B6
			DATA_RECORD_UBYTE
			24.902331
			F_0v0976562_p0_322
			0
			24.902331
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_limp_home_variation
			"Tpac_limp_home_variation"
			VALUE
			0x7952E
			DATA_RECORD_UBYTE
			24.90234375
			F_0v09765625_p0_71
			0
			24.90234375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_low_thrust_detect_dly
			"Tpac_low_thrust_detect_dly"
			VALUE
			0x732B7
			DATA_RECORD_UBYTE
			2088.96
			F_8v192_p0_248
			0
			2088.96
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_maximum_throttle_pos_error_
			"Tpac_maximum_throttle_pos_error"
			VALUE
			0x734AE
			DATA_RECORD_UWORD
			6399.88596
			F_0v097656_p0_5
			0
			6399.88596
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_mcw_inh_test_control_volt_
			"Tpac_mcw_inh_test_control_volt"
			VALUE
			0x73300
			DATA_RECORD_SWORD
			40959.375
			F_0v625_p0_258
			-20480
			20479.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_nul_torque_duty_cycle_
			"Tpac_nul_torque_duty_cycle"
			VALUE
			0x734C2
			DATA_RECORD_UWORD
			399.9938965
			F_0v0061035156_p0_23
			0
			399.9938965
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_open_thrust_search_inh
			"Tpac_open_thrust_search_inh"
			VALUE
			0x732B8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_pidmou_mesure_inh
			"Tpac_pidmou_mesure_inh"
			VALUE
			0x732B9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_prop_gain_map
			"Tpac_prop_gain_map"
			CURVE
			0x734E4
			DATA_RECORD_UWORD
			9830.25
			F_0v15_p0_324
			0
			9830.25
			/begin AXIS_DESCR COM_AXIS
				Vxx_cor_thr_pos_mes
				F_0v097656_p0_5
				16
				0
				6399.88596
				MAX_GRAD 100.0
				AXIS_PTS_REF Tpac_position_bkpt_map
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_servo_failure_detect_delay_
			"Tpac_servo_failure_detect_delay"
			VALUE
			0x732BA
			DATA_RECORD_UBYTE
			510
			F_2_p0_249
			0
			510
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_servo_failure_diag_delay
			"Tpac_servo_failure_diag_delay"
			VALUE
			0x732BB
			DATA_RECORD_UBYTE
			510
			F_2_p0_249
			0
			510
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_throttle_open_thresh_
			"Tpac_throttle_open_thresh"
			VALUE
			0x73504
			DATA_RECORD_UWORD
			6399.88596
			F_0v097656_p0_5
			0
			6399.88596
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_thrust_search_cleoff_delay
			"Tpac_thrust_search_cleoff_delay"
			VALUE
			0x732C1
			DATA_RECORD_UBYTE
			8160
			F_32_p0_122
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_thrusts_air_temp_maxi_
			"Tpac_thrusts_air_temp_maxi"
			VALUE
			0x732C2
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_thrusts_air_temp_mini_
			"Tpac_thrusts_air_temp_mini"
			VALUE
			0x732C3
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_thrusts_search_delay
			"Tpac_thrusts_search_delay"
			VALUE
			0x732C4
			DATA_RECORD_UBYTE
			8160
			F_32_p0_122
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_thrusts_search_manu_inh_
			"Tpac_thrusts_search_manu_inh"
			VALUE
			0x76FAC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_trt_accost
			"Tpac_trt_accost"
			VALUE
			0x732C5
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_trt_mesures
			"Tpac_trt_mesures"
			VALUE
			0x732C6
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_vel_smoothing_low_limit
			"Tpac_vel_smoothing_low_limit"
			VALUE
			0x73506
			DATA_RECORD_UWORD
			6399.88596
			F_0v097656_p0_5
			0
			6399.88596
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_vel_smoothing_up_limit
			"Tpac_vel_smoothing_up_limit"
			VALUE
			0x73508
			DATA_RECORD_UWORD
			6399.88596
			F_0v097656_p0_5
			0
			6399.88596
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_velocity_limit_map_
			"Tpac_velocity_limit_map"
			CURVE
			0x7350A
			DATA_RECORD_UWORD
			4095.9375
			F_0v0625_p0_316
			0
			4095.9375
			/begin AXIS_DESCR COM_AXIS
				Vxx_tco
				F_0v625_m40_25
				4
				-40
				119.375
				MAX_GRAD 100.0
				AXIS_PTS_REF Tpac_velocity_limit_bkpt_4_
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpac_velocity_smoothing_enable
			"Tpac_velocity_smoothing_enable"
			VALUE
			0x732CB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpc_comp_diag_inh_delay_
			"Tpc_comp_diag_inh_delay"
			VALUE
			0x732CC
			DATA_RECORD_UBYTE
			8160
			F_32_p0_122
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpc_free_wheeling_delay_
			"Tpc_free_wheeling_delay"
			VALUE
			0x732CD
			DATA_RECORD_UBYTE
			8160
			F_32_p0_122
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tpc_frequence_pwm_gain_
			"Tpc_frequence_pwm_gain"
			VALUE
			0x732CE
			DATA_RECORD_UBYTE
			255
			F_1_p1_150
			1
			256
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tps_1_default_cc_thresh_
			"Tps_1_default_cc_thresh"
			VALUE
			0x73512
			DATA_RECORD_UWORD
			6399.88596
			F_0v097656_p0_5
			0
			6399.88596
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tps_1_default_co_thresh_
			"Tps_1_default_co_thresh"
			VALUE
			0x73514
			DATA_RECORD_UWORD
			6399.88596
			F_0v097656_p0_5
			0
			6399.88596
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tps_2_default_cc_thresh_
			"Tps_2_default_cc_thresh"
			VALUE
			0x73516
			DATA_RECORD_UWORD
			6399.88596
			F_0v097656_p0_5
			0
			6399.88596
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tps_2_default_scg_thresh
			"Tps_2_default_scg_thresh"
			VALUE
			0x73518
			DATA_RECORD_UWORD
			6399.88596
			F_0v097656_p0_5
			0
			6399.88596
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tps_coh_filter_gain_
			"Tps_coh_filter_gain"
			VALUE
			0x732CF
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Tps_position_tolerance_
			"Tps_position_tolerance"
			VALUE
			0x7351A
			DATA_RECORD_UWORD
			6399.88596
			F_0v097656_p0_5
			0
			6399.88596
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Trgmxvsc
			"Table_seuil_reg_moteur_max_vsc"
			CURVE
			0x720EC
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tco
				F_0v625_m40_25
				9
				-40
				120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Trgmyvsc
			"Table_seuil_reg_moteur_moy_vsc"
			CURVE
			0x720FE
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tco
				F_0v625_m40_25
				9
				-40
				120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ucemux1
			"Init_ucemux1"
			VALUE
			0x71F09
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ucemux10
			"Init_ucemux10"
			VALUE
			0x71F0A
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ucemux11
			"Init_ucemux11"
			VALUE
			0x71F0B
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ucemux12
			"Init_ucemux12"
			VALUE
			0x71F0C
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ucemux13
			"Init_ucemux13"
			VALUE
			0x71F0D
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ucemux14
			"Init_ucemux14"
			VALUE
			0x71F0E
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ucemux15
			"Init_ucemux15"
			VALUE
			0x71F0F
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ucemux16
			"Init_ucemux16"
			VALUE
			0x71F10
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ucemux17
			"Init_ucemux17"
			VALUE
			0x71F11
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ucemux18
			"Init_ucemux18"
			VALUE
			0x71F12
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ucemux19
			"Init_ucemux19"
			VALUE
			0x71F13
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ucemux2
			"Init_ucemux2"
			VALUE
			0x71F14
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ucemux20
			"Init_ucemux20"
			VALUE
			0x71F15
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ucemux21
			"Init_ucemux21"
			VALUE
			0x71F16
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ucemux22
			"Init_ucemux22"
			VALUE
			0x71F17
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ucemux23
			"Init_ucemux23"
			VALUE
			0x71F18
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ucemux24
			"Init_ucemux24"
			VALUE
			0x71F19
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ucemux3
			"Init_ucemux3"
			VALUE
			0x71F1A
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ucemux4
			"Init_ucemux4"
			VALUE
			0x71F1B
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ucemux5
			"Init_ucemux5"
			VALUE
			0x71F1C
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ucemux6
			"Init_ucemux6"
			VALUE
			0x71F1D
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ucemux7
			"Init_ucemux7"
			VALUE
			0x71F1E
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ucemux8
			"Init_ucemux8"
			VALUE
			0x71F1F
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ucemux9
			"Init_ucemux9"
			VALUE
			0x71F20
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Val_tempo_connexion_ev_iae
			"Val_tempo_connexion_ev_iae"
			VALUE
			0x7ADEE
			DATA_RECORD_UBYTE
			2040
			F_8_p0_56
			0
			2040
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Val_tempo_connexion_gmv
			"Val_tempo_connexion_gmv"
			VALUE
			0x7373C
			DATA_RECORD_UBYTE
			2040
			F_8_p0_56
			0
			2040
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Val_tempo_connexion_pav_1
			"Val_tempo_connexion_pav_1"
			VALUE
			0x7372A
			DATA_RECORD_UBYTE
			2040
			F_8_p0_56
			0
			2040
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Val_tempo_connexion_pav_2
			"Val_tempo_connexion_pav_2"
			VALUE
			0x7372B
			DATA_RECORD_UBYTE
			2040
			F_8_p0_56
			0
			2040
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Val_tempo_connexion_pmpair
			"Val_tempo_connexion_pmpair"
			VALUE
			0x7ADEF
			DATA_RECORD_UBYTE
			2040
			F_8_p0_56
			0
			2040
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Val_tempo_connexion_ptc_rov
			"Val_tempo_connexion_ptc_rov"
			VALUE
			0x78D5E
			DATA_RECORD_UBYTE
			2040
			F_8_p0_56
			0
			2040
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Val_tempo_connexion_thp_
			"Val_tempo_connexion_thp"
			VALUE
			0x790BA
			DATA_RECORD_UBYTE
			2040
			F_8_p0_56
			0
			2040
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Val_tempo_connexion_wpmp
			"Val_tempo_connexion_wpmp"
			VALUE
			0x78495
			DATA_RECORD_UBYTE
			2040
			F_8_p0_56
			0
			2040
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Valeur_cpt_pp_trig_edic
			"Valeur_cpt_pp_trig_edic"
			VALUE
			0x736CF
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Valeur_tempo_srv_liaison_tdb
			"Valeur_tempo_srv_liaison_tdb"
			VALUE
			0x7212C
			DATA_RECORD_UBYTE
			2040
			F_8_p0_56
			0
			2040
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Valeur_tempo_srv_reception_abs
			"Valeur_tempo_srv_reception_abs"
			VALUE
			0x72110
			DATA_RECORD_UBYTE
			2040
			F_8_p0_56
			0
			2040
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Valeur_tempo_srv_reception_acc
			"Valeur_tempo_srv_reception_acc"
			VALUE
			0x72114
			DATA_RECORD_UBYTE
			2040
			F_8_p0_56
			0
			2040
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Valeur_tempo_srv_reception_bva
			"Valeur_tempo_srv_reception_bva"
			VALUE
			0x72119
			DATA_RECORD_UBYTE
			2040
			F_8_p0_56
			0
			2040
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Valeur_tempo_srv_reception_clim
			"Valeur_tempo_srv_reception_clim"
			VALUE
			0x7211C
			DATA_RECORD_UBYTE
			2040
			F_8_p0_56
			0
			2040
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Valeur_tempo_srv_reception_gpl
			"Valeur_tempo_srv_reception_gpl"
			VALUE
			0x72124
			DATA_RECORD_UBYTE
			2040
			F_8_p0_56
			0
			2040
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Valeur_tempo_srv_reception_uch
			"Valeur_tempo_srv_reception_uch"
			VALUE
			0x72130
			DATA_RECORD_UBYTE
			2040
			F_8_p0_56
			0
			2040
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Valmax
			"Valeur_max_compteurs_can"
			VALUE
			0x71F3C
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Vta_intake_3_tooth_check
			"Vta_intake_3_tooth_check"
			VALUE
			0x7B0D6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Vta_intake_advance_configuration
			"Vta_intake_advance_configuration"
			VALUE
			0x7B0D7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Vta_intake_band
			"Vta_intake_band"
			VALUE
			0x7B110
			DATA_RECORD_UWORD
			6143.90625
			F_0v09375_p0_282
			0
			6143.90625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Vta_intake_block_failure_delay
			"Vta_intake_block_failure_delay"
			VALUE
			0x7B0D8
			DATA_RECORD_UBYTE
			4080
			F_16_p0_10
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Vta_intake_cam_offsets_manu_inh
			"Vta_intake_cam_offsets_manu_inh"
			VALUE
			0x7B0D9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Vta_intake_camshaft_shift_def
			"Vta_intake_camshaft_shift_def"
			VALUE
			0x7B112
			DATA_RECORD_UWORD
			6143.90625
			F_0v09375_p0_282
			0
			6143.90625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Vta_intake_capture_falling_edge
			"Vta_intake_capture_falling_edge"
			VALUE
			0x7B0DA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Vta_intake_comp_reg_carto
			"Vta_intake_comp_reg_carto"
			CURVE
			0x7B0DB
			DATA_RECORD_UBYTE
			23.90625
			F_0v09375_m12_331
			-12
			11.90625
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				20
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Vta_intake_def_tooth
			"Vta_intake_def_tooth"
			VALUE
			0x7B0EF
			DATA_RECORD_UBYTE
			255
			F_1_p0_9
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Vta_intake_der_gain
			"Vta_intake_der_gain"
			VALUE
			0x7B114
			DATA_RECORD_UWORD
			266.6625835
			F_0v0040690102_p0_326
			0
			266.6625835
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Vta_intake_der_mod
			"Vta_intake_der_mod"
			VALUE
			0x7B0F0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Vta_intake_dyn_lim
			"Vta_intake_dyn_lim"
			VALUE
			0x7B116
			DATA_RECORD_UWORD
			6143.90625
			F_0v09375_p0_329
			0
			6143.90625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Vta_intake_force_off_learning
			"Vta_intake_force_off_learning"
			VALUE
			0x7B0F1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Vta_intake_gain_hb
			"Vta_intake_gain_hb"
			VALUE
			0x7B118
			DATA_RECORD_UWORD
			7585.069396
			F_0v11574074_p0_332
			0
			7585.069396
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Vta_intake_higher_def_limit
			"Vta_intake_higher_def_limit"
			VALUE
			0x7B11A
			DATA_RECORD_UWORD
			6143.90625
			F_0v09375_p0_282
			0
			6143.90625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Vta_intake_hot_oil_condition
			"Vta_intake_hot_oil_condition"
			VALUE
			0x7B11C
			DATA_RECORD_UWORD
			40959.375
			F_0v625_m40_25
			-40
			40919.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Vta_intake_init_max_int_value
			"Vta_intake_init_max_int_value"
			VALUE
			0x7B11E
			DATA_RECORD_UWORD
			6399.902344
			F_0v09765625_p0_71
			0
			6399.902344
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Vta_intake_int_failure_delay
			"Vta_intake_int_failure_delay"
			VALUE
			0x7B0F2
			DATA_RECORD_UBYTE
			4080
			F_16_p0_10
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Vta_intake_int_gain
			"Vta_intake_int_gain"
			VALUE
			0x7B120
			DATA_RECORD_UWORD
			1066.650347
			F_0v016276041_p0_327
			0
			1066.650347
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Vta_intake_int_inh_band
			"Vta_intake_int_inh_band"
			VALUE
			0x7B122
			DATA_RECORD_UWORD
			6143.90625
			F_0v09375_p0_282
			0
			6143.90625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Vta_intake_learn_delay
			"Vta_intake_learn_delay"
			VALUE
			0x7B0F3
			DATA_RECORD_UBYTE
			1044.48
			F_4v096_p0_12
			0
			1044.48
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Vta_intake_learning_oil_max
			"Vta_intake_learning_oil_max"
			VALUE
			0x7B124
			DATA_RECORD_UWORD
			40959.375
			F_0v625_m40_25
			-40
			40919.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Vta_intake_learning_oil_min
			"Vta_intake_learning_oil_min"
			VALUE
			0x7B126
			DATA_RECORD_UWORD
			40959.375
			F_0v625_m40_25
			-40
			40919.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Vta_intake_learning_reg_max
			"Vta_intake_learning_reg_max"
			VALUE
			0x7B128
			DATA_RECORD_UWORD
			8191.875
			F_0v125_p0_30
			0
			8191.875
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Vta_intake_lower_def_limit
			"Vta_intake_lower_def_limit"
			VALUE
			0x7B12A
			DATA_RECORD_UWORD
			6143.90625
			F_m0v09375_p0_333
			-6143.90625
			0
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Vta_intake_min_reg
			"Vta_intake_min_reg"
			VALUE
			0x7B12C
			DATA_RECORD_UWORD
			8191.875
			F_0v125_p0_30
			0
			8191.875
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Vta_intake_min_reg_inh
			"Vta_intake_min_reg_inh"
			VALUE
			0x7B12E
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Vta_intake_off_margin
			"Vta_intake_off_margin"
			VALUE
			0x7B130
			DATA_RECORD_UWORD
			6143.90625
			F_0v09375_p0_282
			0
			6143.90625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Vta_intake_old_off_margin
			"Vta_intake_old_off_margin"
			VALUE
			0x7B132
			DATA_RECORD_UWORD
			6143.90625
			F_0v09375_p0_282
			0
			6143.90625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Vta_intake_pmh_threshold
			"Vta_intake_pmh_threshold"
			VALUE
			0x7B0F4
			DATA_RECORD_UBYTE
			255
			F_1_p0_53
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Vta_intake_prop_gain_map
			"Vta_intake_prop_gain_map"
			CURVE
			0x7B148
			DATA_RECORD_UWORD
			4266.601388
			F_0v065104164_p0_328
			0
			4266.601388
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				10
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Vta_intake_prop_gain_bkpt
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Vta_intake_reference_angle
			"Vta_intake_reference_angle"
			CURVE
			0x7B15C
			DATA_RECORD_UWORD
			6143.90625
			F_0v09375_p0_282
			0
			6143.90625
			/begin AXIS_DESCR FIX_AXIS
				NO_INPUT_QUANTITY
				Id_0x00
				4
				0
				3
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 1 4
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Vta_intake_resynchro_manu_inh
			"Vta_intake_resynchro_manu_inh"
			VALUE
			0x7B0F5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Vta_intake_run_learning_dsb
			"Vta_intake_run_learning_dsb"
			VALUE
			0x7B0F6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Vta_intake_threshold_error
			"Vta_intake_threshold_error"
			VALUE
			0x7B164
			DATA_RECORD_UWORD
			6143.90625
			F_0v09375_p0_282
			0
			6143.90625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Vta_intake_threshold_int_max
			"Vta_intake_threshold_int_max"
			VALUE
			0x7B166
			DATA_RECORD_UWORD
			99.99847412
			F_0v0015258789_p0_115
			0
			99.99847412
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Vta_intake_threshold_int_min
			"Vta_intake_threshold_int_min"
			VALUE
			0x7B168
			DATA_RECORD_UWORD
			99.99847412
			F_0v0015258789_p0_115
			0
			99.99847412
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Vta_intake_to_1
			"Vta_intake_to_1"
			VALUE
			0x7B16A
			DATA_RECORD_UWORD
			2047.96875
			F_0v03125_p0_334
			0
			2047.96875
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Vta_intake_to_2
			"Vta_intake_to_2"
			VALUE
			0x7B16C
			DATA_RECORD_UWORD
			2047.96875
			F_0v03125_p0_334
			0
			2047.96875
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Vta_intake_vel_calc_mod
			"Vta_intake_vel_calc_mod"
			VALUE
			0x7B0F7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin AXIS_PTS Ctb_agb_sli
			"Ctb_agb_sli"
			0x71E9B
			Vxx_agb_sli
			AXIS_PTS_X_UBYTE
			199.21875
			F_0v78125_p0_16
			16
			0
			199.21875
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_agb_sli_tq_eng_n
			"Ctb_agb_sli_tq_eng_n"
			0x72042
			Vxx_n01
			AXIS_PTS_X_UWORD
			65535
			F_1_p0_14
			8
			0
			65535
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_agb_toil
			"Ctb_agb_toil"
			0x71EAB
			Vxx_mux_agb_toil
			AXIS_PTS_X_UBYTE
			255
			F_1_m40_40
			8
			-40
			215
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_alt_n
			"Ctb_alt_n"
			0x7A6CE
			Vxx_alt_n
			AXIS_PTS_X_UWORD
			65535
			F_1_p0_14
			13
			0
			65535
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_alti
			"Ctb_alti"
			0x7AD6E
			Vxx_alti
			AXIS_PTS_X_UBYTE
			943.5
			F_3v7_p0_21
			5
			0
			943.5
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_amp_0_amp_rat_alti
			"Ctb_amp_0_amp_rat_alti"
			0x731BB
			Vxx_alti_255
			AXIS_PTS_X_UBYTE
			943.5
			F_3v7_p0_21
			7
			0
			943.5
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_cru_sl_vs
			"Ctb_cru_sl_vs"
			0x78EC1
			Vxx_cru_sl_vs
			AXIS_PTS_X_UBYTE
			255
			F_1_p0_58
			17
			0
			255
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_csm_agb_tq
			"Ctb_csm_agb_tq"
			0x71D22
			Vxx_agb_csm_tq
			AXIS_PTS_X_UWORD
			511.9921875
			F_0v0078125_p0_15
			9
			0
			511.9921875
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_decl_n
			"Ctb_decl_n"
			0x73AE6
			Regime_pour_gain_ecart_reg_
			AXIS_PTS_X_UWORD
			2097120
			F_32_m256_59
			17
			-256
			2096864
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_dft_comb_eal
			"Ctb_dft_comb_eal"
			0x781D2
			Vxx_eal_tdc_2
			AXIS_PTS_X_UWORD
			399.9938965
			F_0v0061035156_p0_23
			17
			0
			399.9938965
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_dft_comb_eal2
			"Ctb_dft_comb_eal2"
			0x781F4
			Vxx_eal_tdc_2
			AXIS_PTS_X_UWORD
			399.9938965
			F_0v0061035156_p0_23
			5
			0
			399.9938965
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_dft_comb_eal2_lpg
			"Ctb_dft_comb_eal2_lpg"
			0x781FE
			Vxx_eal_tdc_2
			AXIS_PTS_X_UWORD
			399.9938965
			F_0v0061035156_p0_23
			5
			0
			399.9938965
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_dft_comb_n2
			"Ctb_dft_comb_n2"
			0x78208
			Vxx_prev2_n
			AXIS_PTS_X_UWORD
			65535
			F_1_p0_14
			5
			0
			65535
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_dft_comb_n2_lpg
			"Ctb_dft_comb_n2_lpg"
			0x78212
			Vxx_prev2_n
			AXIS_PTS_X_UWORD
			65535
			F_1_p0_14
			5
			0
			65535
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_eal1
			"Ctb_eal1"
			0x7A6E8
			Vxx_eal
			AXIS_PTS_X_UWORD
			399.9938965
			F_0v0061035156_p0_23
			16
			0
			399.9938965
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_eal2
			"Ctb_eal2"
			0x7A708
			Vxx_eal
			AXIS_PTS_X_UWORD
			399.9938965
			F_0v0061035156_p0_23
			9
			0
			399.9938965
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_eal3
			"Ctb_eal3"
			0x76FF2
			Vxx_eal
			AXIS_PTS_X_UWORD
			399.9938965
			F_0v0061035156_p0_23
			6
			0
			399.9938965
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_eal_eai
			"Ctb_eal_eai"
			0x76D04
			Vxx_eal
			AXIS_PTS_X_UWORD
			399.9938965
			F_0v0061035156_p0_23
			9
			0
			399.9938965
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_eal_fl
			"Ctb_eal_fl"
			0x76D16
			Vxx_eal
			AXIS_PTS_X_UWORD
			399.9938965
			F_0v0061035156_p0_23
			11
			0
			399.9938965
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_eng_alti
			"Ctb_eng_alti"
			0x78468
			Vxx_alti
			AXIS_PTS_X_UBYTE
			943.5
			F_3v7_p0_21
			5
			0
			943.5
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_eng_tq
			"Ctb_eng_tq"
			0x78F3A
			Vxx_driv_slow_eng_tq
			AXIS_PTS_X_UWORD
			511.9921875
			F_0v0078125_m100_35
			17
			-100
			411.9921875
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_fac_n_dif_drv
			"Ctb_fac_n_dif_drv"
			0x79032
			NO_INPUT_QUANTITY
			AXIS_PTS_X_UWORD
			65535
			F_1_p0_60
			5
			0
			65535
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_fzy_tkof_tqe_grd
			"Ctb_fzy_tkof_tqe_grd"
			0x73684
			Vxx_driv_tqe_sp_grd
			AXIS_PTS_X_UWORD
			1310.7
			F_0v02_m655v35_61
			9
			-655.35
			655.35
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_fzy_tkof_vs
			"Ctb_fzy_tkof_vs"
			0x73696
			Vxx_vs16
			AXIS_PTS_X_UWORD
			655.35
			F_0v01_p0_62
			5
			0
			655.35
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_gear
			"Ctb_gear"
			0x78ED2
			Vxx_cru_sl_gear
			AXIS_PTS_X_UBYTE
			255
			F_1_p0_9
			8
			0
			255
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_iga_cata_wup_ctr
			"Ctb_iga_cata_wup_ctr"
			0x71D34
			Vxx_cata_wup_ctr
			AXIS_PTS_X_UWORD
			65535
			F_1_p0_53
			9
			0
			65535
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_is_cata_wup_ctr
			"Ctb_is_cata_wup_ctr"
			0x73B08
			Vxx_cata_wup_ctr
			AXIS_PTS_X_UWORD
			65535
			F_1_p0_53
			17
			0
			65535
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_is_cor_alt_pow
			"Ctb_is_cor_alt_pow"
			0x73B2A
			Vxx_fil_alt_pow
			AXIS_PTS_X_UWORD
			1310700
			F_20_p0_63
			9
			0
			1310700
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_is_cor_n
			"Ctb_is_cor_n"
			0x73873
			Vxx_n32
			AXIS_PTS_X_UBYTE
			8160
			F_32_p0_46
			9
			0
			8160
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_lamb_diag_n
			"Ctb_lamb_diag_n"
			0x78BB8
			Vxx_n0125
			AXIS_PTS_X_UWORD
			8191.875
			F_0v125_p0_30
			10
			0
			8191.875
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_lpg_ad_fac
			"Ctb_lpg_ad_fac"
			0x73806
			Vxx_lpg_mv_ad_fac
			AXIS_PTS_X_UWORD
			99.99847412
			F_0v0015258789_m50_64
			3
			-50
			49.99847412
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_lpg_ad_zon_prs
			"Ctb_lpg_ad_zon_prs"
			0x7380C
			Vxx_pred_map
			AXIS_PTS_X_UWORD
			242479.5
			F_3v7_p103_37
			5
			103
			242582.5
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_lpg_temp_09
			"Ctb_lpg_temp_09"
			0x73747
			Vxx_lpg_temp
			AXIS_PTS_X_UBYTE
			255
			F_1_m40_40
			9
			-40
			215
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_lpg_typ
			"Ctb_lpg_typ"
			0x73750
			Vxx_lpg_typ
			AXIS_PTS_X_UBYTE
			99.609375
			F_0v390625_p0_4
			3
			0
			99.609375
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_map
			"Ctb_map"
			0x78600
			Vxx_map
			AXIS_PTS_X_UWORD
			242479.5
			F_3v7_p103_37
			17
			103
			242582.5
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_map_fl
			"Ctb_map_fl"
			0x76D2C
			Vxx_map
			AXIS_PTS_X_UWORD
			242479.5
			F_3v7_p103_37
			11
			103
			242582.5
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_map_ol
			"Ctb_map_ol"
			0x76D42
			Vxx_map
			AXIS_PTS_X_UWORD
			242479.5
			F_3v7_p103_37
			5
			103
			242582.5
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_mis_n_17
			"Ctb_mis_n_17"
			0x78230
			Vxx_prev2_n
			AXIS_PTS_X_UWORD
			65535
			F_1_p0_14
			17
			0
			65535
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_mis_tlz_cor_eal
			"Ctb_mis_tlz_cor_eal"
			0x78252
			Vxx_eal_tdc_2
			AXIS_PTS_X_UWORD
			399.9938965
			F_0v0061035156_p0_23
			9
			0
			399.9938965
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_mis_tlz_cor_eal_lpg
			"Ctb_mis_tlz_cor_eal_lpg"
			0x78264
			Vxx_eal_tdc_2
			AXIS_PTS_X_UWORD
			399.9938965
			F_0v0061035156_p0_23
			9
			0
			399.9938965
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_mis_tlz_cor_n
			"Ctb_mis_tlz_cor_n"
			0x78276
			Vxx_n01
			AXIS_PTS_X_UWORD
			65535
			F_1_p0_14
			9
			0
			65535
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_mis_tlz_cor_n_lpg
			"Ctb_mis_tlz_cor_n_lpg"
			0x78288
			Vxx_n01
			AXIS_PTS_X_UWORD
			65535
			F_1_p0_14
			9
			0
			65535
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_n
			"Ctb_n"
			0x78BCC
			Vxx_n0125
			AXIS_PTS_X_UWORD
			8191.875
			F_0v125_p0_30
			20
			0
			8191.875
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_n1
			"Ctb_n1"
			0x78C1C
			Vxx_n01
			AXIS_PTS_X_UWORD
			65535
			F_1_p0_14
			20
			0
			65535
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_n2
			"Ctb_n2"
			0x78C44
			Vxx_n01
			AXIS_PTS_X_UWORD
			65535
			F_1_p0_14
			9
			0
			65535
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_n3
			"Ctb_n3"
			0x78C56
			Vxx_n01
			AXIS_PTS_X_UWORD
			65535
			F_1_p0_14
			9
			0
			65535
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_n4
			"Ctb_n4"
			0x76FFE
			Vxx_n01
			AXIS_PTS_X_UWORD
			65535
			F_1_p0_14
			6
			0
			65535
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_n5
			"Ctb_n5"
			0x73B3C
			Vxx_n01
			AXIS_PTS_X_UWORD
			65535
			F_1_p0_14
			9
			0
			65535
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_n6
			"Ctb_n6"
			0x71D6A
			Vxx_n01
			AXIS_PTS_X_UWORD
			65535
			F_1_p0_14
			9
			0
			65535
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_n7
			"Ctb_n7"
			0x78622
			Vxx_n0125
			AXIS_PTS_X_UWORD
			8191.875
			F_0v125_p0_30
			9
			0
			8191.875
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_n_aj
			"Ctb_n_aj"
			0x7A71A
			Vxx_n01
			AXIS_PTS_X_UWORD
			65535
			F_1_p0_14
			9
			0
			65535
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_n_dif
			"Ctb_n_dif"
			0x7A72C
			Vxx_tkof_n_dif
			AXIS_PTS_X_UWORD
			65535
			F_1_m4096_65
			9
			-4096
			61439
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_n_drv
			"Ctb_n_drv"
			0x7A73E
			Vxx_tkof_n_dif_drv
			AXIS_PTS_X_UWORD
			65535
			F_1_m8192_66
			9
			-8192
			57343
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_n_eai
			"Ctb_n_eai"
			0x76D4C
			Vxx_n01
			AXIS_PTS_X_UWORD
			65535
			F_1_p0_14
			9
			0
			65535
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_n_gear_cge
			"Ctb_n_gear_cge"
			0x71D46
			Vxx_n01
			AXIS_PTS_X_UWORD
			65535
			F_1_p0_14
			9
			0
			65535
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_n_knk
			"Ctb_n_knk"
			0x78BF4
			Vxx_n0125
			AXIS_PTS_X_UWORD
			8191.875
			F_0v125_p0_30
			20
			0
			8191.875
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_n_ol
			"Ctb_n_ol"
			0x76D5E
			Vxx_n0125
			AXIS_PTS_X_UWORD
			8191.875
			F_0v125_p0_30
			5
			0
			8191.875
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_n_tlz_ad_b
			"Ctb_n_tlz_ad_b"
			0x73126
			Vxx_n01
			AXIS_PTS_X_UWORD
			65535
			F_1_p0_14
			6
			0
			65535
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_n_wup
			"Ctb_n_wup"
			0x71D58
			Vxx_n01
			AXIS_PTS_X_UWORD
			65535
			F_1_p0_14
			9
			0
			65535
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_pred_map_prs_rat
			"Ctb_pred_map_prs_rat"
			0x7866A
			Vxx_raw_mdl_map_spg_rat
			AXIS_PTS_X_UWORD
			1999969.482
			F_30v517578125_p0_67
			10
			0
			1999969.482
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_prs_dif
			"Ctb_prs_dif"
			0x76D68
			Vxx_prs_dif
			AXIS_PTS_X_UWORD
			242479.5
			F_3v7_m2841v6_44
			17
			-2841.6
			239637.9
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_prs_rat
			"Ctb_prs_rat"
			0x7A750
			Vxx_up_down_thr_prs_rat
			AXIS_PTS_X_UWORD
			999984.7412
			F_15v2587890625_p0_68
			22
			0
			999984.7412
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_psi_fac_cor
			"Ctb_psi_fac_cor"
			0x7867E
			Vxx_psi_fac_cor
			AXIS_PTS_X_UWORD
			16383.75
			F_0v25_p0_69
			17
			0
			16383.75
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_ptc_pow
			"Ctb_ptc_pow"
			0x793A7
			Vxx_ptc_pow
			AXIS_PTS_X_UBYTE
			25500
			F_100_p0_70
			5
			0
			25500
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_pump_maf
			"Ctb_pump_maf"
			0x7AF5C
			Vxx_cor_pump_maf
			AXIS_PTS_X_UWORD
			0.9999847412
			F_0v0000152588_p0_27
			9
			0
			0.9999847412
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_rams_tq_req
			"Ctb_rams_tq_req"
			0x7A77C
			Vxx_rams_mask_t_tq_req
			AXIS_PTS_X_UWORD
			511.9921875
			F_0v0078125_m100_35
			17
			-100
			411.9921875
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_rel_pdl_psn
			"Ctb_rel_pdl_psn"
			0x78F5C
			Vxx_rams_pdl_psn_rat
			AXIS_PTS_X_UWORD
			6399.902344
			F_0v09765625_p0_71
			17
			0
			6399.902344
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_rel_tq_wup
			"Ctb_rel_tq_wup"
			0x719F5
			Vxx_cata_wup_rel_tq
			AXIS_PTS_X_UBYTE
			99.609375
			F_0v390625_p0_4
			9
			0
			99.609375
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_rich_sp9
			"Ctb_rich_sp9"
			0x7A79E
			Vxx_rich_sp
			AXIS_PTS_X_UWORD
			1.999969605
			F_0v0000305176_p0_72
			9
			0
			1.999969605
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_spg_ar_maf_fac
			"Ctb_spg_ar_maf_fac"
			0x7AF6E
			Vxx_spg_ar_maf_fac
			AXIS_PTS_X_UWORD
			62500.7295
			F_0v9537_p0_73
			9
			0
			62500.7295
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_spg_n
			"Ctb_spg_n"
			0x7AF80
			Vxx_n01
			AXIS_PTS_X_UWORD
			65535
			F_1_p0_14
			6
			0
			65535
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_spg_ol_map_sp
			"Ctb_spg_ol_map_sp"
			0x7AD73
			NO_INPUT_QUANTITY
			AXIS_PTS_X_UBYTE
			1887
			F_7v4_p750_49
			9
			750
			2637
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_spg_tq_rat
			"Ctb_spg_tq_rat"
			0x7AD7C
			Vxx_spg_tq_rat_sp
			AXIS_PTS_X_UBYTE
			0.99609375
			F_0v00390625_p0_74
			9
			0
			0.99609375
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_t_lbup_hot_rest
			"Ctb_t_lbup_hot_rest"
			0x783C8
			Vxx_lbup_hot_t
			AXIS_PTS_X_UWORD
			8388.48
			F_0v128_p0_75
			3
			0
			8388.48
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_t_lbup_hot_sta
			"Ctb_t_lbup_hot_sta"
			0x783CE
			Vxx_lbup_hot_t
			AXIS_PTS_X_UWORD
			8388.48
			F_0v128_p0_75
			3
			0
			8388.48
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_tco
			"Ctb_tco"
			0x7B170
			Vxx_tco
			AXIS_PTS_X_UBYTE
			159.375
			F_0v625_m40_25
			16
			-40
			119.375
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_tco_cl_off
			"Ctb_tco_cl_off"
			0x755AE
			Vxx_tco
			AXIS_PTS_X_UBYTE
			159.375
			F_0v625_m40_25
			13
			-40
			119.375
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_tco_cut
			"Ctb_tco_cut"
			0x755BB
			Vxx_tco
			AXIS_PTS_X_UBYTE
			159.375
			F_0v625_m40_25
			9
			-40
			119.375
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_tco_dif
			"Ctb_tco_dif"
			0x76FDD
			Vxx_tco_dif
			AXIS_PTS_X_UBYTE
			159.375
			F_0v625_m40_25
			9
			-40
			119.375
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_tco_dif_max
			"Ctb_tco_dif_max"
			0x7B180
			Vxx_tco_mdl
			AXIS_PTS_X_UBYTE
			159.375
			F_0v625_m40_25
			5
			-40
			119.375
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_tco_mdl
			"Ctb_tco_mdl"
			0x7B185
			Vxx_sta_tco
			AXIS_PTS_X_UBYTE
			159.375
			F_0v625_m40_25
			5
			-40
			119.375
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_tco_thd
			"Ctb_tco_thd"
			0x7874E
			Vxx_tco
			AXIS_PTS_X_UBYTE
			159.375
			F_0v625_m40_25
			9
			-40
			119.375
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_thr_mcut_psn
			"Ctb_thr_mcut_psn"
			0x73302
			Tpac_relative_lh_throttle_pos
			AXIS_PTS_X_UWORD
			6399.88596
			F_0v097656_m100_77
			10
			-100
			6299.88596
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_thr_psn
			"Ctb_thr_psn"
			0x7AF8C
			Vxx_fil_thr_psn_sp
			AXIS_PTS_X_UWORD
			6399.88596
			F_0v097656_p0_5
			9
			0
			6399.88596
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_thr_sge_psn
			"Ctb_thr_sge_psn"
			0x73316
			Tpac_relative_lh_throttle_pos
			AXIS_PTS_X_UWORD
			6399.88596
			F_0v097656_m100_77
			10
			-100
			6299.88596
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_tia_17
			"Ctb_tia_17"
			0x719FE
			Vxx_tia
			AXIS_PTS_X_UBYTE
			159.375
			F_0v625_m40_25
			17
			-40
			119.375
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_tkof_vs_n_rat
			"Ctb_tkof_vs_n_rat"
			0x7A7B0
			Vxx_vs_n_rat16
			AXIS_PTS_X_UWORD
			99.9998565
			F_0v0015259_p0_78
			7
			0
			99.9998565
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_toil
			"Ctb_toil"
			0x78C68
			Vxx_toil
			AXIS_PTS_X_UWORD
			40959.375
			F_0v625_m40_25
			5
			-40
			40919.375
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_toil2
			"Ctb_toil2"
			0x78C72
			Vxx_toil
			AXIS_PTS_X_UWORD
			40959.375
			F_0v625_m40_25
			17
			-40
			40919.375
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_tq
			"Ctb_tq"
			0x735D3
			Vxx_tq_rat_sp
			AXIS_PTS_X_UBYTE
			99.609375
			F_0v390625_p0_4
			9
			0
			99.609375
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_tq_rat_sp
			"Ctb_tq_rat_sp"
			0x793AC
			Vxx_tq_rat_sp
			AXIS_PTS_X_UBYTE
			99.609375
			F_0v390625_p0_4
			9
			0
			99.609375
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_tq_stat_ref
			"Ctb_tq_stat_ref"
			0x7AF9E
			Vxx_tq_stat_ref
			AXIS_PTS_X_UWORD
			511.9921875
			F_0v0078125_m100_35
			9
			-100
			411.9921875
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_vs
			"Ctb_vs"
			0x793B5
			Vxx_vs
			AXIS_PTS_X_UBYTE
			255
			F_1_p0_58
			9
			0
			255
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_vs_mvac_dp
			"Ctb_vs_mvac_dp"
			0x73707
			Vxx_vs
			AXIS_PTS_X_UBYTE
			255
			F_1_p0_58
			7
			0
			255
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_vvt_n
			"Ctb_vvt_n"
			0x78C94
			Vxx_n0125
			AXIS_PTS_X_UWORD
			8191.875
			F_0v125_p0_30
			9
			0
			8191.875
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_vvt_n1
			"Ctb_vvt_n1"
			0x735E4
			Vxx_n01
			AXIS_PTS_X_UWORD
			65535
			F_1_p0_14
			9
			0
			65535
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_vvt_n2
			"Ctb_vvt_n2"
			0x78CA6
			Vxx_n01
			AXIS_PTS_X_UWORD
			65535
			F_1_p0_14
			20
			0
			65535
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_wet_cor_map
			"Ctb_wet_cor_map"
			0x786A0
			Vxx_pred_map
			AXIS_PTS_X_UWORD
			242479.5
			F_3v7_p103_37
			9
			103
			242582.5
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_wet_n
			"Ctb_wet_n"
			0x78CCE
			Vxx_n0125
			AXIS_PTS_X_UWORD
			8191.875
			F_0v125_p0_30
			5
			0
			8191.875
		/end AXIS_PTS
		/begin AXIS_PTS Ctb_wet_tdc_rat_ctr
			"Ctb_wet_tdc_rat_ctr"
			0x755C4
			Vxx_wet_tdc_rat_ctr
			AXIS_PTS_X_UBYTE
			255
			Id_0x00
			9
			0
			255
		/end AXIS_PTS
		/begin AXIS_PTS Ctd_n_ptc_is_cor
			"Ctd_n_ptc_is_cor"
			0x7387C
			Vxx_ptc_pow
			AXIS_PTS_X_UBYTE
			25500
			F_100_p0_70
			6
			0
			25500
		/end AXIS_PTS
		/begin AXIS_PTS Ctp_iga_dif
			"Ctp_iga_dif"
			0x7940B
			NO_INPUT_QUANTITY
			AXIS_PTS_X_UBYTE
			95.625
			F_0v375_p0_33
			33
			0
			95.625
		/end AXIS_PTS
		/begin AXIS_PTS Ctp_thr_ar_pos
			"Ctp_thr_ar_pos"
			0x7483A
			Vxx_fil_thr_pos_thr_adj
			AXIS_PTS_X_UWORD
			6399.88596
			F_0v097656_p0_5
			17
			0
			6399.88596
		/end AXIS_PTS
		/begin AXIS_PTS Icd_map_bkpt
			"Icd_map_bkpt"
			0x71E50
			Vxx_map
			AXIS_PTS_X_UWORD
			242479.5
			F_3v7_p103_37
			5
			103
			242582.5
		/end AXIS_PTS
		/begin AXIS_PTS Icd_reg_bkpt
			"Icd_reg_bkpt"
			0x71E5A
			Vxx_n01
			AXIS_PTS_X_UWORD
			65535
			F_1_p0_14
			8
			0
			65535
		/end AXIS_PTS
		/begin AXIS_PTS Ntb_whl_spd
			"Ntb_whl_spd"
			0x7362E
			Vxx_vs
			AXIS_PTS_X_UBYTE
			15.9375
			F_0v0625_p0_110
			9
			0
			15.9375
		/end AXIS_PTS
		/begin AXIS_PTS Table_bkpt_temperature_air
			"Table_bkpt_temperature_air"
			0x70DAC
			Temperature_air_brute_
			AXIS_PTS_X_UWORD
			319.9951172
			F_0v0048828125_p0_281
			17
			0
			319.9951172
		/end AXIS_PTS
		/begin AXIS_PTS Table_bkpt_temperature_eau
			"Table_bkpt_temperature_eau"
			0x7B1C2
			Temperature_eau_brute_
			AXIS_PTS_X_UWORD
			319.9951172
			F_0v0048828125_p0_281
			33
			0
			319.9951172
		/end AXIS_PTS
		/begin AXIS_PTS Tpac_integral_limiter_bkpt_map
			"Tpac_integral_limiter_bkpt_map"
			0x73478
			Vxx_fil_thr_psn_sp
			AXIS_PTS_X_UWORD
			6399.88596
			F_0v097656_p0_5
			9
			0
			6399.88596
		/end AXIS_PTS
		/begin AXIS_PTS Tpac_norm_integral_bkpt
			"Tpac_norm_integral_bkpt"
			0x734B0
			Tpac_abs_integral
			AXIS_PTS_X_UWORD
			20.4796875
			F_0v0003125_p0_307
			9
			0
			20.4796875
		/end AXIS_PTS
		/begin AXIS_PTS Tpac_position_bkpt_map
			"Tpac_position_bkpt_map"
			0x734C4
			NO_INPUT_QUANTITY
			AXIS_PTS_X_UWORD
			6399.88596
			F_0v097656_p0_5
			16
			0
			6399.88596
		/end AXIS_PTS
		/begin AXIS_PTS Tpac_throttle_pos_bkpt_
			"Tpac_throttle_pos_bkpt"
			0x732BC
			Tpac_distance_to_limp_home_
			AXIS_PTS_X_UBYTE
			24.90234375
			F_0v09765625_p0_71
			5
			0
			24.90234375
		/end AXIS_PTS
		/begin AXIS_PTS Tpac_velocity_limit_bkpt_4_
			"Tpac_velocity_limit_bkpt_4"
			0x732C7
			Vxx_tco
			AXIS_PTS_X_UBYTE
			159.375
			F_0v625_m40_25
			4
			-40
			119.375
		/end AXIS_PTS
		/begin AXIS_PTS Vta_intake_prop_gain_bkpt
			"Vta_intake_prop_gain_bkpt"
			0x7B134
			Vxx_n01
			AXIS_PTS_X_UWORD
			65535
			F_1_p0_14
			10
			0
			65535
		/end AXIS_PTS
		/begin MEASUREMENT Eep_dem_ecr_obj_cpt_dem_panne6
			"Eep_dem_ecr_obj_cpt_dem_panne6"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AD6
		/end MEASUREMENT
		/begin MEASUREMENT Eep_defaut_obj_cpt_dem_panne6
			"Eep_defaut_obj_cpt_dem_panne6"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A9E
		/end MEASUREMENT
		/begin MEASUREMENT Eep_defaut_obj_exception_regs
			"Eep_defaut_obj_exception_regs"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A95
		/end MEASUREMENT
		/begin MEASUREMENT Eep_trt_ecr_obj_cpt_pan_valid
			"Eep_trt_ecr_obj_cpt_pan_valid"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AFB
		/end MEASUREMENT
		/begin MEASUREMENT Eep_trt_ecr_obj_calage_verrou
			"Eep_trt_ecr_obj_calage_verrou"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8ADC
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_ecr_obj_cpt_warm_up
			"Eep_dem_ecr_obj_cpt_warm_up"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8ABD
		/end MEASUREMENT
		/begin MEASUREMENT Eep_defaut_obj_objet_aerau_2
			"Eep_defaut_obj_objet_aerau_2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A97
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_ecr_obj_adapt_rich_gpl
			"Eep_dem_ecr_obj_adapt_rich_gpl"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AA8
		/end MEASUREMENT
		/begin MEASUREMENT Eep_trt_ecr_obj_adapt_rich_gpl
			"Eep_trt_ecr_obj_adapt_rich_gpl"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AE0
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_lec_obj_adapt_rich_gpl
			"Eep_dem_lec_obj_adapt_rich_gpl"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B18
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_ecr_obj_objet_aerau_1
			"Eep_dem_ecr_obj_objet_aerau_1"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8ACE
		/end MEASUREMENT
		/begin MEASUREMENT Eep_trt_ecr_obj_eepr_correc_trz
			"Eep_trt_ecr_obj_eepr_correc_trz"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8ADE
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_lec_obj_reco_cyl
			"Eep_dem_lec_obj_reco_cyl"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B1E
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_ecr_obj_objet_aerau_2
			"Eep_dem_ecr_obj_objet_aerau_2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8ACF
		/end MEASUREMENT
		/begin MEASUREMENT Eep_defaut_obj_freeze_frame
			"Eep_defaut_obj_freeze_frame"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A6F
		/end MEASUREMENT
		/begin MEASUREMENT Eep_trt_ecr_obj_version
			"Eep_trt_ecr_obj_version"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AE5
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_lec_obj_version
			"Eep_dem_lec_obj_version"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B1D
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_lec_obj_objet_aerau_1
			"Eep_dem_lec_obj_objet_aerau_1"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B3E
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_lec_obj_objet_aerau_2
			"Eep_dem_lec_obj_objet_aerau_2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B3F
		/end MEASUREMENT
		/begin MEASUREMENT Eep_defaut_obj_reco_cyl
			"Eep_defaut_obj_reco_cyl"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A76
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_ecr_obj_cpt_dem_panne3
			"Eep_dem_ecr_obj_cpt_dem_panne3"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AD3
		/end MEASUREMENT
		/begin MEASUREMENT Eep_trt_ecr_obj_objet_aerau_1
			"Eep_trt_ecr_obj_objet_aerau_1"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B06
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_lec_obj_cpt_warm_up
			"Eep_dem_lec_obj_cpt_warm_up"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B2D
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_lec_obj_cpt_pan_valid
			"Eep_dem_lec_obj_cpt_pan_valid"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B33
		/end MEASUREMENT
		/begin MEASUREMENT Atu_tcnt1a
			"Atu_tcnt1a"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFFF440
		/end MEASUREMENT
		/begin MEASUREMENT Eep_trt_ecr_obj_pos_pied_leve
			"Eep_trt_ecr_obj_pos_pied_leve"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8ADA
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_lec_obj_pos_pied_leve
			"Eep_dem_lec_obj_pos_pied_leve"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B12
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_lec_obj_pap_mot
			"Eep_dem_lec_obj_pap_mot"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B1B
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_lec_obj_cpt_dem_panne6
			"Eep_dem_lec_obj_cpt_dem_panne6"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B46
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_ecr_obj_cpt_dem_panne1
			"Eep_dem_ecr_obj_cpt_dem_panne1"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AD1
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_ecr_obj_sauv_redepart
			"Eep_dem_ecr_obj_sauv_redepart"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AAC
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_ecr_obj_cpt_panne4
			"Eep_dem_ecr_obj_cpt_panne4"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AB7
		/end MEASUREMENT
		/begin MEASUREMENT Eep_trt_ecr_obj_cpt_warm_up
			"Eep_trt_ecr_obj_cpt_warm_up"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AF5
		/end MEASUREMENT
		/begin MEASUREMENT Eep_defaut_obj_adapt_rich_gpl
			"Eep_defaut_obj_adapt_rich_gpl"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A70
		/end MEASUREMENT
		/begin MEASUREMENT Eep_trt_ecr_obj_objet_aerau_2
			"Eep_trt_ecr_obj_objet_aerau_2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B07
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_lec_obj_sauv_redepart
			"Eep_dem_lec_obj_sauv_redepart"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B1C
		/end MEASUREMENT
		/begin MEASUREMENT Eep_defaut_obj_version
			"Eep_defaut_obj_version"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A75
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_ecr_obj_pap_mot
			"Eep_dem_ecr_obj_pap_mot"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AAB
		/end MEASUREMENT
		/begin MEASUREMENT Atu_tcnt2b
			"Atu_tcnt2b"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFFF602
		/end MEASUREMENT
		/begin MEASUREMENT Atu_tcnt2a
			"Atu_tcnt2a"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFFF600
		/end MEASUREMENT
		/begin MEASUREMENT Eep_trt_ecr_obj_cpt_panne4
			"Eep_trt_ecr_obj_cpt_panne4"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AEF
		/end MEASUREMENT
		/begin MEASUREMENT Atu_tcnt1b
			"Atu_tcnt1b"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFFF442
		/end MEASUREMENT
		/begin MEASUREMENT Eep_defaut_obj_cpt_warm_up
			"Eep_defaut_obj_cpt_warm_up"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A85
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_lec_obj_cpt_warm_up_typ
			"Eep_dem_lec_obj_cpt_warm_up_typ"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B2B
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_ecr_obj_ecritures_eeprom
			"Eep_dem_ecr_obj_ecritures_eeprom"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AA5
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_lec_obj_ecritures_eeprom
			"Eep_dem_lec_obj_ecritures_eeprom"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B15
		/end MEASUREMENT
		/begin MEASUREMENT Eep_trt_ecr_obj_cpt_warm_up_typ
			"Eep_trt_ecr_obj_cpt_warm_up_typ"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AF3
		/end MEASUREMENT
		/begin MEASUREMENT Eep_defaut_obj_ecritures_eeprom
			"Eep_defaut_obj_ecritures_eeprom"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A6D
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_ecr_obj_cpt_warm_up_typ
			"Eep_dem_ecr_obj_cpt_warm_up_typ"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8ABB
		/end MEASUREMENT
		/begin MEASUREMENT Eep_defaut_obj_cpt_warm_up_typ
			"Eep_defaut_obj_cpt_warm_up_typ"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A83
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_lec_obj_cpt_panne4
			"Eep_dem_lec_obj_cpt_panne4"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B27
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_lec_obj_objet_gpl
			"Eep_dem_lec_obj_objet_gpl"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B3A
		/end MEASUREMENT
		/begin MEASUREMENT Eep_defaut_obj_cpt_panne5
			"Eep_defaut_obj_cpt_panne5"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A80
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_ecr_obj_cpt_panne5
			"Eep_dem_ecr_obj_cpt_panne5"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AB8
		/end MEASUREMENT
		/begin MEASUREMENT Eep_trt_ecr_obj_ecritures_eeprom
			"Eep_trt_ecr_obj_ecritures_eeprom"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8ADD
		/end MEASUREMENT
		/begin MEASUREMENT Eep_trt_ecr_obj_dtc_vf_stocke2
			"Eep_trt_ecr_obj_dtc_vf_stocke2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AF7
		/end MEASUREMENT
		/begin MEASUREMENT Eep_defaut_obj_dtc_vf_stocke
			"Eep_defaut_obj_dtc_vf_stocke"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A86
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_ecr_obj_dtc_vf_stocke
			"Eep_dem_ecr_obj_dtc_vf_stocke"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8ABE
		/end MEASUREMENT
		/begin MEASUREMENT Eep_trt_ecr_obj_dtc_vf_stocke
			"Eep_trt_ecr_obj_dtc_vf_stocke"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AF6
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_lec_obj_dtc_vf_stocke
			"Eep_dem_lec_obj_dtc_vf_stocke"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B2E
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_lec_obj_dtc_vf_stocke2
			"Eep_dem_lec_obj_dtc_vf_stocke2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B2F
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_ecr_obj_dtc_vf_stocke2
			"Eep_dem_ecr_obj_dtc_vf_stocke2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8ABF
		/end MEASUREMENT
		/begin MEASUREMENT Eep_defaut_obj_dtc_vf_stocke2
			"Eep_defaut_obj_dtc_vf_stocke2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A87
		/end MEASUREMENT
		/begin MEASUREMENT Eep_trt_ecr_obj_objet_gpl
			"Eep_trt_ecr_obj_objet_gpl"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B02
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_ecr_obj_objet_gpl
			"Eep_dem_ecr_obj_objet_gpl"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8ACA
		/end MEASUREMENT
		/begin MEASUREMENT Eep_defaut_obj_objet_gpl
			"Eep_defaut_obj_objet_gpl"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A92
		/end MEASUREMENT
		/begin MEASUREMENT Eep_defaut_obj_sauve_pw_latch2
			"Eep_defaut_obj_sauve_pw_latch2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A8C
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_ecr_obj_sauve_pw_latch2
			"Eep_dem_ecr_obj_sauve_pw_latch2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AC4
		/end MEASUREMENT
		/begin MEASUREMENT Eep_trt_ecr_obj_sauve_pw_latch2
			"Eep_trt_ecr_obj_sauve_pw_latch2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AFC
		/end MEASUREMENT
		/begin MEASUREMENT Eep_trt_ecr_obj_cpt_panne5
			"Eep_trt_ecr_obj_cpt_panne5"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AF0
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_lec_obj_sauve_pw_latch2
			"Eep_dem_lec_obj_sauve_pw_latch2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B34
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_lec_obj_cpt_panne5
			"Eep_dem_lec_obj_cpt_panne5"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B28
		/end MEASUREMENT
		/begin MEASUREMENT Eep_defaut_obj_pw_down_tlz2
			"Eep_defaut_obj_pw_down_tlz2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A90
		/end MEASUREMENT
		/begin MEASUREMENT Eep_defaut_obj_cpt_panne6
			"Eep_defaut_obj_cpt_panne6"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A81
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_ecr_obj_cpt_panne6
			"Eep_dem_ecr_obj_cpt_panne6"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AB9
		/end MEASUREMENT
		/begin MEASUREMENT Eep_trt_ecr_obj_cpt_panne6
			"Eep_trt_ecr_obj_cpt_panne6"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AF1
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_ecr_obj_cpt_dem_panne4
			"Eep_dem_ecr_obj_cpt_dem_panne4"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AD4
		/end MEASUREMENT
		/begin MEASUREMENT Eep_defaut_obj_cpt_dem_panne1
			"Eep_defaut_obj_cpt_dem_panne1"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A99
		/end MEASUREMENT
		/begin MEASUREMENT Eep_defaut_obj_verlog_skeystd
			"Eep_defaut_obj_verlog_skeystd"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A69
		/end MEASUREMENT
		/begin MEASUREMENT Eep_trt_ecr_obj_cpt_dem_panne3
			"Eep_trt_ecr_obj_cpt_dem_panne3"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B0B
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_lec_obj_verlog_skeystd
			"Eep_dem_lec_obj_verlog_skeystd"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B11
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_ecr_obj_pw_down_tlz2
			"Eep_dem_ecr_obj_pw_down_tlz2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AC8
		/end MEASUREMENT
		/begin MEASUREMENT Eep_trt_ecr_obj_pw_down_tlz2
			"Eep_trt_ecr_obj_pw_down_tlz2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B00
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_ecr_obj_verlog_skeystd
			"Eep_dem_ecr_obj_verlog_skeystd"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AA1
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_lec_obj_pw_down_tlz2
			"Eep_dem_lec_obj_pw_down_tlz2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B38
		/end MEASUREMENT
		/begin MEASUREMENT Eep_defaut_obj_pw_down_tlz3
			"Eep_defaut_obj_pw_down_tlz3"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A91
		/end MEASUREMENT
		/begin MEASUREMENT Eep_trt_ecr_obj_verlog_skeystd
			"Eep_trt_ecr_obj_verlog_skeystd"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AD9
		/end MEASUREMENT
		/begin MEASUREMENT Eep_trt_ecr_obj_cpt_dem_panne1
			"Eep_trt_ecr_obj_cpt_dem_panne1"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B09
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_lec_obj_cpt_dem_panne1
			"Eep_dem_lec_obj_cpt_dem_panne1"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B41
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_ecr_obj_exception_regs
			"Eep_dem_ecr_obj_exception_regs"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8ACD
		/end MEASUREMENT
		/begin MEASUREMENT Eep_defaut_obj_cpt_dem_panne2
			"Eep_defaut_obj_cpt_dem_panne2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A9A
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_ecr_obj_cpt_dem_panne2
			"Eep_dem_ecr_obj_cpt_dem_panne2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AD2
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_lec_obj_cpt_panne7
			"Eep_dem_lec_obj_cpt_panne7"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B2A
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_ecr_obj_pw_down_tlz3
			"Eep_dem_ecr_obj_pw_down_tlz3"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AC9
		/end MEASUREMENT
		/begin MEASUREMENT Eep_defaut_obj_cpt_panne7
			"Eep_defaut_obj_cpt_panne7"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A82
		/end MEASUREMENT
		/begin MEASUREMENT Eep_trt_ecr_obj_cpt_panne7
			"Eep_trt_ecr_obj_cpt_panne7"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AF2
		/end MEASUREMENT
		/begin MEASUREMENT Eep_trt_ecr_obj_divers_dsm
			"Eep_trt_ecr_obj_divers_dsm"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AF8
		/end MEASUREMENT
		/begin MEASUREMENT Eep_defaut_obj_cpt_warm_up_typ2
			"Eep_defaut_obj_cpt_warm_up_typ2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A84
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_ecr_obj_cpt_warm_up_typ2
			"Eep_dem_ecr_obj_cpt_warm_up_typ2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8ABC
		/end MEASUREMENT
		/begin MEASUREMENT Eep_trt_ecr_obj_cpt_warm_up_typ2
			"Eep_trt_ecr_obj_cpt_warm_up_typ2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AF4
		/end MEASUREMENT
		/begin MEASUREMENT Eep_trt_ecr_obj_pw_down_tlz3
			"Eep_trt_ecr_obj_pw_down_tlz3"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B01
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_lec_obj_cpt_warm_up_typ2
			"Eep_dem_lec_obj_cpt_warm_up_typ2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B2C
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_lec_obj_pw_down_tlz3
			"Eep_dem_lec_obj_pw_down_tlz3"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B39
		/end MEASUREMENT
		/begin MEASUREMENT Eep_defaut_obj_cpt_p_val_typ2
			"Eep_defaut_obj_cpt_p_val_typ2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A8A
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_ecr_obj_cpt_p_val_typ2
			"Eep_dem_ecr_obj_cpt_p_val_typ2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AC2
		/end MEASUREMENT
		/begin MEASUREMENT Eep_defaut_obj_divers_dsm
			"Eep_defaut_obj_divers_dsm"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A88
		/end MEASUREMENT
		/begin MEASUREMENT Eep_trt_ecr_obj_cpt_p_val_typ2
			"Eep_trt_ecr_obj_cpt_p_val_typ2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AFA
		/end MEASUREMENT
		/begin MEASUREMENT Eep_defaut_obj_ref_calculateur
			"Eep_defaut_obj_ref_calculateur"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A98
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_lec_obj_cpt_p_val_typ2
			"Eep_dem_lec_obj_cpt_p_val_typ2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B32
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_ecr_obj_cpt_panne7
			"Eep_dem_ecr_obj_cpt_panne7"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8ABA
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_ecr_obj_ref_calculateur
			"Eep_dem_ecr_obj_ref_calculateur"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AD0
		/end MEASUREMENT
		/begin MEASUREMENT Eep_defaut_obj_pw_down_tlz
			"Eep_defaut_obj_pw_down_tlz"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A8F
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_lec_obj_ref_calculateur
			"Eep_dem_lec_obj_ref_calculateur"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B40
		/end MEASUREMENT
		/begin MEASUREMENT Eep_trt_ecr_obj_cpt_dem_panne2
			"Eep_trt_ecr_obj_cpt_dem_panne2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B0A
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_lec_obj_cpt_dem_panne2
			"Eep_dem_lec_obj_cpt_dem_panne2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B42
		/end MEASUREMENT
		/begin MEASUREMENT Eep_trt_ecr_obj_cpt_dem_panne6
			"Eep_trt_ecr_obj_cpt_dem_panne6"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B0E
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_ecr_obj_cpt_dem_panne7
			"Eep_dem_ecr_obj_cpt_dem_panne7"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AD7
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_ecr_obj_energy_igbt
			"Eep_dem_ecr_obj_energy_igbt"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AA9
		/end MEASUREMENT
		/begin MEASUREMENT Eep_trt_ecr_obj_cpt_dem_panne7
			"Eep_trt_ecr_obj_cpt_dem_panne7"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B0F
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_lec_obj_cpt_dem_panne7
			"Eep_dem_lec_obj_cpt_dem_panne7"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B47
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_lec_obj_objet_diag
			"Eep_dem_lec_obj_objet_diag"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B3B
		/end MEASUREMENT
		/begin MEASUREMENT Eep_trt_ecr_obj_objet_diag
			"Eep_trt_ecr_obj_objet_diag"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B03
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_ecr_obj_pw_down_tlz
			"Eep_dem_ecr_obj_pw_down_tlz"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AC7
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_ecr_obj_enregistre_trime
			"Eep_dem_ecr_obj_enregistre_trime"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AD8
		/end MEASUREMENT
		/begin MEASUREMENT Eep_defaut_obj_cpt_dem_panne7
			"Eep_defaut_obj_cpt_dem_panne7"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A9F
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_ecr_obj_cpt_panne1
			"Eep_dem_ecr_obj_cpt_panne1"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AB4
		/end MEASUREMENT
		/begin MEASUREMENT Eep_defaut_obj_objet_diag
			"Eep_defaut_obj_objet_diag"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A93
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_lec_obj_objet_vvt
			"Eep_dem_lec_obj_objet_vvt"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B36
		/end MEASUREMENT
		/begin MEASUREMENT Eep_defaut_obj_cpt_dem_panne3
			"Eep_defaut_obj_cpt_dem_panne3"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A9B
		/end MEASUREMENT
		/begin MEASUREMENT Eep_defaut_obj_objet_aerau_1
			"Eep_defaut_obj_objet_aerau_1"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A96
		/end MEASUREMENT
		/begin MEASUREMENT Eep_defaut_obj_sauve_pw_latch
			"Eep_defaut_obj_sauve_pw_latch"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A7B
		/end MEASUREMENT
		/begin MEASUREMENT Eep_defaut_obj_cpt_dem_panne4
			"Eep_defaut_obj_cpt_dem_panne4"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A9C
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_ecr_obj_sauve_pw_latch
			"Eep_dem_ecr_obj_sauve_pw_latch"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AB3
		/end MEASUREMENT
		/begin MEASUREMENT Eep_trt_ecr_obj_objet_vvt
			"Eep_trt_ecr_obj_objet_vvt"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AFE
		/end MEASUREMENT
		/begin MEASUREMENT Eep_trt_ecr_obj_sauve_pw_latch
			"Eep_trt_ecr_obj_sauve_pw_latch"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AEB
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_ecr_obj_objet_diag
			"Eep_dem_ecr_obj_objet_diag"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8ACB
		/end MEASUREMENT
		/begin MEASUREMENT Eep_defaut_obj_sauv_redepart
			"Eep_defaut_obj_sauv_redepart"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A74
		/end MEASUREMENT
		/begin MEASUREMENT Eep_trt_ecr_obj_reco_cyl
			"Eep_trt_ecr_obj_reco_cyl"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AE6
		/end MEASUREMENT
		/begin MEASUREMENT Eep_defaut_obj_redepart_mouil
			"Eep_defaut_obj_redepart_mouil"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A72
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_ecr_obj_redepart_mouil
			"Eep_dem_ecr_obj_redepart_mouil"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AAA
		/end MEASUREMENT
		/begin MEASUREMENT Eep_trt_ecr_obj_redepart_mouil
			"Eep_trt_ecr_obj_redepart_mouil"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AE2
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_lec_obj_redepart_mouil
			"Eep_dem_lec_obj_redepart_mouil"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B1A
		/end MEASUREMENT
		/begin MEASUREMENT Eep_defaut_obj_pap_mot
			"Eep_defaut_obj_pap_mot"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A73
		/end MEASUREMENT
		/begin MEASUREMENT Eep_defaut_obj_objet_can
			"Eep_defaut_obj_objet_can"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A8D
		/end MEASUREMENT
		/begin MEASUREMENT Eep_trt_ecr_obj_pap_mot
			"Eep_trt_ecr_obj_pap_mot"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AE3
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_lec_obj_divers_dsm
			"Eep_dem_lec_obj_divers_dsm"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B30
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_lec_obj_energy_igbt
			"Eep_dem_lec_obj_energy_igbt"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B19
		/end MEASUREMENT
		/begin MEASUREMENT Eep_defaut_obj_cpt_panne2
			"Eep_defaut_obj_cpt_panne2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A7D
		/end MEASUREMENT
		/begin MEASUREMENT Eep_trt_ecr_obj_sauv_redepart
			"Eep_trt_ecr_obj_sauv_redepart"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AE4
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_ecr_obj_cpt_panne2
			"Eep_dem_ecr_obj_cpt_panne2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AB5
		/end MEASUREMENT
		/begin MEASUREMENT Eep_trt_ecr_obj_cpt_panne2
			"Eep_trt_ecr_obj_cpt_panne2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AED
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_ecr_obj_version
			"Eep_dem_ecr_obj_version"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AAD
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_lec_obj_pw_down_tlz
			"Eep_dem_lec_obj_pw_down_tlz"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B37
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_lec_obj_cpt_panne2
			"Eep_dem_lec_obj_cpt_panne2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B25
		/end MEASUREMENT
		/begin MEASUREMENT Eep_defaut_obj_cpt_panne3
			"Eep_defaut_obj_cpt_panne3"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A7E
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_lec_obj_cpt_p_val_typ
			"Eep_dem_lec_obj_cpt_p_val_typ"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B31
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_lec_obj_eepr_correc_trz
			"Eep_dem_lec_obj_eepr_correc_trz"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B16
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_ecr_obj_cpt_panne3
			"Eep_dem_ecr_obj_cpt_panne3"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AB6
		/end MEASUREMENT
		/begin MEASUREMENT Eep_trt_ecr_obj_cpt_panne3
			"Eep_trt_ecr_obj_cpt_panne3"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AEE
		/end MEASUREMENT
		/begin MEASUREMENT Eep_defaut_obj_dpalt
			"Eep_defaut_obj_dpalt"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A6B
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_ecr_obj_dpalt
			"Eep_dem_ecr_obj_dpalt"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AA3
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_lec_obj_sauve_pw_latch
			"Eep_dem_lec_obj_sauve_pw_latch"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B23
		/end MEASUREMENT
		/begin MEASUREMENT Eep_trt_ecr_obj_dpalt
			"Eep_trt_ecr_obj_dpalt"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8ADB
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_lec_obj_dpalt
			"Eep_dem_lec_obj_dpalt"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B13
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_ecr_obj_adapt_richesse
			"Eep_dem_ecr_obj_adapt_richesse"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AAF
		/end MEASUREMENT
		/begin MEASUREMENT Eep_defaut_obj_calage_verrou
			"Eep_defaut_obj_calage_verrou"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A6C
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_ecr_obj_calage_verrou
			"Eep_dem_ecr_obj_calage_verrou"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AA4
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_lec_obj_exception_regs
			"Eep_dem_lec_obj_exception_regs"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B3D
		/end MEASUREMENT
		/begin MEASUREMENT Eep_trt_ecr_obj_exception_regs
			"Eep_trt_ecr_obj_exception_regs"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B05
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_lec_obj_adapt_richesse
			"Eep_dem_lec_obj_adapt_richesse"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B1F
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_lec_obj_cpt_dem_panne3
			"Eep_dem_lec_obj_cpt_dem_panne3"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B43
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_lec_obj_cpt_panne6
			"Eep_dem_lec_obj_cpt_panne6"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B29
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_lec_obj_calage_verrou
			"Eep_dem_lec_obj_calage_verrou"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B14
		/end MEASUREMENT
		/begin MEASUREMENT Eep_defaut_obj_eepr_correc_trz
			"Eep_defaut_obj_eepr_correc_trz"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A6E
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_ecr_obj_diag_panne_eta
			"Eep_dem_ecr_obj_diag_panne_eta"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AB0
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_ecr_obj_cpt_pan_valid
			"Eep_dem_ecr_obj_cpt_pan_valid"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AC3
		/end MEASUREMENT
		/begin MEASUREMENT Eep_defaut_obj_enregistre_trime
			"Eep_defaut_obj_enregistre_trime"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AA0
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_ecr_obj_freeze_frame
			"Eep_dem_ecr_obj_freeze_frame"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AA7
		/end MEASUREMENT
		/begin MEASUREMENT Eep_trt_ecr_obj_freeze_frame
			"Eep_trt_ecr_obj_freeze_frame"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8ADF
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_lec_obj_freeze_frame
			"Eep_dem_lec_obj_freeze_frame"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B17
		/end MEASUREMENT
		/begin MEASUREMENT Eep_defaut_obj_energy_igbt
			"Eep_defaut_obj_energy_igbt"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A71
		/end MEASUREMENT
		/begin MEASUREMENT Eep_defaut_obj_marqueur
			"Eep_defaut_obj_marqueur"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A79
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_ecr_obj_marqueur
			"Eep_dem_ecr_obj_marqueur"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AB1
		/end MEASUREMENT
		/begin MEASUREMENT Eep_defaut_obj_adapt_richesse
			"Eep_defaut_obj_adapt_richesse"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A77
		/end MEASUREMENT
		/begin MEASUREMENT Eep_trt_ecr_obj_energy_igbt
			"Eep_trt_ecr_obj_energy_igbt"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AE1
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_ecr_obj_eepr_correc_trz
			"Eep_dem_ecr_obj_eepr_correc_trz"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AA6
		/end MEASUREMENT
		/begin MEASUREMENT Eep_trt_ecr_obj_pw_down_tlz
			"Eep_trt_ecr_obj_pw_down_tlz"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AFF
		/end MEASUREMENT
		/begin MEASUREMENT Eep_defaut_obj_verlog_skey
			"Eep_defaut_obj_verlog_skey"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A94
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_ecr_obj_reco_cyl
			"Eep_dem_ecr_obj_reco_cyl"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AAE
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_lec_obj_verlog
			"Eep_dem_lec_obj_verlog"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B22
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_ecr_obj_objet_can
			"Eep_dem_ecr_obj_objet_can"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AC5
		/end MEASUREMENT
		/begin MEASUREMENT Eep_trt_ecr_obj_objet_can
			"Eep_trt_ecr_obj_objet_can"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AFD
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_ecr_obj_verlog_skey
			"Eep_dem_ecr_obj_verlog_skey"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8ACC
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_ecr_obj_verlog
			"Eep_dem_ecr_obj_verlog"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AB2
		/end MEASUREMENT
		/begin MEASUREMENT Eep_defaut_obj_cpt_panne1
			"Eep_defaut_obj_cpt_panne1"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A7C
		/end MEASUREMENT
		/begin MEASUREMENT Eep_defaut_obj_verlog
			"Eep_defaut_obj_verlog"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A7A
		/end MEASUREMENT
		/begin MEASUREMENT Eep_trt_ecr_obj_cpt_panne1
			"Eep_trt_ecr_obj_cpt_panne1"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AEC
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_lec_obj_cpt_panne1
			"Eep_dem_lec_obj_cpt_panne1"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B24
		/end MEASUREMENT
		/begin MEASUREMENT Eep_trt_ecr_obj_verlog_skey
			"Eep_trt_ecr_obj_verlog_skey"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B04
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_lec_obj_verlog_skey
			"Eep_dem_lec_obj_verlog_skey"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B3C
		/end MEASUREMENT
		/begin MEASUREMENT Eep_trt_ecr_obj_cpt_dem_panne5
			"Eep_trt_ecr_obj_cpt_dem_panne5"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B0D
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_lec_obj_objet_can
			"Eep_dem_lec_obj_objet_can"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B35
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_ecr_obj_cpt_dem_panne5
			"Eep_dem_ecr_obj_cpt_dem_panne5"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AD5
		/end MEASUREMENT
		/begin MEASUREMENT Eep_defaut_obj_cpt_pan_valid
			"Eep_defaut_obj_cpt_pan_valid"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A8B
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_ecr_obj_divers_dsm
			"Eep_dem_ecr_obj_divers_dsm"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AC0
		/end MEASUREMENT
		/begin MEASUREMENT Eep_trt_ecr_obj_ref_calculateur
			"Eep_trt_ecr_obj_ref_calculateur"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B08
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_lec_obj_cpt_dem_panne5
			"Eep_dem_lec_obj_cpt_dem_panne5"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B45
		/end MEASUREMENT
		/begin MEASUREMENT Eep_defaut_obj_cpt_dem_panne5
			"Eep_defaut_obj_cpt_dem_panne5"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A9D
		/end MEASUREMENT
		/begin MEASUREMENT Eep_trt_ecr_obj_adapt_richesse
			"Eep_trt_ecr_obj_adapt_richesse"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AE7
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_lec_obj_cpt_dem_panne4
			"Eep_dem_lec_obj_cpt_dem_panne4"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B44
		/end MEASUREMENT
		/begin MEASUREMENT Eep_trt_ecr_obj_verlog
			"Eep_trt_ecr_obj_verlog"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AEA
		/end MEASUREMENT
		/begin MEASUREMENT Eep_defaut_obj_diag_panne_eta
			"Eep_defaut_obj_diag_panne_eta"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A78
		/end MEASUREMENT
		/begin MEASUREMENT Eep_trt_ecr_obj_cpt_dem_panne4
			"Eep_trt_ecr_obj_cpt_dem_panne4"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B0C
		/end MEASUREMENT
		/begin MEASUREMENT Eep_trt_ecr_obj_diag_panne_eta
			"Eep_trt_ecr_obj_diag_panne_eta"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AE8
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_lec_obj_diag_panne_eta
			"Eep_dem_lec_obj_diag_panne_eta"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B20
		/end MEASUREMENT
		/begin MEASUREMENT Eep_defaut_obj_objet_vvt
			"Eep_defaut_obj_objet_vvt"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A8E
		/end MEASUREMENT
		/begin MEASUREMENT Eep_defaut_obj_pos_pied_leve
			"Eep_defaut_obj_pos_pied_leve"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A6A
		/end MEASUREMENT
		/begin MEASUREMENT Eep_trt_ecr_obj_marqueur
			"Eep_trt_ecr_obj_marqueur"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AE9
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_lec_obj_marqueur
			"Eep_dem_lec_obj_marqueur"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B21
		/end MEASUREMENT
		/begin MEASUREMENT Eep_defaut_obj_cpt_p_val_typ
			"Eep_defaut_obj_cpt_p_val_typ"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A89
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_ecr_obj_pos_pied_leve
			"Eep_dem_ecr_obj_pos_pied_leve"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AA2
		/end MEASUREMENT
		/begin MEASUREMENT Eep_defaut_obj_cpt_panne4
			"Eep_defaut_obj_cpt_panne4"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A7F
		/end MEASUREMENT
		/begin MEASUREMENT Eep_trt_ecr_obj_enregistre_trime
			"Eep_trt_ecr_obj_enregistre_trime"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B10
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_lec_obj_cpt_panne3
			"Eep_dem_lec_obj_cpt_panne3"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B26
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_ecr_obj_objet_vvt
			"Eep_dem_ecr_obj_objet_vvt"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AC6
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_ecr_obj_cpt_p_val_typ
			"Eep_dem_ecr_obj_cpt_p_val_typ"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AC1
		/end MEASUREMENT
		/begin MEASUREMENT Eep_trt_ecr_obj_cpt_p_val_typ
			"Eep_trt_ecr_obj_cpt_p_val_typ"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8AF9
		/end MEASUREMENT
		/begin MEASUREMENT Eep_dem_lec_obj_enregistre_trime
			"Eep_dem_lec_obj_enregistre_trime"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8B48
		/end MEASUREMENT
		/begin MEASUREMENT _calibration_recopie_demande
			"_CALIBRATION_RECOPIE_DEMANDE"
			UWORD
			F_26940_p0_1
			2
			2
			0
			1765512900
			ECU_ADDRESS 0x100040
		/end MEASUREMENT
		/begin MEASUREMENT Acquitter
			"Acquitter"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF73EC
		/end MEASUREMENT
		/begin MEASUREMENT Activ_pompe_air
			"ACTIV_POMPE_AIR"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x4
			ECU_ADDRESS 0xFFFF84B6
		/end MEASUREMENT
		/begin MEASUREMENT Activation_correction_
			"ACTIVATION_CORRECTION"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x2
			ECU_ADDRESS 0xFFFF8324
		/end MEASUREMENT
		/begin MEASUREMENT Active_compt_nr_instab
			"Active_compt_nr_instab"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF836A
		/end MEASUREMENT
		/begin MEASUREMENT Active_inh_mcw_hseq_
			"Active_inh_mcw_hseq"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF823C
		/end MEASUREMENT
		/begin MEASUREMENT Address_transmit_flag
			"Address_transmit_flag"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF82B0
		/end MEASUREMENT
		/begin MEASUREMENT Adgaincalc_
			"Facteur_adaptatif_calcule"
			UBYTE
			F_0v4_p0_2
			2
			2
			0
			102
			ECU_ADDRESS 0xFFFF7AA6
		/end MEASUREMENT
		/begin MEASUREMENT Adresse_eeprom
			"Adresse_eeprom"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7888
		/end MEASUREMENT
		/begin MEASUREMENT Adv_dyn_cor_cond
			"Adv_dyn_cor_cond"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF78B0
		/end MEASUREMENT
		/begin MEASUREMENT Adv_dyn_ct_pdl
			"Adv_dyn_ct_pdl"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF78B1
		/end MEASUREMENT
		/begin MEASUREMENT Adzerocalc_
			"Offset_adaptatif_calcule"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7AAB
		/end MEASUREMENT
		/begin MEASUREMENT Adzonedet_
			"Numero_zone_determine"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7AAA
		/end MEASUREMENT
		/begin MEASUREMENT Afm_mass_voltage_result_ad_conv
			"Afm_mass_voltage_result_ad_conv"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFFF80C
		/end MEASUREMENT
		/begin MEASUREMENT Alternator_selection
			"Alternator_selection"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6EB8
		/end MEASUREMENT
		/begin MEASUREMENT Amorcage_rampe_gaz
			"AMORCAGE_RAMPE_GAZ"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x2
			ECU_ADDRESS 0xFFFF7968
		/end MEASUREMENT
		/begin MEASUREMENT Amorcage_rampe_gaz_termine
			"AMORCAGE_RAMPE_GAZ_TERMINE"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x4
			ECU_ADDRESS 0xFFFF7968
		/end MEASUREMENT
		/begin MEASUREMENT Ant_deb_gmv1_
			"ANT_DEB_GMV1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x40
			ECU_ADDRESS 0xFFFF792A
		/end MEASUREMENT
		/begin MEASUREMENT Ant_emb_gmv1_
			"ANT_EMB_GMV1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x20
			ECU_ADDRESS 0xFFFF792A
		/end MEASUREMENT
		/begin MEASUREMENT APRES_STRATEGIE
			"APRES_STRATEGIE"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x8
			ECU_ADDRESS 0xFFFF6BD0
		/end MEASUREMENT
		/begin MEASUREMENT Aps_1_raw_memo1_
			"Aps_1_raw_memo1"
			UWORD
			F_0v09765_p0_3
			2
			2
			0
			6399.49275
			ECU_ADDRESS 0xFFFF76F2
		/end MEASUREMENT
		/begin MEASUREMENT Aps_1_raw_memo2_
			"Aps_1_raw_memo2"
			UWORD
			F_0v09765_p0_3
			2
			2
			0
			6399.49275
			ECU_ADDRESS 0xFFFF76F4
		/end MEASUREMENT
		/begin MEASUREMENT Aps_1_sensing_default_diag_inh_
			"Aps_1_sensing_default_diag_inh"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7BCC
		/end MEASUREMENT
		/begin MEASUREMENT Aps_2_raw_memo1_
			"Aps_2_raw_memo1"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF76F6
		/end MEASUREMENT
		/begin MEASUREMENT Aps_2_raw_memo2_
			"Aps_2_raw_memo2"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF76F8
		/end MEASUREMENT
		/begin MEASUREMENT Aps_2_raw_position_mcp_mcp_
			"Aps_2_raw_position_mcp_mcp"
			UBYTE
			F_0v390625_p0_4
			2
			2
			0
			99.609375
			ECU_ADDRESS 0xFFFF7688
		/end MEASUREMENT
		/begin MEASUREMENT Aps_2_raw_position_mcw_mcp_
			"Aps_2_raw_position_mcw_mcp"
			UBYTE
			F_0v390625_p0_4
			2
			2
			0
			99.609375
			ECU_ADDRESS 0xFFFF8260
		/end MEASUREMENT
		/begin MEASUREMENT Aps_2_sensing_default_diag_inh_
			"Aps_2_sensing_default_diag_inh"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7BCD
		/end MEASUREMENT
		/begin MEASUREMENT Aps_coh_filt_abs_error_
			"Aps_coh_filt_abs_error"
			UWORD
			F_0v097656_p0_5
			2
			2
			0
			6399.88596
			ECU_ADDRESS 0xFFFF76FA
		/end MEASUREMENT
		/begin MEASUREMENT Aps_position_tolerance_
			"Aps_position_tolerance"
			UWORD
			F_0v097656_p0_5
			2
			2
			0
			6399.88596
			ECU_ADDRESS 0xFFFF76FC
		/end MEASUREMENT
		/begin MEASUREMENT Aps_sensing_coh_diag_inh_
			"Aps_sensing_coh_diag_inh"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7BCE
		/end MEASUREMENT
		/begin MEASUREMENT Aps_sensing_coh_failure_inh
			"Aps_sensing_coh_failure_inh"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7BCF
		/end MEASUREMENT
		/begin MEASUREMENT Armement_tempo_couple_acc
			"Armement_tempo_couple_acc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8160
		/end MEASUREMENT
		/begin MEASUREMENT Arret_gmv1_
			"ARRET_GMV1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x4
			ECU_ADDRESS 0xFFFF792A
		/end MEASUREMENT
		/begin MEASUREMENT Atabsdof
			"Flg_at_abs_diag_off"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF73C8
		/end MEASUREMENT
		/begin MEASUREMENT Att_cond_coup_
			"Attente_de_condition_coupure"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6D74
		/end MEASUREMENT
		/begin MEASUREMENT Attente_amorcage_rampe_gaz
			"ATTENTE_AMORCAGE_RAMPE_GAZ"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7968
		/end MEASUREMENT
		/begin MEASUREMENT Attente_check_springs
			"ATTENTE_CHECK_SPRINGS"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x2
			ECU_ADDRESS 0xFFFF7695
		/end MEASUREMENT
		/begin MEASUREMENT Attente_corr_cliq_
			"ATTENTE_CORR_CLIQ"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF833E
		/end MEASUREMENT
		/begin MEASUREMENT ATTENTE_DETROMPAGE
			"ATTENTE_DETROMPAGE"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6BD0
		/end MEASUREMENT
		/begin MEASUREMENT Attente_premier_message_
			"Attente_premier_message"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF75B0
		/end MEASUREMENT
		/begin MEASUREMENT Attente_reponse_passerelle
			"ATTENTE_REPONSE_PASSERELLE"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x10
			ECU_ADDRESS 0xFFFF75FE
		/end MEASUREMENT
		/begin MEASUREMENT Attente_surpression_
			"ATTENTE_SURPRESSION"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF84AF
		/end MEASUREMENT
		/begin MEASUREMENT Autforpielev_
			"Auto_forcage_pied_leve"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7FB0
		/end MEASUREMENT
		/begin MEASUREMENT Authreq
			"Demande_authentification"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6BE4
		/end MEASUREMENT
		/begin MEASUREMENT Auto_comm_chauf_sonde_amont_
			"Auto_comm_chauf_sonde_amont"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7E8C
		/end MEASUREMENT
		/begin MEASUREMENT Auto_comm_chauf_sonde_aval_
			"Auto_comm_chauf_sonde_aval"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7E8D
		/end MEASUREMENT
		/begin MEASUREMENT Auto_incr_temps_chauff_so2dw_
			"Auto_incr_temps_chauff_so2dw"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7E8E
		/end MEASUREMENT
		/begin MEASUREMENT Automate_communication_
			"Automate_communication"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF75D2
		/end MEASUREMENT
		/begin MEASUREMENT Automate_transfert_micros
			"Automate_transfert_micros"
			UBYTE
			Automate_transfert_micros_conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF8261
		/end MEASUREMENT
		/begin MEASUREMENT Autorisation_diag_par_relais
			"Autorisation_diag_par_relais"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF781C
		/end MEASUREMENT
		/begin MEASUREMENT Autorisation_mem_rco_theorique_
			"Autorisation_mem_rco_theorique"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF79B0
		/end MEASUREMENT
		/begin MEASUREMENT Autorisation_pwm_adm
			"Autorisation_pwm_adm"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8510
		/end MEASUREMENT
		/begin MEASUREMENT Autorise_acqui_pression_phase_
			"Autorise_acqui_pression_phase"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8050
		/end MEASUREMENT
		/begin MEASUREMENT Autorise_corr_derivee_
			"Autorise_corr_derivee"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF79B1
		/end MEASUREMENT
		/begin MEASUREMENT Autorise_coupure_relais_pompe
			"Autorise_coupure_relais_pompe"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8140
		/end MEASUREMENT
		/begin MEASUREMENT Autorise_coupure_relais_pwrl
			"Autorise_coupure_relais_pwrl"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8141
		/end MEASUREMENT
		/begin MEASUREMENT Autorise_detection_clq
			"Autorise_detection_clq"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF746C
		/end MEASUREMENT
		/begin MEASUREMENT Av_dyn_hors_
			"AV_DYN_HORS"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x8
			ECU_ADDRESS 0xFFFF6D9B
		/end MEASUREMENT
		/begin MEASUREMENT Avance_disponible_
			"Avance_disponible"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6DF0
		/end MEASUREMENT
		/begin MEASUREMENT Avance_mini
			"Avance_mini"
			UBYTE
			Avance_mini_conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF7A20
		/end MEASUREMENT
		/begin MEASUREMENT Avance_mini_correction
			"AVANCE_MINI_CORRECTION"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A20
		/end MEASUREMENT
		/begin MEASUREMENT Avance_mini_lissage
			"AVANCE_MINI_LISSAGE"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x2
			ECU_ADDRESS 0xFFFF7A20
		/end MEASUREMENT
		/begin MEASUREMENT Avant_pompe_air
			"AVANT_POMPE_AIR"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x2
			ECU_ADDRESS 0xFFFF84B6
		/end MEASUREMENT
		/begin MEASUREMENT Avdyn_condition_regime
			"Avdyn_condition_regime"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF78C1
		/end MEASUREMENT
		/begin MEASUREMENT Battery_voltage_correction_
			"Battery_voltage_correction"
			UWORD
			F_0v0032_p0_8
			2
			2
			0
			209.712
			ECU_ADDRESS 0xFFFF7B1A
		/end MEASUREMENT
		/begin MEASUREMENT Bmtimoy
			"Temps_inj_banc_filtre"
			UWORD
			F_0v0032_p0_8
			2
			2
			0
			209.712
			ECU_ADDRESS 0xFFFF7B1E
		/end MEASUREMENT
		/begin MEASUREMENT Bob_a_c_debut_diag
			"BOB_A_C_DEBUT_DIAG"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E0C
		/end MEASUREMENT
		/begin MEASUREMENT Bob_a_c_diag_2nd_point
			"BOB_A_C_DIAG_2ND_POINT"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x8
			ECU_ADDRESS 0xFFFF6E0C
		/end MEASUREMENT
		/begin MEASUREMENT Bob_a_c_diag_fini
			"BOB_A_C_DIAG_FINI"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x10
			ECU_ADDRESS 0xFFFF6E0C
		/end MEASUREMENT
		/begin MEASUREMENT Bob_a_c_prog_1er_point
			"BOB_A_C_PROG_1ER_POINT"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x2
			ECU_ADDRESS 0xFFFF6E0C
		/end MEASUREMENT
		/begin MEASUREMENT Bob_a_c_prog_2nd_point
			"BOB_A_C_PROG_2ND_POINT"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x4
			ECU_ADDRESS 0xFFFF6E0C
		/end MEASUREMENT
		/begin MEASUREMENT Bob_b_d_debut_diag
			"BOB_B_D_DEBUT_DIAG"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E0D
		/end MEASUREMENT
		/begin MEASUREMENT Bob_b_d_diag_2nd_point
			"BOB_B_D_DIAG_2ND_POINT"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x8
			ECU_ADDRESS 0xFFFF6E0D
		/end MEASUREMENT
		/begin MEASUREMENT Bob_b_d_diag_fini
			"BOB_B_D_DIAG_FINI"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x10
			ECU_ADDRESS 0xFFFF6E0D
		/end MEASUREMENT
		/begin MEASUREMENT Bob_b_d_prog_1er_point
			"BOB_B_D_PROG_1ER_POINT"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x2
			ECU_ADDRESS 0xFFFF6E0D
		/end MEASUREMENT
		/begin MEASUREMENT Bob_b_d_prog_2nd_point
			"BOB_B_D_PROG_2ND_POINT"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x4
			ECU_ADDRESS 0xFFFF6E0D
		/end MEASUREMENT
		/begin MEASUREMENT Bobine_a_c_acquis_pente_valides
			"Bobine_a_c_acquis_pente_valides"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6DF1
		/end MEASUREMENT
		/begin MEASUREMENT Bobine_a_c_diag_ccbat_en_cours
			"Bobine_a_c_diag_ccbat_en_cours"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6DF2
		/end MEASUREMENT
		/begin MEASUREMENT Bobine_b_d_acquis_pente_valides
			"Bobine_b_d_acquis_pente_valides"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6DF3
		/end MEASUREMENT
		/begin MEASUREMENT Bobine_b_d_diag_ccbat_en_cours
			"Bobine_b_d_diag_ccbat_en_cours"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6DF4
		/end MEASUREMENT
		/begin MEASUREMENT Bobines_diag_ccbat_conv_dem_ac
			"Bobines_diag_ccbat_conv_dem_ac"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6DF5
		/end MEASUREMENT
		/begin MEASUREMENT Bobines_diag_ccbat_conv_dem_bd
			"Bobines_diag_ccbat_conv_dem_bd"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6DF6
		/end MEASUREMENT
		/begin MEASUREMENT Bools_etat_moteur
			"Bools_etat_moteur"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8608
		/end MEASUREMENT
		/begin MEASUREMENT Bools_redepart
			"Bools_redepart"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8653
		/end MEASUREMENT
		/begin MEASUREMENT Bruit_moyen_cyl_init_
			"Bruit_moyen_cyl_init"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7477
		/end MEASUREMENT
		/begin MEASUREMENT Calcul_dpalt_autorise_
			"Calcul_dpalt_autorise"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7EF4
		/end MEASUREMENT
		/begin MEASUREMENT Calcul_interp_av_pda_
			"Calcul_interp_av_pda"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6D75
		/end MEASUREMENT
		/begin MEASUREMENT Calcul_position_pap_rel_prec
			"Calcul_position_pap_rel_prec"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF848C
		/end MEASUREMENT
		/begin MEASUREMENT Calcul_pression
			"Calcul_pression"
			UWORD
			F_1_p0_9
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF802A
		/end MEASUREMENT
		/begin MEASUREMENT Calcul_rapport_autorise_
			"Calcul_rapport_autorise"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8284
		/end MEASUREMENT
		/begin MEASUREMENT Calcul_reat_nat_cpl_en_cours
			"Calcul_reat_nat_cpl_en_cours"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6D76
		/end MEASUREMENT
		/begin MEASUREMENT Calcul_reat_sw_cpl_en_cours
			"Calcul_reat_sw_cpl_en_cours"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6D77
		/end MEASUREMENT
		/begin MEASUREMENT Calcul_vitesse_autorise_
			"Calcul_vitesse_autorise"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8285
		/end MEASUREMENT
		/begin MEASUREMENT Calibration_offset
			"Calibration_offset"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0x0
		/end MEASUREMENT
		/begin MEASUREMENT Can_expected_segment_number
			"Can_expected_segment_number"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF735C
		/end MEASUREMENT
		/begin MEASUREMENT Can_rx_dtool_to_all_frame_len
			"Can_rx_dtool_to_all_frame_len"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7360
		/end MEASUREMENT
		/begin MEASUREMENT Can_rx_event
			"Can_rx_event"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6EC6
		/end MEASUREMENT
		/begin MEASUREMENT Can_rx_flow_control_type
			"Can_rx_flow_control_type"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6EC7
		/end MEASUREMENT
		/begin MEASUREMENT Can_rx_frame_type
			"Can_rx_frame_type"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6ED0
		/end MEASUREMENT
		/begin MEASUREMENT Can_rx_last_frame
			"Can_rx_last_frame"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7364
		/end MEASUREMENT
		/begin MEASUREMENT Can_rx_message_index
			"Can_rx_message_index"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7366
		/end MEASUREMENT
		/begin MEASUREMENT Can_rx_message_len
			"Can_rx_message_len"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7368
		/end MEASUREMENT
		/begin MEASUREMENT Can_rx_message_source
			"Can_rx_message_source"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF70D1
		/end MEASUREMENT
		/begin MEASUREMENT Can_rx_put_position
			"Can_rx_put_position"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF736A
		/end MEASUREMENT
		/begin MEASUREMENT Can_rx_segment_number
			"Can_rx_segment_number"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF70D2
		/end MEASUREMENT
		/begin MEASUREMENT Can_rx_state
			"Can_rx_state"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF70D3
		/end MEASUREMENT
		/begin MEASUREMENT Can_rx_timer
			"Can_rx_timer"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF70D4
		/end MEASUREMENT
		/begin MEASUREMENT Can_rx_timer_value
			"Can_rx_timer_value"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF736C
		/end MEASUREMENT
		/begin MEASUREMENT Can_tx_block_size
			"Can_tx_block_size"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF736E
		/end MEASUREMENT
		/begin MEASUREMENT Can_tx_change_comm_params
			"Can_tx_change_comm_params"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF70D5
		/end MEASUREMENT
		/begin MEASUREMENT Can_tx_event
			"Can_tx_event"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF70D6
		/end MEASUREMENT
		/begin MEASUREMENT Can_tx_frame_counter
			"Can_tx_frame_counter"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7370
		/end MEASUREMENT
		/begin MEASUREMENT Can_tx_frame_type
			"Can_tx_frame_type"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF70DF
		/end MEASUREMENT
		/begin MEASUREMENT Can_tx_message_index
			"Can_tx_message_index"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7372
		/end MEASUREMENT
		/begin MEASUREMENT Can_tx_message_len
			"Can_tx_message_len"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7374
		/end MEASUREMENT
		/begin MEASUREMENT Can_tx_segment_number
			"Can_tx_segment_number"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF72E0
		/end MEASUREMENT
		/begin MEASUREMENT Can_tx_state
			"Can_tx_state"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF72E1
		/end MEASUREMENT
		/begin MEASUREMENT Can_tx_stmin
			"Can_tx_stmin"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF72E2
		/end MEASUREMENT
		/begin MEASUREMENT Can_tx_timer
			"Can_tx_timer"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF72E3
		/end MEASUREMENT
		/begin MEASUREMENT Can_tx_timer_value
			"Can_tx_timer_value"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7376
		/end MEASUREMENT
		/begin MEASUREMENT Capt_signal_vit_msb_
			"Capt_signal_vit_msb"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7C10
		/end MEASUREMENT
		/begin MEASUREMENT Cc_acc_couple_tempo
			"Cc_acc_couple_tempo"
			UBYTE
			F_16_p0_10
			2
			2
			0
			4080
			ECU_ADDRESS 0xFFFF81BB
		/end MEASUREMENT
		/begin MEASUREMENT Cc_control_switch_result_ad_conv
			"Cc_control_switch_result_ad_conv"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFFF80E
		/end MEASUREMENT
		/begin MEASUREMENT Cc_distance_vehicle_option
			"Cc_distance_vehicle_option"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E6C
		/end MEASUREMENT
		/begin MEASUREMENT Cdcalavd_
			"Cond_calc_av_dyn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6D78
		/end MEASUREMENT
		/begin MEASUREMENT Cdcalavdu_
			"Cond_calc_av_dyn_uni"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6D7A
		/end MEASUREMENT
		/begin MEASUREMENT Cdcnxuce
			"Autori_detect_conex_uce_can"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E50
		/end MEASUREMENT
		/begin MEASUREMENT Changement_rapport_bv_i_1_
			"Changement_rapport_bv_i_1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E51
		/end MEASUREMENT
		/begin MEASUREMENT Chauf_gpl_current_voltage
			"Chauf_gpl_current_voltage"
			UWORD
			F_4v8828125_p0_11
			2
			2
			0
			319995.1172
			ECU_ADDRESS 0xFFFF7ED4
		/end MEASUREMENT
		/begin MEASUREMENT Chauf_gpl_current_voltage_filt
			"Chauf_gpl_current_voltage_filt"
			UWORD
			F_4v8828125_p0_11
			2
			2
			0
			319995.1172
			ECU_ADDRESS 0xFFFF7ED6
		/end MEASUREMENT
		/begin MEASUREMENT Chauf_gpl_current_voltage_plus
			"Chauf_gpl_current_voltage_plus"
			UWORD
			F_4v8828125_p0_11
			2
			2
			0
			319995.1172
			ECU_ADDRESS 0xFFFF7ED8
		/end MEASUREMENT
		/begin MEASUREMENT Chauf_gpl_moins_result_ad_conv_
			"Chauf_gpl_moins_result_ad_conv"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFFF834
		/end MEASUREMENT
		/begin MEASUREMENT Chauf_gpl_plus_result_ad_conv_
			"Chauf_gpl_plus_result_ad_conv"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFFF832
		/end MEASUREMENT
		/begin MEASUREMENT Chauf_gpl_running_compteur
			"Chauf_gpl_running_compteur"
			UBYTE
			F_4v096_p0_12
			2
			2
			0
			1044.48
			ECU_ADDRESS 0xFFFF7EB4
		/end MEASUREMENT
		/begin MEASUREMENT Chauf_gpl_voltage_plus_filt
			"Chauf_gpl_voltage_plus_filt"
			UWORD
			F_4v8828125_p0_11
			2
			2
			0
			319995.1172
			ECU_ADDRESS 0xFFFF7EDA
		/end MEASUREMENT
		/begin MEASUREMENT Check_lh_bas
			"CHECK_LH_BAS"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x8
			ECU_ADDRESS 0xFFFF7695
		/end MEASUREMENT
		/begin MEASUREMENT Check_lh_haut
			"CHECK_LH_HAUT"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x4
			ECU_ADDRESS 0xFFFF7695
		/end MEASUREMENT
		/begin MEASUREMENT Checksum_emission
			"Checksum_emission"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8262
		/end MEASUREMENT
		/begin MEASUREMENT Checksum_message_pile_
			"Checksum_message_pile"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF75D3
		/end MEASUREMENT
		/begin MEASUREMENT Checksum_reception
			"Checksum_reception"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8263
		/end MEASUREMENT
		/begin MEASUREMENT Checksum_rom_mcp
			"Checksum_rom_mcp"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF8278
		/end MEASUREMENT
		/begin MEASUREMENT Checksum_rom_mcw
			"Checksum_rom_mcw"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF827A
		/end MEASUREMENT
		/begin MEASUREMENT Cle_appli
			"Cle_appli"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF75B1
		/end MEASUREMENT
		/begin MEASUREMENT Cmd_appli_cp
			"Cmd_appli_cp"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF781D
		/end MEASUREMENT
		/begin MEASUREMENT Cmd_appli_ev_iae
			"Cmd_appli_ev_iae"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF781E
		/end MEASUREMENT
		/begin MEASUREMENT Cmd_appli_ptc_rov
			"Cmd_appli_ptc_rov"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF781F
		/end MEASUREMENT
		/begin MEASUREMENT Cmd_appli_wgc
			"Cmd_appli_wgc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7820
		/end MEASUREMENT
		/begin MEASUREMENT Cmd_appli_wpmp
			"Cmd_appli_wpmp"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7821
		/end MEASUREMENT
		/begin MEASUREMENT Cmd_chauf_gpl_appli
			"Cmd_chauf_gpl_appli"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7E8F
		/end MEASUREMENT
		/begin MEASUREMENT Cndrgvsc
			"Condition_regime_vsc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E52
		/end MEASUREMENT
		/begin MEASUREMENT Cntaren2
			"Duree_maintien_retrait_cme_eff"
			UBYTE
			F_1_p0_53
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6D9A
		/end MEASUREMENT
		/begin MEASUREMENT Cntares2
			"Duree_maintien_effectuee_cme_sw"
			UBYTE
			F_1_p0_53
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6D99
		/end MEASUREMENT
		/begin MEASUREMENT Cntbusof
			"C_busoff"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6EBC
		/end MEASUREMENT
		/begin MEASUREMENT Cntmute
			"C_mute"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6EBD
		/end MEASUREMENT
		/begin MEASUREMENT Cntobdmx
			"Compt_date_emis_obd_can"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF72E4
		/end MEASUREMENT
		/begin MEASUREMENT Cntpalla
			"Cnt_pannes_alla"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF6E2E
		/end MEASUREMENT
		/begin MEASUREMENT Cntpallb
			"Cnt_pannes_allb"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF6E30
		/end MEASUREMENT
		/begin MEASUREMENT Cnttxnok
			"Compteur_can_txnok"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF72E9
		/end MEASUREMENT
		/begin MEASUREMENT Cnxuce1
			"Etat_connexion_uce_1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E57
		/end MEASUREMENT
		/begin MEASUREMENT Cnxuce10
			"Etat_connexion_uce_10"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E58
		/end MEASUREMENT
		/begin MEASUREMENT Cnxuce11
			"Etat_connexion_uce_11"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E59
		/end MEASUREMENT
		/begin MEASUREMENT Cnxuce12
			"Etat_connexion_uce_12"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E5A
		/end MEASUREMENT
		/begin MEASUREMENT Cnxuce13
			"Etat_connexion_uce_13"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E5B
		/end MEASUREMENT
		/begin MEASUREMENT Cnxuce14
			"Etat_connexion_uce_14"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E5C
		/end MEASUREMENT
		/begin MEASUREMENT Cnxuce15
			"Etat_connexion_uce_15"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E5D
		/end MEASUREMENT
		/begin MEASUREMENT Cnxuce16
			"Etat_connexion_uce_16"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E5E
		/end MEASUREMENT
		/begin MEASUREMENT Cnxuce17
			"Etat_connexion_uce_17"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E5F
		/end MEASUREMENT
		/begin MEASUREMENT Cnxuce18
			"Etat_connexion_uce_18"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E60
		/end MEASUREMENT
		/begin MEASUREMENT Cnxuce19
			"Etat_connexion_uce_19"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E61
		/end MEASUREMENT
		/begin MEASUREMENT Cnxuce2
			"Etat_connexion_uce_2"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E62
		/end MEASUREMENT
		/begin MEASUREMENT Cnxuce20
			"Etat_connexion_uce_20"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E63
		/end MEASUREMENT
		/begin MEASUREMENT Cnxuce21
			"Etat_connexion_uce_21"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E64
		/end MEASUREMENT
		/begin MEASUREMENT Cnxuce22
			"Etat_connexion_uce_22"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E65
		/end MEASUREMENT
		/begin MEASUREMENT Cnxuce23
			"Etat_connexion_uce_23"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E66
		/end MEASUREMENT
		/begin MEASUREMENT Cnxuce24
			"Etat_connexion_uce_24"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E67
		/end MEASUREMENT
		/begin MEASUREMENT Cnxuce3
			"Etat_connexion_uce_3"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E68
		/end MEASUREMENT
		/begin MEASUREMENT Cnxuce4
			"Etat_connexion_uce_4"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E69
		/end MEASUREMENT
		/begin MEASUREMENT Cnxuce5
			"Etat_connexion_uce_5"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E6A
		/end MEASUREMENT
		/begin MEASUREMENT Cnxuce6
			"Etat_connexion_uce_6"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E6B
		/end MEASUREMENT
		/begin MEASUREMENT Cnxuce7
			"Etat_connexion_uce_7"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E6C
		/end MEASUREMENT
		/begin MEASUREMENT Cnxuce8
			"Etat_connexion_uce_8"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E6D
		/end MEASUREMENT
		/begin MEASUREMENT Cnxuce9
			"Etat_connexion_uce_9"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E6E
		/end MEASUREMENT
		/begin MEASUREMENT Com_obd_en_cours
			"Com_obd_en_cours"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF75B2
		/end MEASUREMENT
		/begin MEASUREMENT Comm_init_rapide_en_cours
			"Comm_init_rapide_en_cours"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF75B3
		/end MEASUREMENT
		/begin MEASUREMENT Communication_k_active
			"Communication_k_active"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF75B4
		/end MEASUREMENT
		/begin MEASUREMENT Compare_data_flag
			"Compare_data_flag"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF82B1
		/end MEASUREMENT
		/begin MEASUREMENT Compt_rco_sonde_amont_
			"Compt_rco_sonde_amont"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7EB5
		/end MEASUREMENT
		/begin MEASUREMENT Compt_rco_sonde_aval_
			"Compt_rco_sonde_aval"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7EB6
		/end MEASUREMENT
		/begin MEASUREMENT Compteur_16s
			"Compteur_16s"
			UBYTE
			F_1_p0_54
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7F12
		/end MEASUREMENT
		/begin MEASUREMENT Compteur_autoris_trans_edic
			"Compteur_autoris_trans_edic"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF75D4
		/end MEASUREMENT
		/begin MEASUREMENT Compteur_can_20ms
			"Compteur_can_20ms"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF72E5
		/end MEASUREMENT
		/begin MEASUREMENT Compteur_can_2ms
			"Compteur_can_2ms"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF72E6
		/end MEASUREMENT
		/begin MEASUREMENT Compteur_can_lent
			"Compteur_can_lent"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF72E7
		/end MEASUREMENT
		/begin MEASUREMENT Compteur_can_rapide
			"Compteur_can_rapide"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF72E8
		/end MEASUREMENT
		/begin MEASUREMENT Compteur_config_asic
			"Compteur_config_asic"
			UBYTE
			F_4v096_p0_12
			2
			2
			0
			1044.48
			ECU_ADDRESS 0xFFFF7478
		/end MEASUREMENT
		/begin MEASUREMENT Compteur_de_glissement_de_tache
			"Compteur_de_glissement_de_tache"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7C08
		/end MEASUREMENT
		/begin MEASUREMENT Compteur_de_pmh_ldb_
			"Compteur_de_pmh_ldb"
			UWORD
			F_1_p0_53
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7FA4
		/end MEASUREMENT
		/begin MEASUREMENT Compteur_defaut_except_eep
			"Compteur_defaut_except_eep"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF893A
		/end MEASUREMENT
		/begin MEASUREMENT Compteur_defaut_exception
			"Compteur_defaut_exception"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF6556
		/end MEASUREMENT
		/begin MEASUREMENT Compteur_defaut_logiciel_
			"Compteur_defaut_logiciel"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7C12
		/end MEASUREMENT
		/begin MEASUREMENT Compteur_defaut_pile
			"Compteur_defaut_pile"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF6558
		/end MEASUREMENT
		/begin MEASUREMENT Compteur_defaut_pile_eep
			"Compteur_defaut_pile_eep"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF893C
		/end MEASUREMENT
		/begin MEASUREMENT Compteur_desynchro_trz_
			"Compteur_desynchro_trz"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7F9D
		/end MEASUREMENT
		/begin MEASUREMENT Compteur_detection_bob_a_c_oc
			"Compteur_detection_bob_a_c_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6E06
		/end MEASUREMENT
		/begin MEASUREMENT Compteur_detection_bob_b_d_oc
			"Compteur_detection_bob_b_d_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6E07
		/end MEASUREMENT
		/begin MEASUREMENT Compteur_detection_gas_pump_oc
			"Compteur_detection_gas_pump_oc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF784C
		/end MEASUREMENT
		/begin MEASUREMENT Compteur_diag_k_
			"Compteur_diag_k"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF74B0
		/end MEASUREMENT
		/begin MEASUREMENT Compteur_ech_wakeup_low
			"Compteur_ech_wakeup_low"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF75D5
		/end MEASUREMENT
		/begin MEASUREMENT Compteur_echantillonnage_wakeup
			"Compteur_echantillonnage_wakeup"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF75D6
		/end MEASUREMENT
		/begin MEASUREMENT Compteur_erreurs_reception_k
			"Compteur_erreurs_reception_k"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF75D7
		/end MEASUREMENT
		/begin MEASUREMENT Compteur_errorhook
			"Compteur_errorhook"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7E86
		/end MEASUREMENT
		/begin MEASUREMENT Compteur_glissement_500micros
			"Compteur_glissement_500micros"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7C14
		/end MEASUREMENT
		/begin MEASUREMENT Compteur_mreq
			"Compteur_mreq"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7878
		/end MEASUREMENT
		/begin MEASUREMENT Compteur_nbr_warm_up
			"Compteur_nbr_warm_up"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF86AC
		/end MEASUREMENT
		/begin MEASUREMENT Compteur_panne_parasite_spi
			"Compteur_panne_parasite_spi"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF82B6
		/end MEASUREMENT
		/begin MEASUREMENT Compteur_pmh_inc_temp_eau_
			"Compteur_pmh_inc_temp_eau"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF858A
		/end MEASUREMENT
		/begin MEASUREMENT Compteur_pmh_inc_temp_eau_mdl
			"Compteur_pmh_inc_temp_eau_mdl"
			UWORD
			F_1_p0_53
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF8594
		/end MEASUREMENT
		/begin MEASUREMENT Compteur_pression_pmh_
			"Compteur_pression_pmh"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF8054
		/end MEASUREMENT
		/begin MEASUREMENT Compteur_recalage_dent_en_moins
			"Compteur_recalage_dent_en_moins"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7F9E
		/end MEASUREMENT
		/begin MEASUREMENT Compteur_recalage_dent_en_plus
			"Compteur_recalage_dent_en_plus"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7F9F
		/end MEASUREMENT
		/begin MEASUREMENT Compteur_reset_verrou
			"Compteur_reset_verrou"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF86BF
		/end MEASUREMENT
		/begin MEASUREMENT Compteur_succes_reco_rr
			"Compteur_succes_reco_rr"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF8672
		/end MEASUREMENT
		/begin MEASUREMENT Compteur_top_vitesse_vehicule
			"Compteur_top_vitesse_vehicule"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF828C
		/end MEASUREMENT
		/begin MEASUREMENT Compteur_trame_acc_manquante
			"Compteur_trame_acc_manquante"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF81BC
		/end MEASUREMENT
		/begin MEASUREMENT Cond_calc_av_dyn_ral_
			"Cond_calc_av_dyn_ral"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6D79
		/end MEASUREMENT
		/begin MEASUREMENT Cond_gmv_mot_tournant
			"COND_GMV_MOT_TOURNANT"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x10
			ECU_ADDRESS 0xFFFF792A
		/end MEASUREMENT
		/begin MEASUREMENT Cond_legis_moteur_verif_prem_
			"Cond_legis_moteur_verif_prem"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7CEC
		/end MEASUREMENT
		/begin MEASUREMENT Cond_pompe_air
			"COND_POMPE_AIR"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF84B6
		/end MEASUREMENT
		/begin MEASUREMENT Cond_tension_chauf_sonde_amont
			"Cond_tension_chauf_sonde_amont"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7E90
		/end MEASUREMENT
		/begin MEASUREMENT Condition_rapide_post_injection_
			"Condition_rapide_post_injection"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A58
		/end MEASUREMENT
		/begin MEASUREMENT Connexion_ev_iae_co_ok
			"Connexion_ev_iae_co_ok"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF848D
		/end MEASUREMENT
		/begin MEASUREMENT Connexion_gmv_co_ok_1
			"Connexion_gmv_co_ok_1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF791C
		/end MEASUREMENT
		/begin MEASUREMENT Connexion_gmv_co_ok_2
			"Connexion_gmv_co_ok_2"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF791D
		/end MEASUREMENT
		/begin MEASUREMENT Connexion_pav_co_ok
			"Connexion_pav_co_ok"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF78E8
		/end MEASUREMENT
		/begin MEASUREMENT Connexion_pmpair_co_ok
			"Connexion_pmpair_co_ok"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF848E
		/end MEASUREMENT
		/begin MEASUREMENT Connexion_ptc_rov_co_ok
			"Connexion_ptc_rov_co_ok"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8158
		/end MEASUREMENT
		/begin MEASUREMENT Connexion_thp_co_ok
			"Connexion_thp_co_ok"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF82D8
		/end MEASUREMENT
		/begin MEASUREMENT Connexion_wpmp_co_ok
			"Connexion_wpmp_co_ok"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7F0C
		/end MEASUREMENT
		/begin MEASUREMENT Consigne_rco_vvt_adm
			"Consigne_rco_vvt_adm"
			UWORD
			F_0v09756098_p0_55
			2
			2
			0
			6393.658824
			ECU_ADDRESS 0xFFFF8548
		/end MEASUREMENT
		/begin MEASUREMENT Contact_avec_pompe_ee_
			"CONTACT_AVEC_POMPE_EE"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8151
		/end MEASUREMENT
		/begin MEASUREMENT Contact_moteur_tournant_ee_
			"CONTACT_MOTEUR_TOURNANT_EE"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x4
			ECU_ADDRESS 0xFFFF8151
		/end MEASUREMENT
		/begin MEASUREMENT Contact_sans_pompe_ee_
			"CONTACT_SANS_POMPE_EE"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x2
			ECU_ADDRESS 0xFFFF8151
		/end MEASUREMENT
		/begin MEASUREMENT Copy_m1_etats_raccord_elec
			"Copy_m1_etats_raccord_elec"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF869E
		/end MEASUREMENT
		/begin MEASUREMENT Copy_p1_pannes_mem_entrees
			"Copy_p1_pannes_mem_entrees"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8698
		/end MEASUREMENT
		/begin MEASUREMENT Copy_p1_pannes_mem_sorties
			"Copy_p1_pannes_mem_sorties"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF869B
		/end MEASUREMENT
		/begin MEASUREMENT Copy_p2_pannes_mem_entrees
			"Copy_p2_pannes_mem_entrees"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8699
		/end MEASUREMENT
		/begin MEASUREMENT Copy_p2_pannes_mem_sorties
			"Copy_p2_pannes_mem_sorties"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF869C
		/end MEASUREMENT
		/begin MEASUREMENT Copy_p3_pannes_mem_entrees
			"Copy_p3_pannes_mem_entrees"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF869A
		/end MEASUREMENT
		/begin MEASUREMENT Copy_p3_pannes_mem_sorties
			"Copy_p3_pannes_mem_sorties"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF869D
		/end MEASUREMENT
		/begin MEASUREMENT Correair_
			"Corr_rr_eau_air"
			SWORD
			Id_0x00
			2
			2
			-32768
			32767
			ECU_ADDRESS 0xFFFF79D6
		/end MEASUREMENT
		/begin MEASUREMENT Correction_temporaire_
			"Correction_temporaire"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF79BF
		/end MEASUREMENT
		/begin MEASUREMENT Coupure_cmd_appli_chauf_gpl
			"Coupure_cmd_appli_chauf_gpl"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7E91
		/end MEASUREMENT
		/begin MEASUREMENT Coupure_cmd_appli_cp
			"Coupure_cmd_appli_cp"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7822
		/end MEASUREMENT
		/begin MEASUREMENT Coupure_cmd_appli_ev_iae
			"Coupure_cmd_appli_ev_iae"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7823
		/end MEASUREMENT
		/begin MEASUREMENT Coupure_cmd_appli_ptc_rov
			"Coupure_cmd_appli_ptc_rov"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7824
		/end MEASUREMENT
		/begin MEASUREMENT Coupure_cmd_appli_wgc
			"Coupure_cmd_appli_wgc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7825
		/end MEASUREMENT
		/begin MEASUREMENT Coupure_cmd_appli_wpmp
			"Coupure_cmd_appli_wpmp"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7826
		/end MEASUREMENT
		/begin MEASUREMENT Coupure_decel_commencee
			"Coupure_decel_commencee"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A59
		/end MEASUREMENT
		/begin MEASUREMENT Coupure_decel_progr_inj_
			"Coupure_decel_progr_inj"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7AA2
		/end MEASUREMENT
		/begin MEASUREMENT Coupure_drv
			"COUPURE_DRV"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7695
		/end MEASUREMENT
		/begin MEASUREMENT Coupure_surpression_
			"COUPURE_SURPRESSION"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x4
			ECU_ADDRESS 0xFFFF84AF
		/end MEASUREMENT
		/begin MEASUREMENT Cpt_msf_cat_niv_min_ess_ion
			"Cpt_msf_cat_niv_min_ess_ion"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF86DA
		/end MEASUREMENT
		/begin MEASUREMENT Cpt_ok_reco_veh_roul_apr_cal
			"Cpt_ok_reco_veh_roul_apr_cal"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF8670
		/end MEASUREMENT
		/begin MEASUREMENT Cptdesinj_
			"Compteur_entre_desact_inj"
			UBYTE
			F_8_p0_56
			2
			2
			0
			2040
			ECU_ADDRESS 0xFFFF7AA1
		/end MEASUREMENT
		/begin MEASUREMENT Cpytopat
			"Cranking_autorisation_at_via_ecm"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF72EA
		/end MEASUREMENT
		/begin MEASUREMENT Crashmx1
			"Donnee_1_trame_air_bag_crash"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF740C
		/end MEASUREMENT
		/begin MEASUREMENT Crashmx2
			"Donnee_2_trame_air_bag_crash"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF740D
		/end MEASUREMENT
		/begin MEASUREMENT Cskey
			"Clear_skey"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF741D
		/end MEASUREMENT
		/begin MEASUREMENT Cumul_periodes_moteur_temp
			"Cumul_periodes_moteur_temp"
			UWORD
			F_6v4_p0_140
			2
			2
			0
			419424
			ECU_ADDRESS 0xFFFF8294
		/end MEASUREMENT
		/begin MEASUREMENT Cur_bob_1_4_result_ad_conv
			"Cur_bob_1_4_result_ad_conv"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFFF816
		/end MEASUREMENT
		/begin MEASUREMENT Cur_bob_3_2_result_ad_conv
			"Cur_bob_3_2_result_ad_conv"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFFF844
		/end MEASUREMENT
		/begin MEASUREMENT Data_transmit_flag
			"Data_transmit_flag"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF82B2
		/end MEASUREMENT
		/begin MEASUREMENT Debordement_durees_dents_
			"Debordement_durees_dents"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF74F0
		/end MEASUREMENT
		/begin MEASUREMENT Debut_fenetre_cliquetis_num
			"Debut_fenetre_cliquetis_num"
			UBYTE
			F_0v375_p0_29
			2
			2
			0
			95.625
			ECU_ADDRESS 0xFFFF747F
		/end MEASUREMENT
		/begin MEASUREMENT Decol_hyst1_output
			"Decol_hyst1_output"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF77F8
		/end MEASUREMENT
		/begin MEASUREMENT Decol_hyst2_output
			"Decol_hyst2_output"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF77F9
		/end MEASUREMENT
		/begin MEASUREMENT Decrementation_pression_
			"DECREMENTATION_PRESSION"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x2
			ECU_ADDRESS 0xFFFF833E
		/end MEASUREMENT
		/begin MEASUREMENT Decrementation_tempo_remise_
			"DECREMENTATION_TEMPO_REMISE"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x8
			ECU_ADDRESS 0xFFFF833E
		/end MEASUREMENT
		/begin MEASUREMENT Decrementation_tempo_retrait_
			"DECREMENTATION_TEMPO_RETRAIT"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x4
			ECU_ADDRESS 0xFFFF833E
		/end MEASUREMENT
		/begin MEASUREMENT Defaut_present_detecte_
			"Defaut_present_detecte"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF786C
		/end MEASUREMENT
		/begin MEASUREMENT Defdem
			"Defaut_demarrage"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E53
		/end MEASUREMENT
		/begin MEASUREMENT Dem_init_defaut_adapt_memo_
			"Dem_init_defaut_adapt_memo"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF75D8
		/end MEASUREMENT
		/begin MEASUREMENT Dem_init_defaut_carres_memo_
			"Dem_init_defaut_carres_memo"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF75D9
		/end MEASUREMENT
		/begin MEASUREMENT Dem_init_defaut_cliquetis_memo_
			"Dem_init_defaut_cliquetis_memo"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF75DA
		/end MEASUREMENT
		/begin MEASUREMENT Dem_init_defaut_couple_memo_
			"Dem_init_defaut_couple_memo"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF75DB
		/end MEASUREMENT
		/begin MEASUREMENT Dem_init_defaut_generale_memo_
			"Dem_init_defaut_generale_memo"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF75DC
		/end MEASUREMENT
		/begin MEASUREMENT Dem_init_defaut_pannes_memo_
			"Dem_init_defaut_pannes_memo"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF75DD
		/end MEASUREMENT
		/begin MEASUREMENT Dem_init_defaut_pannes_obd_memo_
			"Dem_init_defaut_pannes_obd_memo"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF75DE
		/end MEASUREMENT
		/begin MEASUREMENT Dem_init_defaut_papillon_memo_
			"Dem_init_defaut_papillon_memo"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF75DF
		/end MEASUREMENT
		/begin MEASUREMENT Dem_init_defaut_rr_memo_
			"Dem_init_defaut_rr_memo"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF75E0
		/end MEASUREMENT
		/begin MEASUREMENT Demande_conversion
			"Demande_conversion"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7E92
		/end MEASUREMENT
		/begin MEASUREMENT Demande_coupure_relais_pompe
			"Demande_coupure_relais_pompe"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8142
		/end MEASUREMENT
		/begin MEASUREMENT Demande_coupure_relais_pwrl
			"Demande_coupure_relais_pwrl"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8143
		/end MEASUREMENT
		/begin MEASUREMENT Demande_free_wheeling
			"Demande_free_wheeling"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7818
		/end MEASUREMENT
		/begin MEASUREMENT Demande_inhib_carburant_
			"Demande_inhib_carburant"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF75B5
		/end MEASUREMENT
		/begin MEASUREMENT Demande_init_par_defaut_aac_memo
			"Demande_init_par_defaut_aac_memo"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF75E1
		/end MEASUREMENT
		/begin MEASUREMENT Demande_init_prog_adapt_memo_
			"Demande_init_prog_adapt_memo"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF75E2
		/end MEASUREMENT
		/begin MEASUREMENT Demande_init_prog_adgainm_memo_
			"Demande_init_prog_adgainm_memo"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF75E3
		/end MEASUREMENT
		/begin MEASUREMENT Demande_init_prog_adzerom_memo_
			"Demande_init_prog_adzerom_memo"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF75E4
		/end MEASUREMENT
		/begin MEASUREMENT Demande_init_prog_betamax0_memo_
			"Demande_init_prog_betamax0_memo"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF75E5
		/end MEASUREMENT
		/begin MEASUREMENT Demande_init_prog_betamax1_memo_
			"Demande_init_prog_betamax1_memo"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF75E6
		/end MEASUREMENT
		/begin MEASUREMENT Demande_init_prog_betamax2_memo_
			"Demande_init_prog_betamax2_memo"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF75E7
		/end MEASUREMENT
		/begin MEASUREMENT Demande_init_prog_betamax3_memo_
			"Demande_init_prog_betamax3_memo"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF75E8
		/end MEASUREMENT
		/begin MEASUREMENT Demande_init_prog_betamax4_memo_
			"Demande_init_prog_betamax4_memo"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF75E9
		/end MEASUREMENT
		/begin MEASUREMENT Demande_init_prog_betamin0_memo_
			"Demande_init_prog_betamin0_memo"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF75EA
		/end MEASUREMENT
		/begin MEASUREMENT Demande_init_prog_betamin1_memo_
			"Demande_init_prog_betamin1_memo"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF75EB
		/end MEASUREMENT
		/begin MEASUREMENT Demande_init_prog_betamin2_memo_
			"Demande_init_prog_betamin2_memo"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF75EC
		/end MEASUREMENT
		/begin MEASUREMENT Demande_init_prog_betamin3_memo_
			"Demande_init_prog_betamin3_memo"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF75ED
		/end MEASUREMENT
		/begin MEASUREMENT Demande_init_prog_betamin4_memo_
			"Demande_init_prog_betamin4_memo"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF75EE
		/end MEASUREMENT
		/begin MEASUREMENT Demande_init_prog_carres_memo_
			"Demande_init_prog_carres_memo"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF75EF
		/end MEASUREMENT
		/begin MEASUREMENT Demande_init_prog_cntnbmc_memo_
			"Demande_init_prog_cntnbmc_memo"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF75F0
		/end MEASUREMENT
		/begin MEASUREMENT Demande_init_prog_couple_memo_
			"Demande_init_prog_couple_memo"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF75F1
		/end MEASUREMENT
		/begin MEASUREMENT Demande_init_prog_flgbet_memo_
			"Demande_init_prog_flgbet_memo"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF75F2
		/end MEASUREMENT
		/begin MEASUREMENT Demande_init_prog_rr_memo_
			"Demande_init_prog_rr_memo"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF75F3
		/end MEASUREMENT
		/begin MEASUREMENT Demande_init_prog_rrdmin_memo_
			"Demande_init_prog_rrdmin_memo"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF75F4
		/end MEASUREMENT
		/begin MEASUREMENT Demande_init_prog_tlzb1f_memo_
			"Demande_init_prog_tlzb1f_memo"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF75F5
		/end MEASUREMENT
		/begin MEASUREMENT Demande_init_prog_tlzb2f_memo_
			"Demande_init_prog_tlzb2f_memo"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF75F6
		/end MEASUREMENT
		/begin MEASUREMENT Demande_init_prog_tlzcorap_memo_
			"Demande_init_prog_tlzcorap_memo"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF75F7
		/end MEASUREMENT
		/begin MEASUREMENT Demande_init_prog_tlzcorf_memo_
			"Demande_init_prog_tlzcorf_memo"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF75F8
		/end MEASUREMENT
		/begin MEASUREMENT Demande_init_prog_trzb1f_memo_
			"Demande_init_prog_trzb1f_memo"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF75F9
		/end MEASUREMENT
		/begin MEASUREMENT Demande_init_prog_trzb2f_memo_
			"Demande_init_prog_trzb2f_memo"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF75FA
		/end MEASUREMENT
		/begin MEASUREMENT Demande_init_prog_trzbeta1_memo_
			"Demande_init_prog_trzbeta1_memo"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF75FB
		/end MEASUREMENT
		/begin MEASUREMENT Demande_init_prog_trzbeta2_memo_
			"Demande_init_prog_trzbeta2_memo"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF75FC
		/end MEASUREMENT
		/begin MEASUREMENT Demande_purge_dormant_
			"Demande_purge_dormant"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8098
		/end MEASUREMENT
		/begin MEASUREMENT Demande_raz_eeprom
			"Demande_raz_eeprom"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF788A
		/end MEASUREMENT
		/begin MEASUREMENT Demande_reconf_asic
			"Demande_reconf_asic"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF746D
		/end MEASUREMENT
		/begin MEASUREMENT Demande_stop_communication
			"Demande_stop_communication"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF75B8
		/end MEASUREMENT
		/begin MEASUREMENT Demande_vvt_adm_dormant
			"Demande_vvt_adm_dormant"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8511
		/end MEASUREMENT
		/begin MEASUREMENT Demarrage_detecte_
			"Demarrage_detecte"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF786D
		/end MEASUREMENT
		/begin MEASUREMENT Demi_tour_effectue_trz
			"Demi_tour_effectue_trz"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7F1C
		/end MEASUREMENT
		/begin MEASUREMENT Desact_pompe_air
			"DESACT_POMPE_AIR"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x10
			ECU_ADDRESS 0xFFFF84B6
		/end MEASUREMENT
		/begin MEASUREMENT Desactive_inh_mcw_hseq_
			"Desactive_inh_mcw_hseq"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF823D
		/end MEASUREMENT
		/begin MEASUREMENT DETROMPAGE
			"DETROMPAGE"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6BD0
		/end MEASUREMENT
		/begin MEASUREMENT Deux_cyl_actifs
			"DEUX_CYL_ACTIFS"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x2
			ECU_ADDRESS 0xFFFF8329
		/end MEASUREMENT
		/begin MEASUREMENT DEUXIEME_ATTENTE
			"DEUXIEME_ATTENTE"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x4
			ECU_ADDRESS 0xFFFF6BD0
		/end MEASUREMENT
		/begin MEASUREMENT DEUXIEME_CALCULS
			"DEUXIEME_CALCULS"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6BD0
		/end MEASUREMENT
		/begin MEASUREMENT Dgfcstat
			"Diag_statique_fin_chaine"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF82C4
		/end MEASUREMENT
		/begin MEASUREMENT Diag_delay
			"Diag_delay"
			UBYTE
			F_128_p0_125
			2
			2
			0
			32640
			ECU_ADDRESS 0xFFFF84A9
		/end MEASUREMENT
		/begin MEASUREMENT Diag_it_pmh
			"Diag_it_pmh"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6BA8
		/end MEASUREMENT
		/begin MEASUREMENT Diag_lis_enable
			"Diag_lis_enable"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7C28
		/end MEASUREMENT
		/begin MEASUREMENT Diag_pmvac_att_inco
			"DIAG_PMVAC_ATT_INCO"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x2
			ECU_ADDRESS 0xFFFF7902
		/end MEASUREMENT
		/begin MEASUREMENT Diag_pmvac_inco_conf
			"DIAG_PMVAC_INCO_CONF"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x4
			ECU_ADDRESS 0xFFFF7902
		/end MEASUREMENT
		/begin MEASUREMENT Diag_pmvac_inco_temp
			"DIAG_PMVAC_INCO_TEMP"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7902
		/end MEASUREMENT
		/begin MEASUREMENT Diag_pmvac_init
			"DIAG_PMVAC_INIT"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7902
		/end MEASUREMENT
		/begin MEASUREMENT Diag_pmvac_temp_dem
			"DIAG_PMVAC_TEMP_DEM"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7902
		/end MEASUREMENT
		/begin MEASUREMENT Diag_seq_etat_cata_
			"DIAG_SEQ_ETAT_CATA"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D7D
		/end MEASUREMENT
		/begin MEASUREMENT Diag_seq_etat_sai
			"DIAG_SEQ_ETAT_SAI"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x4
			ECU_ADDRESS 0xFFFF7D7D
		/end MEASUREMENT
		/begin MEASUREMENT Diag_seq_etat_sans_requete_
			"DIAG_SEQ_ETAT_SANS_REQUETE"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x8
			ECU_ADDRESS 0xFFFF7D7D
		/end MEASUREMENT
		/begin MEASUREMENT Diag_seq_etat_sondes_
			"DIAG_SEQ_ETAT_SONDES"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x2
			ECU_ADDRESS 0xFFFF7D7D
		/end MEASUREMENT
		/begin MEASUREMENT Diag_tempo_relais_actionneur
			"Diag_tempo_relais_actionneur"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF784D
		/end MEASUREMENT
		/begin MEASUREMENT Diag_tpc_active_tempo_
			"Diag_tpc_active_tempo"
			UBYTE
			F_2_p0_249
			2
			2
			0
			510
			ECU_ADDRESS 0xFFFF7689
		/end MEASUREMENT
		/begin MEASUREMENT Diag_wastegate_etat_bas
			"Diag_wastegate_etat_bas"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7827
		/end MEASUREMENT
		/begin MEASUREMENT Diag_wastegate_etat_haut
			"Diag_wastegate_etat_haut"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7828
		/end MEASUREMENT
		/begin MEASUREMENT Diag_wgc_etat_bas_autorise
			"Diag_wgc_etat_bas_autorise"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7829
		/end MEASUREMENT
		/begin MEASUREMENT Diag_wgc_etat_haut_autorise
			"Diag_wgc_etat_haut_autorise"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF782A
		/end MEASUREMENT
		/begin MEASUREMENT Diagnostic_cliquetis
			"Diagnostic_cliquetis"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF746E
		/end MEASUREMENT
		/begin MEASUREMENT Diagnostic_enable_injecteurs
			"Diagnostic_enable_injecteurs"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF782B
		/end MEASUREMENT
		/begin MEASUREMENT Diagnostic_enable_relais
			"Diagnostic_enable_relais"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF782C
		/end MEASUREMENT
		/begin MEASUREMENT Diagnostic_enable_vvt
			"Diagnostic_enable_vvt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF782D
		/end MEASUREMENT
		/begin MEASUREMENT Diff_pres_coll_pres_sural
			"Diff_pres_coll_pres_sural"
			UBYTE
			F_3v7_p0_21
			2
			2
			0
			943.5
			ECU_ADDRESS 0xFFFF84AA
		/end MEASUREMENT
		/begin MEASUREMENT Dinitclq
			"Demande_init_par_defaut_cliq"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF75B6
		/end MEASUREMENT
		/begin MEASUREMENT Dinitpap
			"Demande_init_par_defaut_papillon"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF75B7
		/end MEASUREMENT
		/begin MEASUREMENT Diviseur_256_redepart_
			"Diviseur_256_redepart"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF80DD
		/end MEASUREMENT
		/begin MEASUREMENT Diviseur_pmh_redepart_
			"Diviseur_pmh_redepart"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF80DE
		/end MEASUREMENT
		/begin MEASUREMENT Dmde_call_acces_eeprom_
			"Dmde_call_acces_eeprom"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF75B9
		/end MEASUREMENT
		/begin MEASUREMENT Dmdspec
			"Demand_specific"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E54
		/end MEASUREMENT
		/begin MEASUREMENT Doc_on
			"Doc_on"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF75FD
		/end MEASUREMENT
		/begin MEASUREMENT Donnee_eeprom
			"Donnee_eeprom"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF82BE
		/end MEASUREMENT
		/begin MEASUREMENT Driver_wastegate_valide
			"Driver_wastegate_valide"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF848F
		/end MEASUREMENT
		/begin MEASUREMENT Dsk
			"Demande_skey"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6BE5
		/end MEASUREMENT
		/begin MEASUREMENT Dtc_panne_eobd_freeze_
			"Dtc_panne_eobd_freeze"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF787A
		/end MEASUREMENT
		/begin MEASUREMENT Dtc_panne_presente_
			"Dtc_panne_presente"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7DE0
		/end MEASUREMENT
		/begin MEASUREMENT Dtc_throttle_pos_ref_old
			"Dtc_throttle_pos_ref_old"
			UWORD
			F_0v097656_p0_5
			2
			2
			0
			6399.88596
			ECU_ADDRESS 0xFFFF836C
		/end MEASUREMENT
		/begin MEASUREMENT Dtc_torque_ratio_setpoint_para
			"Dtc_torque_ratio_setpoint_para"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF77B2
		/end MEASUREMENT
		/begin MEASUREMENT Duree_boucle_morte
			"Duree_boucle_morte"
			UWORD
			F_0v4_p0_273
			2
			2
			0
			26214
			ECU_ADDRESS 0xFFFF7C16
		/end MEASUREMENT
		/begin MEASUREMENT Duree_dent_high
			"Duree_dent_msb"
			UWORD
			F_6v5536_p0_274
			2
			2
			0
			429490.176
			ECU_ADDRESS 0xFFFF7F2C
		/end MEASUREMENT
		/begin MEASUREMENT Duree_dent_low
			"Duree_dent_lsb"
			UWORD
			F_0v1_p0_275
			2
			2
			0
			6553.5
			ECU_ADDRESS 0xFFFF7F2E
		/end MEASUREMENT
		/begin MEASUREMENT Duree_dent_noise_canceler
			"Duree_dent_noise_canceler"
			ULONG
			F_0v1_p0_275
			2
			2
			0
			429496729.5
			ECU_ADDRESS 0xFFFF7F30
		/end MEASUREMENT
		/begin MEASUREMENT Duree_diag_appli_cp
			"Duree_diag_appli_cp"
			UWORD
			F_3v2_p0_152
			2
			2
			0
			209712
			ECU_ADDRESS 0xFFFF7854
		/end MEASUREMENT
		/begin MEASUREMENT Duree_diag_appli_ev_iae
			"Duree_diag_appli_ev_iae"
			UWORD
			F_3v2_p0_152
			2
			2
			0
			209712
			ECU_ADDRESS 0xFFFF7856
		/end MEASUREMENT
		/begin MEASUREMENT Duree_diag_appli_ptc_rov
			"Duree_diag_appli_ptc_rov"
			UWORD
			F_3v2_p0_152
			2
			2
			0
			209712
			ECU_ADDRESS 0xFFFF7858
		/end MEASUREMENT
		/begin MEASUREMENT Duree_diag_appli_wgc_bas
			"Duree_diag_appli_wgc_bas"
			UWORD
			F_3v2_p0_152
			2
			2
			0
			209712
			ECU_ADDRESS 0xFFFF785A
		/end MEASUREMENT
		/begin MEASUREMENT Duree_diag_appli_wgc_haut
			"Duree_diag_appli_wgc_haut"
			UWORD
			F_3v2_p0_152
			2
			2
			0
			209712
			ECU_ADDRESS 0xFFFF785C
		/end MEASUREMENT
		/begin MEASUREMENT Duree_diag_appli_wpmp
			"Duree_diag_appli_wpmp"
			UWORD
			F_3v2_p0_152
			2
			2
			0
			209712
			ECU_ADDRESS 0xFFFF785E
		/end MEASUREMENT
		/begin MEASUREMENT Duree_fenetre_cliquetis_num
			"Duree_fenetre_cliquetis_num"
			UBYTE
			F_0v375_p0_29
			2
			2
			0
			95.625
			ECU_ADDRESS 0xFFFF7480
		/end MEASUREMENT
		/begin MEASUREMENT Duree_fenetre_k2
			"Duree_fenetre_k2"
			UBYTE
			F_0v375_p0_29
			2
			2
			0
			95.625
			ECU_ADDRESS 0xFFFF7481
		/end MEASUREMENT
		/begin MEASUREMENT Duree_inc_reg_min_prog_
			"Duree_inc_reg_min_prog"
			UBYTE
			F_0v128_p0_75
			2
			2
			0
			32.64
			ECU_ADDRESS 0xFFFF80EA
		/end MEASUREMENT
		/begin MEASUREMENT Duree_reg_pression_huile
			"Duree_reg_pression_huile"
			UBYTE
			F_1v024_p0_119
			2
			2
			0
			261.12
			ECU_ADDRESS 0xFFFF80EB
		/end MEASUREMENT
		/begin MEASUREMENT Duree_tache_select_
			"Duree_tache_select"
			UWORD
			F_0v4_p0_273
			2
			2
			0
			26214
			ECU_ADDRESS 0xFFFF7C1A
		/end MEASUREMENT
		/begin MEASUREMENT Echelle_rco_wastegate
			"Echelle_rco_wastegate"
			UBYTE
			F_0v0125_p0_276
			2
			2
			0
			3.1875
			ECU_ADDRESS 0xFFFF84AB
		/end MEASUREMENT
		/begin MEASUREMENT Ecut_ecu_temper_lshd_up_trim
			"Ecut_ecu_temper_lshd_up_trim"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8A66
		/end MEASUREMENT
		/begin MEASUREMENT Eep_1ere_partie_obj_deja_traitee
			"Eep_1ere_partie_obj_deja_traitee"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF787C
		/end MEASUREMENT
		/begin MEASUREMENT Eep_interdiction_d_ecrire
			"Eep_interdiction_d_ecrire"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7C09
		/end MEASUREMENT
		/begin MEASUREMENT Eep_nb_ecr_pages
			"Eep_nb_ecr_pages"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF860A
		/end MEASUREMENT
		/begin MEASUREMENT Eep_nb_ecr_pages_roulage
			"Eep_nb_ecr_pages_roulage"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF78AE
		/end MEASUREMENT
		/begin MEASUREMENT Eep_nb_mots_cmp
			"Eep_nb_mots_cmp"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF82B8
		/end MEASUREMENT
		/begin MEASUREMENT Eep_nb_mots_page
			"Eep_nb_mots_page"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF82B9
		/end MEASUREMENT
		/begin MEASUREMENT Eep_nb_tentatives
			"Eep_nb_tentatives"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF82BA
		/end MEASUREMENT
		/begin MEASUREMENT Eep_nb_total_ecr_pages
			"Eep_nb_total_ecr_pages"
			ULONG
			Id_0x00
			2
			2
			0
			4294967295
			ECU_ADDRESS 0xFFFF7880
		/end MEASUREMENT
		/begin MEASUREMENT Eep_nb_total_ecr_pages_lsb
			"Eep_nb_total_ecr_pages_lsb"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF860E
		/end MEASUREMENT
		/begin MEASUREMENT Eep_nb_total_ecr_pages_msb
			"Eep_nb_total_ecr_pages_msb"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF860C
		/end MEASUREMENT
		/begin MEASUREMENT Eep_no_objet_courant
			"Eep_no_objet_courant"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7886
		/end MEASUREMENT
		/begin MEASUREMENT Eep_tps_cycle_ecr
			"Eep_tps_cycle_ecr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF82BB
		/end MEASUREMENT
		/begin MEASUREMENT Emission_can_doc_en_cours
			"Emission_can_doc_en_cours"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E55
		/end MEASUREMENT
		/begin MEASUREMENT Emul
			"Carte_emulatrice"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7BE8
		/end MEASUREMENT
		/begin MEASUREMENT En_injecteur_a_cc_sortie
			"En_injecteur_a_cc_sortie"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7B94
		/end MEASUREMENT
		/begin MEASUREMENT En_injecteur_a_co_sortie_
			"En_injecteur_a_co_sortie"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7B95
		/end MEASUREMENT
		/begin MEASUREMENT En_injecteur_b_cc_sortie
			"En_injecteur_b_cc_sortie"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7B96
		/end MEASUREMENT
		/begin MEASUREMENT En_injecteur_b_co_sortie_
			"En_injecteur_b_co_sortie"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7B97
		/end MEASUREMENT
		/begin MEASUREMENT En_injecteur_c_cc_sortie
			"En_injecteur_c_cc_sortie"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7B98
		/end MEASUREMENT
		/begin MEASUREMENT En_injecteur_c_co_sortie_
			"En_injecteur_c_co_sortie"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7B99
		/end MEASUREMENT
		/begin MEASUREMENT En_injecteur_d_cc_sortie
			"En_injecteur_d_cc_sortie"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7B9A
		/end MEASUREMENT
		/begin MEASUREMENT En_injecteur_d_co_sortie_
			"En_injecteur_d_co_sortie"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7B9B
		/end MEASUREMENT
		/begin MEASUREMENT En_sonde_o2_am_1_result_ad_conv_
			"En_sonde_o2_am_1_result_ad_conv"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFFF808
		/end MEASUREMENT
		/begin MEASUREMENT En_sonde_o2_av_1_result_ad_conv_
			"En_sonde_o2_av_1_result_ad_conv"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFFF848
		/end MEASUREMENT
		/begin MEASUREMENT Enable_pre_injection
			"Enable_pre_injection"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7B9C
		/end MEASUREMENT
		/begin MEASUREMENT Engine_dpalt_para
			"Engine_dpalt_para"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7F02
		/end MEASUREMENT
		/begin MEASUREMENT Engine_speed_2_bkpt_
			"Engine_speed_2_bkpt"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF8108
		/end MEASUREMENT
		/begin MEASUREMENT Engine_speed_3_bkpt_
			"Engine_speed_3_bkpt"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF810A
		/end MEASUREMENT
		/begin MEASUREMENT Engine_speed_para_
			"Engine_speed_para"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF810C
		/end MEASUREMENT
		/begin MEASUREMENT Engine_speed_vvt_para_
			"Engine_speed_vvt_para"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF810E
		/end MEASUREMENT
		/begin MEASUREMENT Erreur_bus_can_
			"Erreur_bus_can"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E56
		/end MEASUREMENT
		/begin MEASUREMENT Erreur_eeprom_op
			"Erreur_eeprom_op"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF82B3
		/end MEASUREMENT
		/begin MEASUREMENT Erreur_somme_clq_prev0_1
			"Erreur_somme_clq_prev0_1"
			SWORD
			Id_0x00
			2
			2
			-32768
			32767
			ECU_ADDRESS 0xFFFF7494
		/end MEASUREMENT
		/begin MEASUREMENT Erreur_somme_clq_prev0_2
			"Erreur_somme_clq_prev0_2"
			SWORD
			Id_0x00
			2
			2
			-32768
			32767
			ECU_ADDRESS 0xFFFF749A
		/end MEASUREMENT
		/begin MEASUREMENT Erreur_somme_clq_prev0_3
			"Erreur_somme_clq_prev0_3"
			SWORD
			Id_0x00
			2
			2
			-32768
			32767
			ECU_ADDRESS 0xFFFF7496
		/end MEASUREMENT
		/begin MEASUREMENT Erreur_somme_clq_prev0_4
			"Erreur_somme_clq_prev0_4"
			SWORD
			Id_0x00
			2
			2
			-32768
			32767
			ECU_ADDRESS 0xFFFF7498
		/end MEASUREMENT
		/begin MEASUREMENT Erreur_somme_clq_prev0_filtree1
			"Erreur_somme_clq_prev0_filtree1"
			SWORD
			Id_0x00
			2
			2
			-32768
			32767
			ECU_ADDRESS 0xFFFF749C
		/end MEASUREMENT
		/begin MEASUREMENT Erreur_somme_clq_prev0_filtree2
			"Erreur_somme_clq_prev0_filtree2"
			SWORD
			Id_0x00
			2
			2
			-32768
			32767
			ECU_ADDRESS 0xFFFF74A2
		/end MEASUREMENT
		/begin MEASUREMENT Erreur_somme_clq_prev0_filtree3
			"Erreur_somme_clq_prev0_filtree3"
			SWORD
			Id_0x00
			2
			2
			-32768
			32767
			ECU_ADDRESS 0xFFFF749E
		/end MEASUREMENT
		/begin MEASUREMENT Erreur_somme_clq_prev0_filtree4
			"Erreur_somme_clq_prev0_filtree4"
			SWORD
			Id_0x00
			2
			2
			-32768
			32767
			ECU_ADDRESS 0xFFFF74A0
		/end MEASUREMENT
		/begin MEASUREMENT Erreur_somme_clq_prev1_filtree1
			"Erreur_somme_clq_prev1_filtree1"
			SWORD
			Id_0x00
			2
			2
			-32768
			32767
			ECU_ADDRESS 0xFFFF74A4
		/end MEASUREMENT
		/begin MEASUREMENT Erreur_somme_clq_prev1_filtree2
			"Erreur_somme_clq_prev1_filtree2"
			SWORD
			Id_0x00
			2
			2
			-32768
			32767
			ECU_ADDRESS 0xFFFF74AA
		/end MEASUREMENT
		/begin MEASUREMENT Erreur_somme_clq_prev1_filtree3
			"Erreur_somme_clq_prev1_filtree3"
			SWORD
			Id_0x00
			2
			2
			-32768
			32767
			ECU_ADDRESS 0xFFFF74A6
		/end MEASUREMENT
		/begin MEASUREMENT Erreur_somme_clq_prev1_filtree4
			"Erreur_somme_clq_prev1_filtree4"
			SWORD
			Id_0x00
			2
			2
			-32768
			32767
			ECU_ADDRESS 0xFFFF74A4
		/end MEASUREMENT
		/begin MEASUREMENT Error_alarm
			"Error_alarm"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7E87
		/end MEASUREMENT
		/begin MEASUREMENT Etamotmx
			"Etat_moteur_mux"
			UBYTE
			Etamotmx_conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF72EE
		/end MEASUREMENT
		/begin MEASUREMENT Etamxinj
			"Ecu_status_inj"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF72EC
		/end MEASUREMENT
		/begin MEASUREMENT Etat_ac_out
			"Etat_ac_out"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF782E
		/end MEASUREMENT
		/begin MEASUREMENT Etat_adaptation_
			"Etat_adaptation"
			UBYTE
			Etat_adaptation__conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF7AA3
		/end MEASUREMENT
		/begin MEASUREMENT Etat_amorcage_rampe_gaz
			"Etat_amorcage_rampe_gaz"
			UBYTE
			Etat_amorcage_rampe_gaz_conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF7968
		/end MEASUREMENT
		/begin MEASUREMENT Etat_apprentissage
			"ETAT_APPRENTISSAGE"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x4
			ECU_ADDRESS 0xFFFF7AA3
		/end MEASUREMENT
		/begin MEASUREMENT Etat_automate_il
			"Etat_automate_il"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF73ED
		/end MEASUREMENT
		/begin MEASUREMENT Etat_av_dyn_
			"Etat_av_dyn"
			UBYTE
			Etat_av_dyn__conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF6D9B
		/end MEASUREMENT
		/begin MEASUREMENT Etat_avance_preced_dem
			"Etat_avance_preced_dem"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6D7B
		/end MEASUREMENT
		/begin MEASUREMENT Etat_calcul_adaptation
			"ETAT_CALCUL_ADAPTATION"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x8
			ECU_ADDRESS 0xFFFF7AA3
		/end MEASUREMENT
		/begin MEASUREMENT Etat_cond_rr_
			"Etat_cond_rr"
			UBYTE
			Etat_cond_rr__conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF79C0
		/end MEASUREMENT
		/begin MEASUREMENT Etat_condition_adaptation
			"ETAT_CONDITION_ADAPTATION"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x2
			ECU_ADDRESS 0xFFFF7AA3
		/end MEASUREMENT
		/begin MEASUREMENT Etat_connexion
			"Etat_connexion"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF86CE
		/end MEASUREMENT
		/begin MEASUREMENT Etat_contact_arrete_redep_
			"ETAT_CONTACT_ARRETE_REDEP"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF80DF
		/end MEASUREMENT
		/begin MEASUREMENT Etat_convertisseur_bva_i_1_
			"Etat_convertisseur_bva_i_1"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF72ED
		/end MEASUREMENT
		/begin MEASUREMENT Etat_demarrage_injection_redep_
			"ETAT_DEMARRAGE_INJECTION_REDEP"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x2
			ECU_ADDRESS 0xFFFF80DF
		/end MEASUREMENT
		/begin MEASUREMENT Etat_dep_mvac_insuffisante
			"Etat_dep_mvac_insuffisante"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF78E9
		/end MEASUREMENT
		/begin MEASUREMENT Etat_dep_mvac_suffisante
			"Etat_dep_mvac_suffisante"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF78EA
		/end MEASUREMENT
		/begin MEASUREMENT Etat_diag_bobine_a_c
			"Etat_diag_bobine_a_c"
			UBYTE
			Etat_diag_bobine_a_c_conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF6E0C
		/end MEASUREMENT
		/begin MEASUREMENT Etat_diag_bobine_b_d
			"Etat_diag_bobine_b_d"
			UBYTE
			Etat_diag_bobine_b_d_conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF6E0D
		/end MEASUREMENT
		/begin MEASUREMENT Etat_en_injecteur_a_cc_sortie
			"Etat_en_injecteur_a_cc_sortie"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF782F
		/end MEASUREMENT
		/begin MEASUREMENT Etat_en_injecteur_a_co_sortie
			"Etat_en_injecteur_a_co_sortie"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7830
		/end MEASUREMENT
		/begin MEASUREMENT Etat_en_injecteur_b_cc_sortie
			"Etat_en_injecteur_b_cc_sortie"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7831
		/end MEASUREMENT
		/begin MEASUREMENT Etat_en_injecteur_b_co_sortie
			"Etat_en_injecteur_b_co_sortie"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7832
		/end MEASUREMENT
		/begin MEASUREMENT Etat_en_injecteur_c_cc_sortie
			"Etat_en_injecteur_c_cc_sortie"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7833
		/end MEASUREMENT
		/begin MEASUREMENT Etat_en_injecteur_c_co_sortie
			"Etat_en_injecteur_c_co_sortie"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7834
		/end MEASUREMENT
		/begin MEASUREMENT Etat_en_injecteur_d_cc_sortie
			"Etat_en_injecteur_d_cc_sortie"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7835
		/end MEASUREMENT
		/begin MEASUREMENT Etat_en_injecteur_d_co_sortie
			"Etat_en_injecteur_d_co_sortie"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7836
		/end MEASUREMENT
		/begin MEASUREMENT Etat_hors_adaptation
			"ETAT_HORS_ADAPTATION"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7AA3
		/end MEASUREMENT
		/begin MEASUREMENT Etat_hors_phase_demarrage_redep_
			"ETAT_HORS_PHASE_DEMARRAGE_REDEP"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x4
			ECU_ADDRESS 0xFFFF80DF
		/end MEASUREMENT
		/begin MEASUREMENT Etat_inh_out_apres_hf_
			"Etat_inh_out_apres_hf"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7648
		/end MEASUREMENT
		/begin MEASUREMENT Etat_inh_pap_wtdg_input_apres_hf
			"Etat_inh_pap_wtdg_input_apres_hf"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7649
		/end MEASUREMENT
		/begin MEASUREMENT Etat_injecteur_a
			"Etat_injecteur_a"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7837
		/end MEASUREMENT
		/begin MEASUREMENT Etat_injecteur_b
			"Etat_injecteur_b"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7838
		/end MEASUREMENT
		/begin MEASUREMENT Etat_injecteur_c
			"Etat_injecteur_c"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7839
		/end MEASUREMENT
		/begin MEASUREMENT Etat_injecteur_d
			"Etat_injecteur_d"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF783A
		/end MEASUREMENT
		/begin MEASUREMENT Etat_mdf1
			"Etat_mdf1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF783B
		/end MEASUREMENT
		/begin MEASUREMENT Etat_mdf2
			"Etat_mdf2"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF783C
		/end MEASUREMENT
		/begin MEASUREMENT Etat_nagares
			"Etat_nagares"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF783D
		/end MEASUREMENT
		/begin MEASUREMENT Etat_obd_sondes_diagnostic_
			"ETAT_OBD_SONDES_DIAGNOSTIC"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x8
			ECU_ADDRESS 0xFFFF7DAE
		/end MEASUREMENT
		/begin MEASUREMENT Etat_obd_sondes_fin_de_diag_
			"ETAT_OBD_SONDES_FIN_DE_DIAG"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x10
			ECU_ADDRESS 0xFFFF7DAE
		/end MEASUREMENT
		/begin MEASUREMENT Etat_obd_sondes_hors_diagnostic_
			"ETAT_OBD_SONDES_HORS_DIAGNOSTIC"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7DAE
		/end MEASUREMENT
		/begin MEASUREMENT Etat_obd_sondes_mesures_
			"ETAT_OBD_SONDES_MESURES"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x4
			ECU_ADDRESS 0xFFFF7DAE
		/end MEASUREMENT
		/begin MEASUREMENT Etat_obd_sondes_stabilisation_
			"ETAT_OBD_SONDES_STABILISATION"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x2
			ECU_ADDRESS 0xFFFF7DAE
		/end MEASUREMENT
		/begin MEASUREMENT Etat_papmot_mode_banc
			"Etat_papmot_mode_banc"
			UBYTE
			Etat_papmot_mode_banc_conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF768A
		/end MEASUREMENT
		/begin MEASUREMENT Etat_power_latch_redep_
			"ETAT_POWER_LATCH_REDEP"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x8
			ECU_ADDRESS 0xFFFF80DF
		/end MEASUREMENT
		/begin MEASUREMENT Etat_prec_def_pap_niv_0_
			"Etat_prec_def_pap_niv_0"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6D7C
		/end MEASUREMENT
		/begin MEASUREMENT Etat_pressostat_da_prec_
			"Etat_pressostat_da_prec"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF79B2
		/end MEASUREMENT
		/begin MEASUREMENT Etat_relais_iae
			"Etat_relais_iae"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF783E
		/end MEASUREMENT
		/begin MEASUREMENT Etat_relais_pompe_essence
			"Etat_relais_pompe_essence"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF783F
		/end MEASUREMENT
		/begin MEASUREMENT Etat_requete_obd
			"Etat_requete_obd"
			UBYTE
			Etat_requete_obd_conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF75FE
		/end MEASUREMENT
		/begin MEASUREMENT Etat_reset_mux
			"Etat_reset_mux"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E6F
		/end MEASUREMENT
		/begin MEASUREMENT Etat_rl_mvac
			"Etat_rl_mvac"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7840
		/end MEASUREMENT
		/begin MEASUREMENT Etat_sequence_obd_
			"Etat_sequence_obd"
			UBYTE
			Etat_sequence_obd__conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF7D7D
		/end MEASUREMENT
		/begin MEASUREMENT Etat_sf_input_apres_hf_
			"Etat_sf_input_apres_hf"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF764A
		/end MEASUREMENT
		/begin MEASUREMENT Etat_sonde_amont_i_1_
			"Etat_sonde_amont_i_1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7E93
		/end MEASUREMENT
		/begin MEASUREMENT Etat_sous_automate_br_
			"Etat_sous_automate_br"
			UBYTE
			Etat_sous_automate_br__conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF7AA4
		/end MEASUREMENT
		/begin MEASUREMENT Etat_sous_automate_injection_
			"Etat_sous_automate_injection"
			UBYTE
			Etat_sous_automate_injection__conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF7AA5
		/end MEASUREMENT
		/begin MEASUREMENT Etat_vvt_adm
			"Etat_vvt_adm"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7841
		/end MEASUREMENT
		/begin MEASUREMENT Ev_iae_diag_enable
			"Ev_iae_diag_enable"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7842
		/end MEASUREMENT
		/begin MEASUREMENT Execute_inhibe_sdf_hseq_
			"Execute_inhibe_sdf_hseq"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF823E
		/end MEASUREMENT
		/begin MEASUREMENT Execute_test_prod_hseq_
			"Execute_test_prod_hseq"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF823F
		/end MEASUREMENT
		/begin MEASUREMENT Facteur_formatage_14
			"Facteur_formatage_14"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF74B2
		/end MEASUREMENT
		/begin MEASUREMENT Facteur_formatage_23
			"Facteur_formatage_23"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF74B4
		/end MEASUREMENT
		/begin MEASUREMENT Facteur_formatage_clq_num_cyl1
			"Facteur_formatage_clq_num_cyl1"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF74B6
		/end MEASUREMENT
		/begin MEASUREMENT Facteur_formatage_clq_num_cyl2
			"Facteur_formatage_clq_num_cyl2"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF74BC
		/end MEASUREMENT
		/begin MEASUREMENT Facteur_formatage_clq_num_cyl3
			"Facteur_formatage_clq_num_cyl3"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF74B8
		/end MEASUREMENT
		/begin MEASUREMENT Facteur_formatage_clq_num_cyl4
			"Facteur_formatage_clq_num_cyl4"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF74BA
		/end MEASUREMENT
		/begin MEASUREMENT Fenetre_cliquetis_num
			"Fenetre_cliquetis_num"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF746F
		/end MEASUREMENT
		/begin MEASUREMENT Fin_amorcage_rampe_gaz
			"FIN_AMORCAGE_RAMPE_GAZ"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x8
			ECU_ADDRESS 0xFFFF7968
		/end MEASUREMENT
		/begin MEASUREMENT Fin_app_b_basse
			"Fin_app_b_basse"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF764B
		/end MEASUREMENT
		/begin MEASUREMENT Fin_app_b_haute
			"Fin_app_b_haute"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF764C
		/end MEASUREMENT
		/begin MEASUREMENT Fin_app_lh
			"Fin_app_lh"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF764D
		/end MEASUREMENT
		/begin MEASUREMENT Fin_check_lh
			"Fin_check_lh"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF764E
		/end MEASUREMENT
		/begin MEASUREMENT Fin_check_springs
			"Fin_check_springs"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF764F
		/end MEASUREMENT
		/begin MEASUREMENT Fin_strategie_check_springs
			"FIN_STRATEGIE_CHECK_SPRINGS"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x10
			ECU_ADDRESS 0xFFFF7695
		/end MEASUREMENT
		/begin MEASUREMENT First_demarrage
			"First_demarrage"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF88CB
		/end MEASUREMENT
		/begin MEASUREMENT Flag_ccvbat_bobine_a_c
			"Flag_ccvbat_bobine_a_c"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6DF7
		/end MEASUREMENT
		/begin MEASUREMENT Flag_ccvbat_bobine_b_d
			"Flag_ccvbat_bobine_b_d"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6DF8
		/end MEASUREMENT
		/begin MEASUREMENT Flash_zone_nb
			"Flash_zone_nb"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7C0A
		/end MEASUREMENT
		/begin MEASUREMENT Flglentpl_
			"Flag_lent_pied_leve"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7FB1
		/end MEASUREMENT
		/begin MEASUREMENT Flgrappl_
			"Flag_rapide_pied_leve"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7FB2
		/end MEASUREMENT
		/begin MEASUREMENT Freeze_frame_priorite
			"Freeze_frame_priorite"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8622
		/end MEASUREMENT
		/begin MEASUREMENT Frein1mx
			"Vxx_brk1_mx"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF73B3
		/end MEASUREMENT
		/begin MEASUREMENT Freq_applique_purge_
			"Freq_applique_purge"
			UWORD
			D_2_0v0000032_p0v0000032_277
			2
			2
			4.768371582
			312500
			ECU_ADDRESS 0xFFFF80B6
		/end MEASUREMENT
		/begin MEASUREMENT Freq_capacom
			"Freq_capacom"
			UBYTE
			D_1_0v00005_p0_278
			2
			2
			78.43137255
			20000
			ECU_ADDRESS 0xFFFF7482
		/end MEASUREMENT
		/begin MEASUREMENT Freq_demande_purge_
			"Freq_demande_purge"
			UBYTE
			F_1_p0_162
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF80A6
		/end MEASUREMENT
		/begin MEASUREMENT Gain_batterie
			"Gain_batterie"
			SBYTE
			F_0v0009765625_p1_279
			2
			2
			0.875
			1.124023438
			ECU_ADDRESS 0xFFFF8A58
		/end MEASUREMENT
		/begin MEASUREMENT Gain_cliquetis_14
			"Gain_cliquetis_14"
			UBYTE
			F_0v0039_p0_171
			2
			2
			0
			0.9945
			ECU_ADDRESS 0xFFFF7483
		/end MEASUREMENT
		/begin MEASUREMENT Gain_cliquetis_23
			"Gain_cliquetis_23"
			UBYTE
			F_0v0039_p0_171
			2
			2
			0
			0.9945
			ECU_ADDRESS 0xFFFF7484
		/end MEASUREMENT
		/begin MEASUREMENT Gain_passe_bande
			"Gain_passe_bande"
			SBYTE
			Id_0x00
			2
			2
			-128
			127
			ECU_ADDRESS 0xFFFF7476
		/end MEASUREMENT
		/begin MEASUREMENT Get_condition_hte_temperat_eau
			"Get_condition_hte_temperat_eau"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF77A7
		/end MEASUREMENT
		/begin MEASUREMENT Get_condition_regime
			"Get_condition_regime"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF77A8
		/end MEASUREMENT
		/begin MEASUREMENT Get_condition_temperat_eau
			"Get_condition_temperat_eau"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF77A9
		/end MEASUREMENT
		/begin MEASUREMENT Gmv1_mot_arrete_
			"GMV1_MOT_ARRETE"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x2
			ECU_ADDRESS 0xFFFF792A
		/end MEASUREMENT
		/begin MEASUREMENT Gmv_mot_tournant_
			"GMV_MOT_TOURNANT"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x8
			ECU_ADDRESS 0xFFFF792A
		/end MEASUREMENT
		/begin MEASUREMENT Gpl_fct_ess
			"GPL_FCT_ESS"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x8
			ECU_ADDRESS 0xFFFF796E
		/end MEASUREMENT
		/begin MEASUREMENT Gpl_fct_gpl
			"GPL_FCT_GPL"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x10
			ECU_ADDRESS 0xFFFF796E
		/end MEASUREMENT
		/begin MEASUREMENT Gpl_mode_injection_ess
			"Gpl_mode_injection_ess"
			UBYTE
			Gpl_mode_injection_ess_conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF7969
		/end MEASUREMENT
		/begin MEASUREMENT Gpl_mode_injection_gpl
			"Gpl_mode_injection_gpl"
			UBYTE
			Gpl_mode_injection_gpl_conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF796A
		/end MEASUREMENT
		/begin MEASUREMENT High_load_condition_pos_pedale
			"High_load_condition_pos_pedale"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8084
		/end MEASUREMENT
		/begin MEASUREMENT High_load_condition_regime
			"High_load_condition_regime"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8085
		/end MEASUREMENT
		/begin MEASUREMENT High_load_condition_vitesse
			"High_load_condition_vitesse"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8086
		/end MEASUREMENT
		/begin MEASUREMENT Horloge_500micros
			"Horloge_500micros"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7C1E
		/end MEASUREMENT
		/begin MEASUREMENT Hors_phase_dem_seq_
			"HORS_PHASE_DEM_SEQ"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x10
			ECU_ADDRESS 0xFFFF7AB9
		/end MEASUREMENT
		/begin MEASUREMENT Hors_phase_dem_sfg_
			"HORS_PHASE_DEM_SFG"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x4
			ECU_ADDRESS 0xFFFF7AB9
		/end MEASUREMENT
		/begin MEASUREMENT Hors_purge_
			"HORS_PURGE"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF80A9
		/end MEASUREMENT
		/begin MEASUREMENT Hors_requete
			"HORS_REQUETE"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF75FE
		/end MEASUREMENT
		/begin MEASUREMENT Hystrap
			"Hyst_vitrap_reco_rapport"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF80C9
		/end MEASUREMENT
		/begin MEASUREMENT Icd_adapt_calc_a_c
			"Icd_adapt_calc_a_c"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6DF9
		/end MEASUREMENT
		/begin MEASUREMENT Icd_adapt_calc_b_d
			"Icd_adapt_calc_b_d"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6DFA
		/end MEASUREMENT
		/begin MEASUREMENT Icd_adapt_factor_a_c
			"Icd_adapt_factor_a_c"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF8634
		/end MEASUREMENT
		/begin MEASUREMENT Icd_adapt_factor_b_d
			"Icd_adapt_factor_b_d"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF8638
		/end MEASUREMENT
		/begin MEASUREMENT Icd_adapt_offset_a_c
			"Icd_adapt_offset_a_c"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF8636
		/end MEASUREMENT
		/begin MEASUREMENT Icd_adapt_offset_b_d
			"Icd_adapt_offset_b_d"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF863A
		/end MEASUREMENT
		/begin MEASUREMENT Icd_applied_energy_ratio_a_c_
			"Icd_applied_energy_ratio_a_c"
			UBYTE
			F_0v390625_p0_4
			2
			2
			0
			99.609375
			ECU_ADDRESS 0xFFFF6E0E
		/end MEASUREMENT
		/begin MEASUREMENT Icd_applied_energy_ratio_b_d_
			"Icd_applied_energy_ratio_b_d"
			UBYTE
			F_0v390625_p0_4
			2
			2
			0
			99.609375
			ECU_ADDRESS 0xFFFF6E0F
		/end MEASUREMENT
		/begin MEASUREMENT Icd_boost_count
			"Icd_boost_count"
			UBYTE
			F_32_p0_122
			2
			2
			0
			8160
			ECU_ADDRESS 0xFFFF6E10
		/end MEASUREMENT
		/begin MEASUREMENT Icd_boost_load_status
			"Icd_boost_load_status"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6DFB
		/end MEASUREMENT
		/begin MEASUREMENT Icd_boost_transient_status
			"Icd_boost_transient_status"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6DFC
		/end MEASUREMENT
		/begin MEASUREMENT Icd_diagnostic_enabled_
			"Icd_diagnostic_enabled"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6DFD
		/end MEASUREMENT
		/begin MEASUREMENT Icd_igbt_fdbk_gain_a
			"Icd_igbt_fdbk_gain_a"
			SBYTE
			Id_0x00
			2
			2
			-128
			127
			ECU_ADDRESS 0xFFFF8A5A
		/end MEASUREMENT
		/begin MEASUREMENT Icd_igbt_fdbk_gain_a_c
			"Icd_igbt_fdbk_gain_a_c"
			SBYTE
			Id_0x00
			2
			2
			-128
			127
			ECU_ADDRESS 0xFFFF8A5E
		/end MEASUREMENT
		/begin MEASUREMENT Icd_igbt_fdbk_gain_a_c_phys
			"Icd_igbt_fdbk_gain_a_c_phys"
			SBYTE
			Id_0x00
			2
			2
			-128
			127
			ECU_ADDRESS 0xFFFF8A60
		/end MEASUREMENT
		/begin MEASUREMENT Icd_igbt_fdbk_gain_b
			"Icd_igbt_fdbk_gain_b"
			SBYTE
			Id_0x00
			2
			2
			-128
			127
			ECU_ADDRESS 0xFFFF8A5B
		/end MEASUREMENT
		/begin MEASUREMENT Icd_igbt_fdbk_gain_b_d
			"Icd_igbt_fdbk_gain_b_d"
			SBYTE
			Id_0x00
			2
			2
			-128
			127
			ECU_ADDRESS 0xFFFF8A5F
		/end MEASUREMENT
		/begin MEASUREMENT Icd_igbt_fdbk_gain_b_d_phys
			"Icd_igbt_fdbk_gain_b_d_phys"
			SBYTE
			Id_0x00
			2
			2
			-128
			127
			ECU_ADDRESS 0xFFFF8A61
		/end MEASUREMENT
		/begin MEASUREMENT Icd_igbt_fdbk_gain_c
			"Icd_igbt_fdbk_gain_c"
			SBYTE
			Id_0x00
			2
			2
			-128
			127
			ECU_ADDRESS 0xFFFF8A5C
		/end MEASUREMENT
		/begin MEASUREMENT Icd_igbt_fdbk_gain_d
			"Icd_igbt_fdbk_gain_d"
			SBYTE
			Id_0x00
			2
			2
			-128
			127
			ECU_ADDRESS 0xFFFF8A5D
		/end MEASUREMENT
		/begin MEASUREMENT Icd_ratio_energy_
			"Icd_ratio_energy"
			UBYTE
			F_0v390625_p0_4
			2
			2
			0
			99.609375
			ECU_ADDRESS 0xFFFF6E11
		/end MEASUREMENT
		/begin MEASUREMENT Icd_state
			"Icd_state"
			UBYTE
			Icd_state_conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF6E12
		/end MEASUREMENT
		/begin MEASUREMENT Icd_time_slope_1_a_c
			"Icd_time_slope_1_a_c"
			UWORD
			F_0v0032_p0_8
			2
			2
			0
			209.712
			ECU_ADDRESS 0xFFFF6E3A
		/end MEASUREMENT
		/begin MEASUREMENT Icd_time_slope_1_b_d
			"Icd_time_slope_1_b_d"
			UWORD
			F_0v0032_p0_8
			2
			2
			0
			209.712
			ECU_ADDRESS 0xFFFF6E3C
		/end MEASUREMENT
		/begin MEASUREMENT Icd_time_slope_2_a_c
			"Icd_time_slope_2_a_c"
			UWORD
			F_0v0032_p0_8
			2
			2
			0
			209.712
			ECU_ADDRESS 0xFFFF6E3E
		/end MEASUREMENT
		/begin MEASUREMENT Icd_time_slope_2_b_d
			"Icd_time_slope_2_b_d"
			UWORD
			F_0v0032_p0_8
			2
			2
			0
			209.712
			ECU_ADDRESS 0xFFFF6E40
		/end MEASUREMENT
		/begin MEASUREMENT Icd_twin_adapt
			"ICD_TWIN_ADAPT"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x2
			ECU_ADDRESS 0xFFFF6E12
		/end MEASUREMENT
		/begin MEASUREMENT Icd_twin_fixed
			"ICD_TWIN_FIXED"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E12
		/end MEASUREMENT
		/begin MEASUREMENT Icd_voltage_max_energy_a_c
			"Icd_voltage_max_energy_a_c"
			UBYTE
			F_4v8828125_p0_11
			2
			2
			0
			1245.117188
			ECU_ADDRESS 0xFFFF6E13
		/end MEASUREMENT
		/begin MEASUREMENT Icd_voltage_max_energy_b_d
			"Icd_voltage_max_energy_b_d"
			UBYTE
			F_4v8828125_p0_11
			2
			2
			0
			1245.117188
			ECU_ADDRESS 0xFFFF6E14
		/end MEASUREMENT
		/begin MEASUREMENT Icd_voltage_slope_1_a_c
			"Icd_voltage_slope_1_a_c"
			UWORD
			F_4v8828125_p0_11
			2
			2
			0
			319995.1172
			ECU_ADDRESS 0xFFFF6E42
		/end MEASUREMENT
		/begin MEASUREMENT Icd_voltage_slope_1_b_d
			"Icd_voltage_slope_1_b_d"
			UWORD
			F_4v8828125_p0_11
			2
			2
			0
			319995.1172
			ECU_ADDRESS 0xFFFF6E44
		/end MEASUREMENT
		/begin MEASUREMENT Icd_voltage_slope_2_a_c
			"Icd_voltage_slope_2_a_c"
			UWORD
			F_4v8828125_p0_11
			2
			2
			0
			319995.1172
			ECU_ADDRESS 0xFFFF6E46
		/end MEASUREMENT
		/begin MEASUREMENT Icd_voltage_slope_2_b_d
			"Icd_voltage_slope_2_b_d"
			UWORD
			F_4v8828125_p0_11
			2
			2
			0
			319995.1172
			ECU_ADDRESS 0xFFFF6E48
		/end MEASUREMENT
		/begin MEASUREMENT Identifiant_message_mcp_
			"Identifiant_message_mcp"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8264
		/end MEASUREMENT
		/begin MEASUREMENT Identifiant_message_trig_mcp_
			"Identifiant_message_trig_mcp"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8265
		/end MEASUREMENT
		/begin MEASUREMENT Identification
			"Identification"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0x8914
		/end MEASUREMENT
		/begin MEASUREMENT Idx_lecture_dtc
			"Idx_lecture_dtc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF75FF
		/end MEASUREMENT
		/begin MEASUREMENT Il_timer
			"Il_timer"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF73EE
		/end MEASUREMENT
		/begin MEASUREMENT Il_timer_value
			"Il_timer_value"
			UWORD
			F_8_p0_56
			2
			2
			0
			524280
			ECU_ADDRESS 0xFFFF73F0
		/end MEASUREMENT
		/begin MEASUREMENT Illegal_instruction
			"Illegal_instruction"
			ULONG
			Id_0x00
			2
			2
			0
			4294967295
			ECU_ADDRESS 0xFFFF650C
		/end MEASUREMENT
		/begin MEASUREMENT Illegal_instruction_eep
			"Illegal_instruction_eep"
			ULONG
			Id_0x00
			2
			2
			0
			4294967295
			ECU_ADDRESS 0xFFFF7BF0
		/end MEASUREMENT
		/begin MEASUREMENT Illegal_instruction_eep_lsb
			"Illegal_instruction_eep_lsb"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF8940
		/end MEASUREMENT
		/begin MEASUREMENT Illegal_instruction_eep_msb
			"Illegal_instruction_eep_msb"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF893E
		/end MEASUREMENT
		/begin MEASUREMENT Image_rapport_de_boite_filtre_1_
			"Image_rapport_de_boite_filtre_1"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF80D4
		/end MEASUREMENT
		/begin MEASUREMENT Image_rapport_de_boite_mux_1
			"Image_rapport_de_boite_mux_1"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF80CA
		/end MEASUREMENT
		/begin MEASUREMENT Incrementation_pression_
			"INCREMENTATION_PRESSION"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x10
			ECU_ADDRESS 0xFFFF833E
		/end MEASUREMENT
		/begin MEASUREMENT Ind_fct_srbl
			"Ind_fct_srbl"
			SBYTE
			Id_0x00
			2
			2
			-128
			127
			ECU_ADDRESS 0xFFFF75D0
		/end MEASUREMENT
		/begin MEASUREMENT Index_tab_duree_dent
			"Index_tab_duree_dent"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7FA0
		/end MEASUREMENT
		/begin MEASUREMENT Index_tab_vect_test_mcp_
			"Index_tab_vect_test_mcp"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8266
		/end MEASUREMENT
		/begin MEASUREMENT Indice_porta
			"Indice_porta"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7C30
		/end MEASUREMENT
		/begin MEASUREMENT Indice_portb
			"Indice_portb"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7C31
		/end MEASUREMENT
		/begin MEASUREMENT Indice_portc
			"Indice_portc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7C32
		/end MEASUREMENT
		/begin MEASUREMENT Indice_portd
			"Indice_portd"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7C33
		/end MEASUREMENT
		/begin MEASUREMENT Indice_porte
			"Indice_porte"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7C34
		/end MEASUREMENT
		/begin MEASUREMENT Indice_portf
			"Indice_portf"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7C35
		/end MEASUREMENT
		/begin MEASUREMENT Indice_portg
			"Indice_portg"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7C36
		/end MEASUREMENT
		/begin MEASUREMENT Indice_porth
			"Indice_porth"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7C37
		/end MEASUREMENT
		/begin MEASUREMENT Indice_portj
			"Indice_portj"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7C38
		/end MEASUREMENT
		/begin MEASUREMENT Indice_portk
			"Indice_portk"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7C39
		/end MEASUREMENT
		/begin MEASUREMENT Indice_portl
			"Indice_portl"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7C3A
		/end MEASUREMENT
		/begin MEASUREMENT Indice_sequencement
			"Indice_sequencement"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8267
		/end MEASUREMENT
		/begin MEASUREMENT Indice_table_buffer
			"Indice_table_buffer"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8268
		/end MEASUREMENT
		/begin MEASUREMENT Indpmhk
			"Indice_pmh_k"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7485
		/end MEASUREMENT
		/begin MEASUREMENT Info_niveau_mini_carb_mux_prec_
			"Info_niveau_mini_carb_mux_prec"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E70
		/end MEASUREMENT
		/begin MEASUREMENT Info_niveau_mini_gpl_mux_prec
			"Info_niveau_mini_gpl_mux_prec"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E71
		/end MEASUREMENT
		/begin MEASUREMENT Inftyp
			"Inftyp"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7601
		/end MEASUREMENT
		/begin MEASUREMENT Inhib_can_dec_abs_
			"Inhib_can_dec_abs"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF73AC
		/end MEASUREMENT
		/begin MEASUREMENT Inhib_can_dec_acc
			"Inhib_can_dec_acc"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF73C0
		/end MEASUREMENT
		/begin MEASUREMENT Inhib_can_dec_busoff_
			"Inhib_can_dec_busoff"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E72
		/end MEASUREMENT
		/begin MEASUREMENT Inhib_can_dec_bva_
			"Inhib_can_dec_bva"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF73C9
		/end MEASUREMENT
		/begin MEASUREMENT Inhib_can_dec_clm
			"Inhib_can_dec_clm"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF73E0
		/end MEASUREMENT
		/begin MEASUREMENT Inhib_can_dec_gpl
			"Inhib_can_dec_gpl"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF73F4
		/end MEASUREMENT
		/begin MEASUREMENT Inhib_can_dec_mute_
			"Inhib_can_dec_mute"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E73
		/end MEASUREMENT
		/begin MEASUREMENT Inhib_can_dec_tdb_
			"Inhib_can_dec_tdb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7410
		/end MEASUREMENT
		/begin MEASUREMENT Inhib_can_dec_uch_
			"Inhib_can_dec_uch"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF741F
		/end MEASUREMENT
		/begin MEASUREMENT Inhibition_correction_
			"INHIBITION_CORRECTION"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8324
		/end MEASUREMENT
		/begin MEASUREMENT Inhibition_detection
			"Inhibition_detection"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7650
		/end MEASUREMENT
		/begin MEASUREMENT Inhibition_detection_prec
			"Inhibition_detection_prec"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7651
		/end MEASUREMENT
		/begin MEASUREMENT Inhibtion_diag_huile
			"Inhibtion_diag_huile"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7C29
		/end MEASUREMENT
		/begin MEASUREMENT Init_amorcage_rampe_gaz
			"INIT_AMORCAGE_RAMPE_GAZ"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7968
		/end MEASUREMENT
		/begin MEASUREMENT Init_capcom_diag_chauff_gpl_gnv
			"Init_capcom_diag_chauff_gpl_gnv"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7E94
		/end MEASUREMENT
		/begin MEASUREMENT Init_capcom_diag_chauff_sonde_dw
			"Init_capcom_diag_chauff_sonde_dw"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7E95
		/end MEASUREMENT
		/begin MEASUREMENT Init_capcom_diag_chauff_sonde_up
			"Init_capcom_diag_chauff_sonde_up"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7E96
		/end MEASUREMENT
		/begin MEASUREMENT Init_cumul_erreur
			"Init_cumul_erreur"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7652
		/end MEASUREMENT
		/begin MEASUREMENT Init_cumul_erreur_prec
			"Init_cumul_erreur_prec"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7653
		/end MEASUREMENT
		/begin MEASUREMENT Init_cyl_actifs
			"INIT_CYL_ACTIFS"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8329
		/end MEASUREMENT
		/begin MEASUREMENT Init_vxx_gear_cge_l_tq_dly
			"Init_vxx_gear_cge_l_tq_dly"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF78B2
		/end MEASUREMENT
		/begin MEASUREMENT Init_vxx_gear_cge_l_tq_dly_prec
			"Init_vxx_gear_cge_l_tq_dly_prec"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF78B3
		/end MEASUREMENT
		/begin MEASUREMENT Init_wg_int_adaptatif_memo
			"Init_wg_int_adaptatif_memo"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7602
		/end MEASUREMENT
		/begin MEASUREMENT Initdynpl_
			"Init_dyn_pied_leve"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7FB3
		/end MEASUREMENT
		/begin MEASUREMENT Injades_
			"Injecteur_a_desactiver"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7AA7
		/end MEASUREMENT
		/begin MEASUREMENT Injecteur_a_
			"Injecteur_a"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7B9D
		/end MEASUREMENT
		/begin MEASUREMENT Injecteur_b_
			"Injecteur_b"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7B9E
		/end MEASUREMENT
		/begin MEASUREMENT Injecteur_c_
			"Injecteur_c"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7B9F
		/end MEASUREMENT
		/begin MEASUREMENT Injecteur_d_
			"Injecteur_d"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7BA0
		/end MEASUREMENT
		/begin MEASUREMENT Interdit_trig_it_dent_ref
			"Interdit_trig_it_dent_ref"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6BA9
		/end MEASUREMENT
		/begin MEASUREMENT Interp_teau_post_inj_
			"Interp_teau_post_inj"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7AA8
		/end MEASUREMENT
		/begin MEASUREMENT It_dent_enable
			"It_dent_enable"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7F1D
		/end MEASUREMENT
		/begin MEASUREMENT Keyresp
			"Clef_ou_reponse"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF741E
		/end MEASUREMENT
		/begin MEASUREMENT Largeur_fenetre_1
			"Largeur_fenetre_1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7470
		/end MEASUREMENT
		/begin MEASUREMENT Largeur_fenetre_2
			"Largeur_fenetre_2"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7471
		/end MEASUREMENT
		/begin MEASUREMENT Largeur_fenetre_3
			"Largeur_fenetre_3"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7472
		/end MEASUREMENT
		/begin MEASUREMENT Lissage_parametre_vvt
			"Lissage_parametre_vvt"
			UWORD
			F_0v0596046_p0_257
			2
			2
			0
			3906.187461
			ECU_ADDRESS 0xFFFF802C
		/end MEASUREMENT
		/begin MEASUREMENT Longueur_a_transmettre_
			"Longueur_a_transmettre"
			SBYTE
			Id_0x00
			2
			2
			-128
			127
			ECU_ADDRESS 0xFFFF75D1
		/end MEASUREMENT
		/begin MEASUREMENT Longueur_message_
			"Longueur_message"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7603
		/end MEASUREMENT
		/begin MEASUREMENT Lshd_dw_current_voltage_filt_
			"Lshd_dw_current_voltage_filt"
			UWORD
			F_0v00488_p0_285
			2
			2
			0
			319.8108
			ECU_ADDRESS 0xFFFF7EDC
		/end MEASUREMENT
		/begin MEASUREMENT Lshd_dw_diag_compteur_
			"Lshd_dw_diag_compteur"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7EB7
		/end MEASUREMENT
		/begin MEASUREMENT Lshd_dw_engine_running_compteur_
			"Lshd_dw_engine_running_compteur"
			UBYTE
			F_4096_p0_286
			2
			2
			0
			1044480
			ECU_ADDRESS 0xFFFF7EB8
		/end MEASUREMENT
		/begin MEASUREMENT Lshd_dw_resistance_trim
			"Lshd_dw_resistance_trim"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF8A62
		/end MEASUREMENT
		/begin MEASUREMENT Lshd_dw_voltage_1_result_ad_conv
			"Lshd_dw_voltage_1_result_ad_conv"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFFF840
		/end MEASUREMENT
		/begin MEASUREMENT Lshd_up_current_voltage_filt_
			"Lshd_up_current_voltage_filt"
			UWORD
			F_0v00488_p0_285
			2
			2
			0
			319.8108
			ECU_ADDRESS 0xFFFF7EDE
		/end MEASUREMENT
		/begin MEASUREMENT Lshd_up_diag_compteur_
			"Lshd_up_diag_compteur"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7EE0
		/end MEASUREMENT
		/begin MEASUREMENT Lshd_up_engine_running_compteur
			"Lshd_up_engine_running_compteur"
			UBYTE
			F_4v096_p0_12
			2
			2
			0
			1044.48
			ECU_ADDRESS 0xFFFF7EB9
		/end MEASUREMENT
		/begin MEASUREMENT Lshd_up_resistance_reference
			"Lshd_up_resistance_reference"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF8A64
		/end MEASUREMENT
		/begin MEASUREMENT Lshd_up_voltage_1_result_ad_conv
			"Lshd_up_voltage_1_result_ad_conv"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFFF830
		/end MEASUREMENT
		/begin MEASUREMENT Maint_pompe_air
			"MAINT_POMPE_AIR"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x8
			ECU_ADDRESS 0xFFFF84B6
		/end MEASUREMENT
		/begin MEASUREMENT Marqueur_eeprom
			"Marqueur_eeprom"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF86A8
		/end MEASUREMENT
		/begin MEASUREMENT Mask_inhibe_sdf_
			"Mask_inhibe_sdf"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8269
		/end MEASUREMENT
		/begin MEASUREMENT Max_retrait_pda_
			"Max_retrait_pda"
			UBYTE
			F_0v375_p0_29
			2
			2
			0
			95.625
			ECU_ADDRESS 0xFFFF6D9C
		/end MEASUREMENT
		/begin MEASUREMENT Maxi_corr_int_
			"Maxi_corr_int"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF79DC
		/end MEASUREMENT
		/begin MEASUREMENT Memo_panne_msfcat_lpg_mem_obd
			"Memo_panne_msfcat_lpg_mem_obd"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7CEE
		/end MEASUREMENT
		/begin MEASUREMENT Memo_panne_msfcat_mem_obd
			"Memo_panne_msfcat_mem_obd"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7CEF
		/end MEASUREMENT
		/begin MEASUREMENT Memo_panne_msfpol_lpg_mem_obd
			"Memo_panne_msfpol_lpg_mem_obd"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7CF0
		/end MEASUREMENT
		/begin MEASUREMENT Memo_panne_msfpol_mem_obd
			"Memo_panne_msfpol_mem_obd"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7CF1
		/end MEASUREMENT
		/begin MEASUREMENT Memo_rephase_obd_msf_
			"Memo_rephase_obd_msf"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7CF2
		/end MEASUREMENT
		/begin MEASUREMENT Message_micro_wtdg_en_cours
			"Message_micro_wtdg_en_cours"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8240
		/end MEASUREMENT
		/begin MEASUREMENT Misfire_1_sur_4_detecte_i_1_
			"Misfire_1_sur_4_detecte_i_1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7CF3
		/end MEASUREMENT
		/begin MEASUREMENT Misfire_1_sur_4_detecte_i_2_
			"Misfire_1_sur_4_detecte_i_2"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7CF4
		/end MEASUREMENT
		/begin MEASUREMENT Misfire_bobine_a
			"Misfire_bobine_a"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6DFE
		/end MEASUREMENT
		/begin MEASUREMENT Misfire_bobine_b
			"Misfire_bobine_b"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6DFF
		/end MEASUREMENT
		/begin MEASUREMENT Misfire_bobine_c
			"Misfire_bobine_c"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E00
		/end MEASUREMENT
		/begin MEASUREMENT Misfire_bobine_d
			"Misfire_bobine_d"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E01
		/end MEASUREMENT
		/begin MEASUREMENT Mode_a_determiner_gpl
			"MODE_A_DETERMINER_GPL"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x20
			ECU_ADDRESS 0xFFFF796A
		/end MEASUREMENT
		/begin MEASUREMENT Mode_diag_selectionne_
			"Mode_diag_selectionne"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7604
		/end MEASUREMENT
		/begin MEASUREMENT Mot_d_etat_mcp
			"Mot_d_etat_mcp"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF826A
		/end MEASUREMENT
		/begin MEASUREMENT Mot_d_etat_mcw
			"Mot_d_etat_mcw"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF826B
		/end MEASUREMENT
		/begin MEASUREMENT Muce1
			"Etat_uce_1"
			UBYTE
			F_1_p0_9
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF72EF
		/end MEASUREMENT
		/begin MEASUREMENT Muce10
			"Etat_uce_10"
			UBYTE
			F_1_p0_9
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF72F0
		/end MEASUREMENT
		/begin MEASUREMENT Muce11
			"Etat_uce_11"
			UBYTE
			F_1_p0_9
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF72F1
		/end MEASUREMENT
		/begin MEASUREMENT Muce12
			"Etat_uce_12"
			UBYTE
			F_1_p0_9
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF72F2
		/end MEASUREMENT
		/begin MEASUREMENT Muce13
			"Etat_uce_13"
			UBYTE
			F_1_p0_9
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF72F3
		/end MEASUREMENT
		/begin MEASUREMENT Muce14
			"Etat_uce_14"
			UBYTE
			F_1_p0_9
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF72F4
		/end MEASUREMENT
		/begin MEASUREMENT Muce15
			"Etat_uce_15"
			UBYTE
			F_1_p0_9
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF72F5
		/end MEASUREMENT
		/begin MEASUREMENT Muce16
			"Etat_uce_16"
			UBYTE
			F_1_p0_9
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF72F6
		/end MEASUREMENT
		/begin MEASUREMENT Muce17
			"Etat_uce_17"
			UBYTE
			F_1_p0_9
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF72F7
		/end MEASUREMENT
		/begin MEASUREMENT Muce18
			"Etat_uce_18"
			UBYTE
			F_1_p0_9
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF72F8
		/end MEASUREMENT
		/begin MEASUREMENT Muce19
			"Etat_uce_19"
			UBYTE
			F_1_p0_9
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF72F9
		/end MEASUREMENT
		/begin MEASUREMENT Muce2
			"Etat_uce_2"
			UBYTE
			F_1_p0_9
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF72FA
		/end MEASUREMENT
		/begin MEASUREMENT Muce20
			"Etat_uce_20"
			UBYTE
			F_1_p0_9
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF72FB
		/end MEASUREMENT
		/begin MEASUREMENT Muce21
			"Etat_uce_21"
			UBYTE
			F_1_p0_9
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF72FC
		/end MEASUREMENT
		/begin MEASUREMENT Muce22
			"Etat_uce_22"
			UBYTE
			F_1_p0_9
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF72FD
		/end MEASUREMENT
		/begin MEASUREMENT Muce23
			"Etat_uce_23"
			UBYTE
			F_1_p0_9
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF72FE
		/end MEASUREMENT
		/begin MEASUREMENT Muce24
			"Etat_uce_24"
			UBYTE
			F_1_p0_9
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF72FF
		/end MEASUREMENT
		/begin MEASUREMENT Muce3
			"Etat_uce_3"
			UBYTE
			F_1_p0_9
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7300
		/end MEASUREMENT
		/begin MEASUREMENT Muce4
			"Etat_uce_4"
			UBYTE
			F_1_p0_9
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7301
		/end MEASUREMENT
		/begin MEASUREMENT Muce5
			"Etat_uce_5"
			UBYTE
			F_1_p0_9
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7302
		/end MEASUREMENT
		/begin MEASUREMENT Muce6
			"Etat_uce_6"
			UBYTE
			F_1_p0_9
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7303
		/end MEASUREMENT
		/begin MEASUREMENT Muce7
			"Etat_uce_7"
			UBYTE
			F_1_p0_9
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7304
		/end MEASUREMENT
		/begin MEASUREMENT Muce8
			"Etat_uce_8"
			UBYTE
			F_1_p0_9
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7305
		/end MEASUREMENT
		/begin MEASUREMENT Muce9
			"Etat_uce_9"
			UBYTE
			F_1_p0_9
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7306
		/end MEASUREMENT
		/begin MEASUREMENT Nb_acq_inh_in_wtdg_bf_
			"Nb_acq_inh_in_wtdg_bf"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF768B
		/end MEASUREMENT
		/begin MEASUREMENT Nb_acq_inh_out_bf_
			"Nb_acq_inh_out_bf"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF768C
		/end MEASUREMENT
		/begin MEASUREMENT Nb_acq_sf_in_bf_
			"Nb_acq_sf_in_bf"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF768D
		/end MEASUREMENT
		/begin MEASUREMENT Nb_allum_bobine_msf_
			"Nb_allum_bobine_msf"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6E15
		/end MEASUREMENT
		/begin MEASUREMENT Nb_calc_rco_on_sonde_amont_
			"Nb_calc_rco_on_sonde_amont"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7EBA
		/end MEASUREMENT
		/begin MEASUREMENT Nb_calc_rco_on_sonde_aval_
			"Nb_calc_rco_on_sonde_aval"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7EBB
		/end MEASUREMENT
		/begin MEASUREMENT Nb_condition_rr
			"Nb_condition_rr"
			UBYTE
			F_1_p0_9
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF84AC
		/end MEASUREMENT
		/begin MEASUREMENT Nb_coup_inj
			"Nb_coup_inj"
			UBYTE
			F_1_p0_9
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF84AD
		/end MEASUREMENT
		/begin MEASUREMENT Nb_cycle_test_actionneur
			"Nb_cycle_test_actionneur"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF82C9
		/end MEASUREMENT
		/begin MEASUREMENT Nb_dtc_system_torque
			"Nb_dtc_system_torque"
			UBYTE
			F_1_p0_9
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF84AE
		/end MEASUREMENT
		/begin MEASUREMENT Nb_max_phases_inj_a
			"Nb_max_phases_inj_a"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7BA5
		/end MEASUREMENT
		/begin MEASUREMENT Nb_max_phases_inj_b
			"Nb_max_phases_inj_b"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7BA6
		/end MEASUREMENT
		/begin MEASUREMENT Nb_max_phases_inj_c
			"Nb_max_phases_inj_c"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7BA7
		/end MEASUREMENT
		/begin MEASUREMENT Nb_max_phases_inj_d
			"Nb_max_phases_inj_d"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7BA8
		/end MEASUREMENT
		/begin MEASUREMENT Nb_papillon_a_fond_
			"Nb_papillon_a_fond"
			UBYTE
			F_1_p0_9
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7EFC
		/end MEASUREMENT
		/begin MEASUREMENT Nb_pmh_a_
			"Nb_pmh_a"
			UBYTE
			F_1_p0_53
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7AA9
		/end MEASUREMENT
		/begin MEASUREMENT Nb_position_ped_moy_
			"Nb_position_ped_moy"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7FBE
		/end MEASUREMENT
		/begin MEASUREMENT Nb_signaux_vitesse_mesures_
			"Nb_signaux_vitesse_mesures"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF828D
		/end MEASUREMENT
		/begin MEASUREMENT Nb_vf_dtc_stocke
			"Nb_vf_dtc_stocke"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8846
		/end MEASUREMENT
		/begin MEASUREMENT Needtool
			"Need_security_tool"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6BE7
		/end MEASUREMENT
		/begin MEASUREMENT No_fonction_can
			"No_fonction_can"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7307
		/end MEASUREMENT
		/begin MEASUREMENT Nombre_data_message
			"Nombre_data_message"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF826C
		/end MEASUREMENT
		/begin MEASUREMENT Nombre_dtc_a_transmettre
			"Nombre_dtc_a_transmettre"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7607
		/end MEASUREMENT
		/begin MEASUREMENT Nombre_echant_cliq
			"Nombre_echant_cliq"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF74BE
		/end MEASUREMENT
		/begin MEASUREMENT Nombre_echant_cliq_cyl1
			"Nombre_echant_cliq_cyl1"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF74C0
		/end MEASUREMENT
		/begin MEASUREMENT Nombre_echant_cliq_cyl2
			"Nombre_echant_cliq_cyl2"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF74C6
		/end MEASUREMENT
		/begin MEASUREMENT Nombre_echant_cliq_cyl3
			"Nombre_echant_cliq_cyl3"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF74C2
		/end MEASUREMENT
		/begin MEASUREMENT Nombre_echant_cliq_cyl4
			"Nombre_echant_cliq_cyl4"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF74C4
		/end MEASUREMENT
		/begin MEASUREMENT Non_active_incr_gain_correctif
			"Non_active_incr_gain_correctif"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF836E
		/end MEASUREMENT
		/begin MEASUREMENT Non_coupure_surpression_
			"NON_COUPURE_SURPRESSION"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x2
			ECU_ADDRESS 0xFFFF84AF
		/end MEASUREMENT
		/begin MEASUREMENT NON_DECISION
			"NON_DECISION"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6BD0
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_acr_bfr_clu
			"NSX_ACR_BFR_CLU"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7456
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_acr_bfr_dclu
			"NSX_ACR_BFR_DCLU"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7456
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_acr_clu
			"NSX_ACR_CLU"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x2
			ECU_ADDRESS 0xFFFF7456
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_acr_dclu
			"NSX_ACR_DCLU"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7456
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_act_cru
			"NSX_ACT_CRU"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x4
			ECU_ADDRESS 0xFFFF81D9
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_act_sl
			"NSX_ACT_SL"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x4
			ECU_ADDRESS 0xFFFF81DB
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_att_cond_pomp
			"NSX_ATT_COND_POMP"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x10
			ECU_ADDRESS 0xFFFF796B
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_att_coup
			"NSX_ATT_COUP"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF796B
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_att_coup_1024
			"NSX_ATT_COUP_1024"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x2
			ECU_ADDRESS 0xFFFF796B
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_cru
			"NSX_CRU"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x2
			ECU_ADDRESS 0xFFFF81D5
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_cru_raw
			"NSX_CRU_RAW"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x2
			ECU_ADDRESS 0xFFFF81D6
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_cru_sl_acel
			"NSX_CRU_SL_ACEL"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x20
			ECU_ADDRESS 0xFFFF81D8
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_cru_sl_decl
			"NSX_CRU_SL_DECL"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x10
			ECU_ADDRESS 0xFFFF81D8
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_cru_sl_nok_raw
			"NSX_CRU_SL_NOK_RAW"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF81D6
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_cru_sl_off
			"NSX_CRU_SL_OFF"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF81D5
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_cru_sl_off_raw
			"NSX_CRU_SL_OFF_RAW"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF81D6
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_cru_sl_open
			"NSX_CRU_SL_OPEN"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF81D8
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_cru_sl_resu
			"NSX_CRU_SL_RESU"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x4
			ECU_ADDRESS 0xFFFF81D8
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_cru_sl_rls
			"NSX_CRU_SL_RLS"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x2
			ECU_ADDRESS 0xFFFF81D8
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_cru_sl_susp
			"NSX_CRU_SL_SUSP"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x8
			ECU_ADDRESS 0xFFFF81D8
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_cru_sl_whl_nok
			"NSX_CRU_SL_WHL_NOK"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x80
			ECU_ADDRESS 0xFFFF81D8
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_cyl_cut_att
			"NSX_CYL_CUT_ATT"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D83
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_cyl_cut_dmd_verif
			"NSX_CYL_CUT_DMD_VERIF"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x2
			ECU_ADDRESS 0xFFFF7D83
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_cyl_cut_inactif
			"NSX_CYL_CUT_INACTIF"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D83
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_cyl_cut_verif_nok
			"NSX_CYL_CUT_VERIF_NOK"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D83
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_cyl_cut_verif_ok
			"NSX_CYL_CUT_VERIF_OK"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x4
			ECU_ADDRESS 0xFFFF7D83
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_dsb_cru
			"NSX_DSB_CRU"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF81D9
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_dsb_sl
			"NSX_DSB_SL"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF81DB
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_lpg_act_mod_req
			"NSX_LPG_ACT_MOD_REQ"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF796F
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_lpg_bfr_gas_lpg
			"NSX_LPG_BFR_GAS_LPG"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x4
			ECU_ADDRESS 0xFFFF7969
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_lpg_bfr_lpg_gas
			"NSX_LPG_BFR_LPG_GAS"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x4
			ECU_ADDRESS 0xFFFF796A
		/end MEASUREMENT
		/begin MEASUREMENT NSX_LPG_DEC_COUP_A
			"NSX_LPG_DEC_COUP_A"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x2
			ECU_ADDRESS 0xFFFF796C
		/end MEASUREMENT
		/begin MEASUREMENT NSX_LPG_DEC_COUP_B
			"NSX_LPG_DEC_COUP_B"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x4
			ECU_ADDRESS 0xFFFF796C
		/end MEASUREMENT
		/begin MEASUREMENT NSX_LPG_DEC_COUP_C
			"NSX_LPG_DEC_COUP_C"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x8
			ECU_ADDRESS 0xFFFF796C
		/end MEASUREMENT
		/begin MEASUREMENT NSX_LPG_DEC_COUP_D
			"NSX_LPG_DEC_COUP_D"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x10
			ECU_ADDRESS 0xFFFF796C
		/end MEASUREMENT
		/begin MEASUREMENT NSX_LPG_DEC_HC
			"NSX_LPG_DEC_HC"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF796C
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_lpg_eng_stop_gas
			"NSX_LPG_ENG_STOP_GAS"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF796E
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_lpg_eng_stop_gas_lpg
			"NSX_LPG_ENG_STOP_GAS_LPG"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x2
			ECU_ADDRESS 0xFFFF796E
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_lpg_eng_stop_lpg_mod
			"NSX_LPG_ENG_STOP_LPG_MOD"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x4
			ECU_ADDRESS 0xFFFF796E
		/end MEASUREMENT
		/begin MEASUREMENT NSX_LPG_FIN
			"NSX_LPG_FIN"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x20
			ECU_ADDRESS 0xFFFF796C
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_lpg_gas
			"NSX_LPG_GAS"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7969
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_lpg_gas_lih
			"NSX_LPG_GAS_LIH"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x10
			ECU_ADDRESS 0xFFFF7969
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_lpg_gas_lih_lpg_cdn
			"NSX_LPG_GAS_LIH_LPG_CDN"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF796D
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_lpg_gas_lih_lpg_cdn_ess
			"NSX_LPG_GAS_LIH_LPG_CDN_ESS"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x2
			ECU_ADDRESS 0xFFFF7969
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_lpg_gas_lih_lpg_dft
			"NSX_LPG_GAS_LIH_LPG_DFT"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF796D
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_lpg_gas_lih_lpg_lvl
			"NSX_LPG_GAS_LIH_LPG_LVL"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF796D
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_lpg_gas_lpg_trs
			"NSX_LPG_GAS_LPG_TRS"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x8
			ECU_ADDRESS 0xFFFF7969
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_lpg_gas_lpg_trs_mod
			"NSX_LPG_GAS_LPG_TRS_MOD"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF796D
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_lpg_gas_mod
			"NSX_LPG_GAS_MOD"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF796D
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_lpg_gas_mod_req
			"NSX_LPG_GAS_MOD_REQ"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF796F
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_lpg_lpg
			"NSX_LPG_LPG"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF796A
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_lpg_lpg_gas_trs
			"NSX_LPG_LPG_GAS_TRS"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x8
			ECU_ADDRESS 0xFFFF796A
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_lpg_lpg_gas_trs_mod
			"NSX_LPG_LPG_GAS_TRS_MOD"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x2
			ECU_ADDRESS 0xFFFF796D
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_lpg_lpg_lih
			"NSX_LPG_LPG_LIH"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x2
			ECU_ADDRESS 0xFFFF796A
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_lpg_lpg_lih_mod
			"NSX_LPG_LPG_LIH_MOD"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x4
			ECU_ADDRESS 0xFFFF796D
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_lpg_lpg_mod
			"NSX_LPG_LPG_MOD"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF796D
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_lpg_lpg_mod_req
			"NSX_LPG_LPG_MOD_REQ"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF796F
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_ob_mdmsf_att1
			"NSX_OB_MDMSF_ATT1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x2
			ECU_ADDRESS 0xFFFF7D86
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_ob_mdmsf_att2
			"NSX_OB_MDMSF_ATT2"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D86
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_ob_mdmsf_cyl_cut
			"NSX_OB_MDMSF_CYL_CUT"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D86
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_ob_mdmsf_cyl_ok
			"NSX_OB_MDMSF_CYL_OK"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x4
			ECU_ADDRESS 0xFFFF7D86
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_ob_mdmsf_inactif
			"NSX_OB_MDMSF_INACTIF"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D86
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_ob_mdmsf_init
			"NSX_OB_MDMSF_INIT"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D86
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_ovs_sl
			"NSX_OVS_SL"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x10
			ECU_ADDRESS 0xFFFF81DB
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_pomp_coup
			"NSX_POMP_COUP"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x8
			ECU_ADDRESS 0xFFFF796B
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_pres_ramp
			"NSX_PRES_RAMP"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x4
			ECU_ADDRESS 0xFFFF796B
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_sf1_att
			"NSX_SF1_ATT"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D85
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_sf1_bien_phs
			"NSX_SF1_BIEN_PHS"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D85
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_sf1_cut
			"NSX_SF1_CUT"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D85
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_sf1_detromp
			"NSX_SF1_DETROMP"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x2
			ECU_ADDRESS 0xFFFF7D85
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_sf1_mal_phs
			"NSX_SF1_MAL_PHS"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D85
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_sf1_paire
			"NSX_SF1_PAIRE"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x4
			ECU_ADDRESS 0xFFFF7D85
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_sl
			"NSX_SL"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF81D5
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_sl_raw
			"NSX_SL_RAW"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF81D6
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_susp_cru
			"NSX_SUSP_CRU"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x8
			ECU_ADDRESS 0xFFFF81D9
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_susp_sl
			"NSX_SUSP_SL"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x8
			ECU_ADDRESS 0xFFFF81DB
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_wait_cru
			"NSX_WAIT_CRU"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x2
			ECU_ADDRESS 0xFFFF81D9
		/end MEASUREMENT
		/begin MEASUREMENT Nsx_wait_sl
			"NSX_WAIT_SL"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x2
			ECU_ADDRESS 0xFFFF81DB
		/end MEASUREMENT
		/begin MEASUREMENT Null
			"Null"
			ULONG
			Id_0x00
			2
			2
			0
			4294967295
			ECU_ADDRESS 0xFFFF85F4
		/end MEASUREMENT
		/begin MEASUREMENT Num_test_actionneur_
			"Num_test_actionneur"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF82CA
		/end MEASUREMENT
		/begin MEASUREMENT Numero_de_tache_
			"Numero_de_tache"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7C0E
		/end MEASUREMENT
		/begin MEASUREMENT Numero_telechargement
			"Numero_telechargement"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8658
		/end MEASUREMENT
		/begin MEASUREMENT NXX_AJ_FIL1
			"NXX_AJ_FIL1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8328
		/end MEASUREMENT
		/begin MEASUREMENT NXX_AJ_FIL2
			"NXX_AJ_FIL2"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x2
			ECU_ADDRESS 0xFFFF8328
		/end MEASUREMENT
		/begin MEASUREMENT NXX_AJ_FIL3
			"NXX_AJ_FIL3"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x4
			ECU_ADDRESS 0xFFFF8328
		/end MEASUREMENT
		/begin MEASUREMENT NXX_AJ_FIL4
			"NXX_AJ_FIL4"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x8
			ECU_ADDRESS 0xFFFF8328
		/end MEASUREMENT
		/begin MEASUREMENT NXX_AJ_FIL5
			"NXX_AJ_FIL5"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x10
			ECU_ADDRESS 0xFFFF8328
		/end MEASUREMENT
		/begin MEASUREMENT NXX_AJ_FIL6
			"NXX_AJ_FIL6"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x20
			ECU_ADDRESS 0xFFFF8328
		/end MEASUREMENT
		/begin MEASUREMENT Nxx_aut_run_eng
			"NXX_AUT_RUN_ENG"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x4
			ECU_ADDRESS 0xFFFF78E1
		/end MEASUREMENT
		/begin MEASUREMENT Nxx_sta_run_eng
			"NXX_STA_RUN_ENG"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x2
			ECU_ADDRESS 0xFFFF78E1
		/end MEASUREMENT
		/begin MEASUREMENT Nxx_stal_eng
			"NXX_STAL_ENG"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x8
			ECU_ADDRESS 0xFFFF78E1
		/end MEASUREMENT
		/begin MEASUREMENT Nxx_stop1_eng
			"NXX_STOP1_ENG"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF78E1
		/end MEASUREMENT
		/begin MEASUREMENT Nxx_wpmp_spy
			"NXX_WPMP_SPY"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x2
			ECU_ADDRESS 0xFFFF7F17
		/end MEASUREMENT
		/begin MEASUREMENT Nxx_wpmp_stop
			"NXX_WPMP_STOP"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7F17
		/end MEASUREMENT
		/begin MEASUREMENT Nxx_wpmp_stop_eng
			"NXX_WPMP_STOP_ENG"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x4
			ECU_ADDRESS 0xFFFF7F17
		/end MEASUREMENT
		/begin MEASUREMENT Obd_diag_cata_diagnostic
			"OBD_DIAG_CATA_DIAGNOSTIC"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x10
			ECU_ADDRESS 0xFFFF7D92
		/end MEASUREMENT
		/begin MEASUREMENT Obd_diag_cata_fin
			"OBD_DIAG_CATA_FIN"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x20
			ECU_ADDRESS 0xFFFF7D92
		/end MEASUREMENT
		/begin MEASUREMENT Obd_diag_cata_hors_diagnostic
			"OBD_DIAG_CATA_HORS_DIAGNOSTIC"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D92
		/end MEASUREMENT
		/begin MEASUREMENT Obd_diag_cata_mesure
			"OBD_DIAG_CATA_MESURE"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x8
			ECU_ADDRESS 0xFFFF7D92
		/end MEASUREMENT
		/begin MEASUREMENT Obd_diag_cata_stab_bcle_fermee
			"OBD_DIAG_CATA_STAB_BCLE_FERMEE"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x2
			ECU_ADDRESS 0xFFFF7D92
		/end MEASUREMENT
		/begin MEASUREMENT Obd_diag_cata_stab_bcle_ouv_f
			"OBD_DIAG_CATA_STAB_BCLE_OUV_F"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x4
			ECU_ADDRESS 0xFFFF7D92
		/end MEASUREMENT
		/begin MEASUREMENT Obd_diag_fsm_diagnostic
			"OBD_DIAG_FSM_DIAGNOSTIC"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x4
			ECU_ADDRESS 0xFFFF7D84
		/end MEASUREMENT
		/begin MEASUREMENT Obd_diag_fsm_hors_diagnostic
			"OBD_DIAG_FSM_HORS_DIAGNOSTIC"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D84
		/end MEASUREMENT
		/begin MEASUREMENT Obd_diag_msf_diagnostic
			"OBD_DIAG_MSF_DIAGNOSTIC"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x4
			ECU_ADDRESS 0xFFFF7DBF
		/end MEASUREMENT
		/begin MEASUREMENT Obd_diag_msf_hors_diagnostic
			"OBD_DIAG_MSF_HORS_DIAGNOSTIC"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7DBF
		/end MEASUREMENT
		/begin MEASUREMENT Obd_diag_msf_stabilisation
			"OBD_DIAG_MSF_STABILISATION"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x2
			ECU_ADDRESS 0xFFFF7DBF
		/end MEASUREMENT
		/begin MEASUREMENT Obd_diag_sa_diagnostic
			"OBD_DIAG_SA_DIAGNOSTIC"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x8
			ECU_ADDRESS 0xFFFF7DC8
		/end MEASUREMENT
		/begin MEASUREMENT Obd_diag_sa_fin_diagnostic
			"OBD_DIAG_SA_FIN_DIAGNOSTIC"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x10
			ECU_ADDRESS 0xFFFF7DC8
		/end MEASUREMENT
		/begin MEASUREMENT Obd_diag_sa_hors_diagnostic
			"OBD_DIAG_SA_HORS_DIAGNOSTIC"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7DC8
		/end MEASUREMENT
		/begin MEASUREMENT Obd_diag_sa_mesures
			"OBD_DIAG_SA_MESURES"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x4
			ECU_ADDRESS 0xFFFF7DC8
		/end MEASUREMENT
		/begin MEASUREMENT Obd_diag_sa_stabilisation
			"OBD_DIAG_SA_STABILISATION"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x2
			ECU_ADDRESS 0xFFFF7DC8
		/end MEASUREMENT
		/begin MEASUREMENT Octet_micro_wtdg_en_cours
			"Octet_micro_wtdg_en_cours"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8241
		/end MEASUREMENT
		/begin MEASUREMENT Offset_batterie_trim
			"Offset_batterie_trim"
			SBYTE
			F_2v9479687_p0_289
			2
			2
			-377.3399936
			374.3920249
			ECU_ADDRESS 0xFFFF8A59
		/end MEASUREMENT
		/begin MEASUREMENT Offset_bob_a_commander
			"Offset_bob_a_commander"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6E16
		/end MEASUREMENT
		/begin MEASUREMENT Offset_temps_fdc_tact
			"Offset_temps_fdc_tact"
			UWORD
			F_0v0032_p0_8
			2
			2
			0
			209.712
			ECU_ADDRESS 0xFFFF82D0
		/end MEASUREMENT
		/begin MEASUREMENT Offset_temps_t2_tact
			"Offset_temps_t2_tact"
			UWORD
			F_0v0032_p0_8
			2
			2
			0
			209.712
			ECU_ADDRESS 0xFFFF82D2
		/end MEASUREMENT
		/begin MEASUREMENT Old_table_dephasage_inj_A
			"Old_table_dephasage_inj_A"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7BAA
		/end MEASUREMENT
		/begin MEASUREMENT Old_table_dephasage_inj_B
			"Old_table_dephasage_inj_B"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7BAC
		/end MEASUREMENT
		/begin MEASUREMENT Old_table_dephasage_inj_C
			"Old_table_dephasage_inj_C"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7BAE
		/end MEASUREMENT
		/begin MEASUREMENT Old_table_dephasage_inj_D
			"Old_table_dephasage_inj_D"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7BB0
		/end MEASUREMENT
		/begin MEASUREMENT One_hundred_ms_counter
			"One_hundred_ms_counter"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7308
		/end MEASUREMENT
		/begin MEASUREMENT Opr_var0
			"Opr_var0"
			ULONG
			Id_0x00
			2
			2
			0
			4294967295
			ECU_ADDRESS 0xFFFF6604
		/end MEASUREMENT
		/begin MEASUREMENT Opr_var1
			"Opr_var1"
			ULONG
			Id_0x00
			2
			2
			0
			4294967295
			ECU_ADDRESS 0xFFFF6608
		/end MEASUREMENT
		/begin MEASUREMENT Opr_var10
			"Opr_var10"
			ULONG
			Id_0x00
			2
			2
			0
			4294967295
			ECU_ADDRESS 0xFFFF662C
		/end MEASUREMENT
		/begin MEASUREMENT Opr_var11
			"Opr_var11"
			ULONG
			Id_0x00
			2
			2
			0
			4294967295
			ECU_ADDRESS 0xFFFF6630
		/end MEASUREMENT
		/begin MEASUREMENT Opr_var12
			"Opr_var12"
			ULONG
			Id_0x00
			2
			2
			0
			4294967295
			ECU_ADDRESS 0xFFFF6634
		/end MEASUREMENT
		/begin MEASUREMENT Opr_var13
			"Opr_var13"
			ULONG
			Id_0x00
			2
			2
			0
			4294967295
			ECU_ADDRESS 0xFFFF6638
		/end MEASUREMENT
		/begin MEASUREMENT Opr_var14
			"Opr_var14"
			ULONG
			Id_0x00
			2
			2
			0
			4294967295
			ECU_ADDRESS 0xFFFF663C
		/end MEASUREMENT
		/begin MEASUREMENT Opr_var15
			"Opr_var15"
			ULONG
			Id_0x00
			2
			2
			0
			4294967295
			ECU_ADDRESS 0xFFFF6640
		/end MEASUREMENT
		/begin MEASUREMENT Opr_var2
			"Opr_var2"
			ULONG
			Id_0x00
			2
			2
			0
			4294967295
			ECU_ADDRESS 0xFFFF660C
		/end MEASUREMENT
		/begin MEASUREMENT Opr_var3
			"Opr_var3"
			ULONG
			Id_0x00
			2
			2
			0
			4294967295
			ECU_ADDRESS 0xFFFF6610
		/end MEASUREMENT
		/begin MEASUREMENT Opr_var4
			"Opr_var4"
			ULONG
			Id_0x00
			2
			2
			0
			4294967295
			ECU_ADDRESS 0xFFFF6614
		/end MEASUREMENT
		/begin MEASUREMENT Opr_var5
			"Opr_var5"
			ULONG
			Id_0x00
			2
			2
			0
			4294967295
			ECU_ADDRESS 0xFFFF6618
		/end MEASUREMENT
		/begin MEASUREMENT Opr_var6
			"Opr_var6"
			ULONG
			Id_0x00
			2
			2
			0
			4294967295
			ECU_ADDRESS 0xFFFF661C
		/end MEASUREMENT
		/begin MEASUREMENT Opr_var7
			"Opr_var7"
			ULONG
			Id_0x00
			2
			2
			0
			4294967295
			ECU_ADDRESS 0xFFFF6620
		/end MEASUREMENT
		/begin MEASUREMENT Opr_var8
			"Opr_var8"
			ULONG
			Id_0x00
			2
			2
			0
			4294967295
			ECU_ADDRESS 0xFFFF6624
		/end MEASUREMENT
		/begin MEASUREMENT Opr_var9
			"Opr_var9"
			ULONG
			Id_0x00
			2
			2
			0
			4294967295
			ECU_ADDRESS 0xFFFF6628
		/end MEASUREMENT
		/begin MEASUREMENT Otoriab
			"Autorisation_fonct_mot_airbag"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6EB9
		/end MEASUREMENT
		/begin MEASUREMENT Otoribvr
			"Autorisation_fonct_mot_bvr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6EBA
		/end MEASUREMENT
		/begin MEASUREMENT Otoriuch
			"Autorisation_fonct_moteur_uch"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6EBB
		/end MEASUREMENT
		/begin MEASUREMENT Output_hyst
			"Output_hyst"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF74F1
		/end MEASUREMENT
		/begin MEASUREMENT Output_hyst_lis_max
			"Output_hyst_lis_max"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7C2A
		/end MEASUREMENT
		/begin MEASUREMENT Output_hyst_lis_min
			"Output_hyst_lis_min"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7C2B
		/end MEASUREMENT
		/begin MEASUREMENT Ouverture_fenetre
			"Ouverture_fenetre"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7473
		/end MEASUREMENT
		/begin MEASUREMENT Panne_alim_1_confirmee_
			"Panne_alim_1_confirmee"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6D14
		/end MEASUREMENT
		/begin MEASUREMENT Panne_alim_2_confirmee_
			"Panne_alim_2_confirmee"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6D15
		/end MEASUREMENT
		/begin MEASUREMENT Panne_bob_a_c_2cc0_memo
			"Panne_bob_a_c_2cc0_memo"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E1B
		/end MEASUREMENT
		/begin MEASUREMENT Panne_bob_a_c_2cc0_pres
			"Panne_bob_a_c_2cc0_pres"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E17
		/end MEASUREMENT
		/begin MEASUREMENT Panne_bob_a_c_cc1_memo
			"Panne_bob_a_c_cc1_memo"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E1C
		/end MEASUREMENT
		/begin MEASUREMENT Panne_bob_a_c_cc1_pres
			"Panne_bob_a_c_cc1_pres"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E18
		/end MEASUREMENT
		/begin MEASUREMENT Panne_bob_b_d_2cc0_memo
			"Panne_bob_b_d_2cc0_memo"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E1D
		/end MEASUREMENT
		/begin MEASUREMENT Panne_bob_b_d_2cc0_pres
			"Panne_bob_b_d_2cc0_pres"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E19
		/end MEASUREMENT
		/begin MEASUREMENT Panne_bob_b_d_cc1_memo
			"Panne_bob_b_d_cc1_memo"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E1E
		/end MEASUREMENT
		/begin MEASUREMENT Panne_bob_b_d_cc1_pres
			"Panne_bob_b_d_cc1_pres"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E1A
		/end MEASUREMENT
		/begin MEASUREMENT Panne_injecteurs
			"Panne_injecteurs"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF784E
		/end MEASUREMENT
		/begin MEASUREMENT Panne_moteur_synchro_presente_
			"Panne_moteur_synchro_presente"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7F1E
		/end MEASUREMENT
		/begin MEASUREMENT Panne_relais
			"Panne_relais"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF784F
		/end MEASUREMENT
		/begin MEASUREMENT Panne_tle_vvt
			"Panne_tle_vvt"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7850
		/end MEASUREMENT
		/begin MEASUREMENT Papmot_idle
			"PAPMOT_IDLE"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF768A
		/end MEASUREMENT
		/begin MEASUREMENT Papmot_incr_idx
			"PAPMOT_INCR_IDX"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x2
			ECU_ADDRESS 0xFFFF768A
		/end MEASUREMENT
		/begin MEASUREMENT Pas_de_timeout_
			"Pas_de_timeout"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF75BE
		/end MEASUREMENT
		/begin MEASUREMENT Passage_en_test_actionneur_
			"Passage_en_test_actionneur"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF82C5
		/end MEASUREMENT
		/begin MEASUREMENT Pda_diff_butee_1
			"Pda_diff_butee_1"
			UBYTE
			F_0v04376_p0_180
			2
			2
			0
			11.1588
			ECU_ADDRESS 0xFFFF77BF
		/end MEASUREMENT
		/begin MEASUREMENT Pda_diff_butee_2
			"Pda_diff_butee_2"
			UBYTE
			F_0v04376_p0_180
			2
			2
			0
			11.1588
			ECU_ADDRESS 0xFFFF77C0
		/end MEASUREMENT
		/begin MEASUREMENT Ped_pied_leve_
			"Ped_pied_leve"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7FBF
		/end MEASUREMENT
		/begin MEASUREMENT Perio4_pre
			"Periode_moteur_precedente"
			UWORD
			F_4_p0_149
			2
			2
			0
			262140
			ECU_ADDRESS 0xFFFF8110
		/end MEASUREMENT
		/begin MEASUREMENT Periode_signal_vitesse_
			"Periode_signal_vitesse"
			UWORD
			F_0v0512_p0_290
			2
			2
			0
			3355.392
			ECU_ADDRESS 0xFFFF8296
		/end MEASUREMENT
		/begin MEASUREMENT Periode_throttle_
			"Periode_throttle"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF76FE
		/end MEASUREMENT
		/begin MEASUREMENT Periode_vvt_adm
			"Periode_vvt_adm"
			UWORD
			F_0v0032_p0_8
			2
			2
			0
			209.712
			ECU_ADDRESS 0xFFFF854A
		/end MEASUREMENT
		/begin MEASUREMENT Periode_wastegate
			"Periode_wastegate"
			UWORD
			F_0v0032_p0_8
			2
			2
			0
			209.712
			ECU_ADDRESS 0xFFFF84C8
		/end MEASUREMENT
		/begin MEASUREMENT Phase_application_correction_
			"Phase_application_correction"
			UBYTE
			Phase_application_correction__conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF8324
		/end MEASUREMENT
		/begin MEASUREMENT Phase_av_boucle_ouverte_rr
			"PHASE_AV_BOUCLE_OUVERTE_RR"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x4
			ECU_ADDRESS 0xFFFF7AA4
		/end MEASUREMENT
		/begin MEASUREMENT Phase_avant_bouclage
			"PHASE_AVANT_BOUCLAGE"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x2
			ECU_ADDRESS 0xFFFF7ABA
		/end MEASUREMENT
		/begin MEASUREMENT Phase_avant_pre_injection_
			"Phase_avant_pre_injection"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7BA1
		/end MEASUREMENT
		/begin MEASUREMENT Phase_boucle_ferme
			"PHASE_BOUCLE_FERME"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7AA4
		/end MEASUREMENT
		/begin MEASUREMENT Phase_boucle_ouverte
			"PHASE_BOUCLE_OUVERTE"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7ABA
		/end MEASUREMENT
		/begin MEASUREMENT Phase_boucle_ouverte_rr
			"PHASE_BOUCLE_OUVERTE_RR"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x2
			ECU_ADDRESS 0xFFFF7AA4
		/end MEASUREMENT
		/begin MEASUREMENT Phase_boucle_pauvre
			"PHASE_BOUCLE_PAUVRE"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x20
			ECU_ADDRESS 0xFFFF7AB7
		/end MEASUREMENT
		/begin MEASUREMENT Phase_bp_pente_douce_p
			"PHASE_BP_PENTE_DOUCE_P"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x4
			ECU_ADDRESS 0xFFFF7AB8
		/end MEASUREMENT
		/begin MEASUREMENT Phase_bp_pente_douce_r
			"PHASE_BP_PENTE_DOUCE_R"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x2
			ECU_ADDRESS 0xFFFF7AB8
		/end MEASUREMENT
		/begin MEASUREMENT Phase_bp_pente_forte_p
			"PHASE_BP_PENTE_FORTE_P"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x10
			ECU_ADDRESS 0xFFFF7AB8
		/end MEASUREMENT
		/begin MEASUREMENT Phase_bp_pente_forte_r
			"PHASE_BP_PENTE_FORTE_R"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x8
			ECU_ADDRESS 0xFFFF7AB8
		/end MEASUREMENT
		/begin MEASUREMENT Phase_coupure_surpression
			"Phase_coupure_surpression"
			UBYTE
			Phase_coupure_surpression_conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF84AF
		/end MEASUREMENT
		/begin MEASUREMENT Phase_debut_post_injection_
			"Phase_debut_post_injection"
			UBYTE
			F_3_p0_111
			2
			2
			0
			765
			ECU_ADDRESS 0xFFFF7AAC
		/end MEASUREMENT
		/begin MEASUREMENT Phase_dem_sfg_
			"PHASE_DEM_SFG"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x2
			ECU_ADDRESS 0xFFFF7AB9
		/end MEASUREMENT
		/begin MEASUREMENT Phase_demarrage_br
			"PHASE_DEMARRAGE_BR"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x10
			ECU_ADDRESS 0xFFFF7ABA
		/end MEASUREMENT
		/begin MEASUREMENT Phase_demarrage_calcul_du_dwell_
			"Phase_demarrage_calcul_du_dwell"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E02
		/end MEASUREMENT
		/begin MEASUREMENT Phase_diag_pmvac
			"Phase_diag_pmvac"
			UBYTE
			Phase_diag_pmvac_conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF7902
		/end MEASUREMENT
		/begin MEASUREMENT Phase_en_cours_inj_a
			"Phase_en_cours_inj_a"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6BAF
		/end MEASUREMENT
		/begin MEASUREMENT Phase_en_cours_inj_b
			"Phase_en_cours_inj_b"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6BB0
		/end MEASUREMENT
		/begin MEASUREMENT Phase_en_cours_inj_c
			"Phase_en_cours_inj_c"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6BB1
		/end MEASUREMENT
		/begin MEASUREMENT Phase_en_cours_inj_d
			"Phase_en_cours_inj_d"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6BB2
		/end MEASUREMENT
		/begin MEASUREMENT Phase_initialisation_
			"PHASE_INITIALISATION"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7AB7
		/end MEASUREMENT
		/begin MEASUREMENT Phase_initialisation_bp
			"PHASE_INITIALISATION_BP"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7AB8
		/end MEASUREMENT
		/begin MEASUREMENT Phase_injection_sequentielle_
			"Phase_injection_sequentielle"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7BA2
		/end MEASUREMENT
		/begin MEASUREMENT Phase_moteur_
			"Phase_moteur"
			UBYTE
			Phase_moteur__conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF8151
		/end MEASUREMENT
		/begin MEASUREMENT Phase_pente_douce_p_
			"PHASE_PENTE_DOUCE_P"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x4
			ECU_ADDRESS 0xFFFF7AB7
		/end MEASUREMENT
		/begin MEASUREMENT Phase_pente_douce_r_
			"PHASE_PENTE_DOUCE_R"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x2
			ECU_ADDRESS 0xFFFF7AB7
		/end MEASUREMENT
		/begin MEASUREMENT Phase_pente_forte_p
			"PHASE_PENTE_FORTE_P"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x10
			ECU_ADDRESS 0xFFFF7AB7
		/end MEASUREMENT
		/begin MEASUREMENT Phase_pente_forte_r_
			"PHASE_PENTE_FORTE_R"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x8
			ECU_ADDRESS 0xFFFF7AB7
		/end MEASUREMENT
		/begin MEASUREMENT Phase_pleine_charge
			"PHASE_PLEINE_CHARGE"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x8
			ECU_ADDRESS 0xFFFF7ABA
		/end MEASUREMENT
		/begin MEASUREMENT Phase_redepart_
			"Phase_redepart"
			UBYTE
			Phase_redepart__conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF80DF
		/end MEASUREMENT
		/begin MEASUREMENT Phase_sous_automate_br
			"PHASE_SOUS_AUTOMATE_BR"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x4
			ECU_ADDRESS 0xFFFF7ABA
		/end MEASUREMENT
		/begin MEASUREMENT Phase_trans_sfg_seq_
			"PHASE_TRANS_SFG_SEQ"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x8
			ECU_ADDRESS 0xFFFF7AB9
		/end MEASUREMENT
		/begin MEASUREMENT Phvl
			"Phase_automate_verrou"
			UBYTE
			Phvl_conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF6C03
		/end MEASUREMENT
		/begin MEASUREMENT Pmea_amorcage_catalyseur_iae
			"PMEA_AMORCAGE_CATALYSEUR_IAE"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x4
			ECU_ADDRESS 0xFFFF6D61
		/end MEASUREMENT
		/begin MEASUREMENT Pmea_amorcage_catalyseur_repart_
			"PMEA_AMORCAGE_CATALYSEUR_REPART"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x10
			ECU_ADDRESS 0xFFFF6D61
		/end MEASUREMENT
		/begin MEASUREMENT Pmea_amorcage_pauvre_catalyseur_
			"PMEA_AMORCAGE_PAUVRE_CATALYSEUR"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x8
			ECU_ADDRESS 0xFFFF6D61
		/end MEASUREMENT
		/begin MEASUREMENT Pmea_depollution
			"PMEA_DEPOLLUTION"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x80
			ECU_ADDRESS 0xFFFF6D61
		/end MEASUREMENT
		/begin MEASUREMENT Pmea_mise_en_action_termine
			"PMEA_MISE_EN_ACTION_TERMINE"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x40
			ECU_ADDRESS 0xFFFF6D61
		/end MEASUREMENT
		/begin MEASUREMENT Pmea_rechauffage_catalyseur_
			"PMEA_RECHAUFFAGE_CATALYSEUR"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x2
			ECU_ADDRESS 0xFFFF6D61
		/end MEASUREMENT
		/begin MEASUREMENT Pmea_rechauffage_habitacle_
			"PMEA_RECHAUFFAGE_HABITACLE"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x20
			ECU_ADDRESS 0xFFFF6D61
		/end MEASUREMENT
		/begin MEASUREMENT Pmea_releve_temperature_eau_
			"PMEA_RELEVE_TEMPERATURE_EAU"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6D61
		/end MEASUREMENT
		/begin MEASUREMENT Pompe_a_eau_diag_enable
			"Pompe_a_eau_diag_enable"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7843
		/end MEASUREMENT
		/begin MEASUREMENT Pompe_a_eau_tco_cut
			"Pompe_a_eau_tco_cut"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7F13
		/end MEASUREMENT
		/begin MEASUREMENT Pompe_a_eau_vb_cut
			"Pompe_a_eau_vb_cut"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7F14
		/end MEASUREMENT
		/begin MEASUREMENT Porta
			"Porta"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7C3C
		/end MEASUREMENT
		/begin MEASUREMENT Portb
			"Portb"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7C3E
		/end MEASUREMENT
		/begin MEASUREMENT Portc
			"Portc"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7C40
		/end MEASUREMENT
		/begin MEASUREMENT Portd
			"Portd"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7C42
		/end MEASUREMENT
		/begin MEASUREMENT Porte
			"Porte"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7C44
		/end MEASUREMENT
		/begin MEASUREMENT Porteur_adapt_calc
			"Porteur_adapt_calc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF863C
		/end MEASUREMENT
		/begin MEASUREMENT Porteur_arret_perco
			"Porteur_arret_perco"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8654
		/end MEASUREMENT
		/begin MEASUREMENT Porteur_bool_adapt
			"Porteur_bool_adapt"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8693
		/end MEASUREMENT
		/begin MEASUREMENT Porteur_bool_recocyl
			"Porteur_bool_recocyl"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8682
		/end MEASUREMENT
		/begin MEASUREMENT Porteur_demande_spi
			"Porteur_demande_spi"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF82C2
		/end MEASUREMENT
		/begin MEASUREMENT Porteur_misfire
			"Porteur_misfire"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF86DC
		/end MEASUREMENT
		/begin MEASUREMENT Porteur_readiness_code
			"Porteur_readiness_code"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF86D4
		/end MEASUREMENT
		/begin MEASUREMENT Porteur_regulateur_vitesse1
			"Porteur_regulateur_vitesse1"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF86D6
		/end MEASUREMENT
		/begin MEASUREMENT Porteur_regulateur_vitesse2
			"Porteur_regulateur_vitesse2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF86D7
		/end MEASUREMENT
		/begin MEASUREMENT Portf
			"Portf"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7C46
		/end MEASUREMENT
		/begin MEASUREMENT Portg
			"Portg"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7C48
		/end MEASUREMENT
		/begin MEASUREMENT Porth
			"Porth"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7C4A
		/end MEASUREMENT
		/begin MEASUREMENT Portj
			"Portj"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7C4C
		/end MEASUREMENT
		/begin MEASUREMENT Portk
			"Portk"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7C4E
		/end MEASUREMENT
		/begin MEASUREMENT Portl
			"Portl"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7C50
		/end MEASUREMENT
		/begin MEASUREMENT Pos_papillon_1_result_ad_conv_
			"Pos_papillon_1_result_ad_conv"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFFF802
		/end MEASUREMENT
		/begin MEASUREMENT Pos_papillon_2_affecte
			"Pos_papillon_2_affecte"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x2
			ECU_ADDRESS 0xFFFF8242
		/end MEASUREMENT
		/begin MEASUREMENT Pos_papillon_2_result_ad_conv_
			"Pos_papillon_2_result_ad_conv"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFFF804
		/end MEASUREMENT
		/begin MEASUREMENT Pos_papillon_2_synchro
			"Pos_papillon_2_synchro"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8243
		/end MEASUREMENT
		/begin MEASUREMENT Pos_pedale_1_result_ad_conv_
			"Pos_pedale_1_result_ad_conv"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFFF810
		/end MEASUREMENT
		/begin MEASUREMENT Pos_pedale_2_affecte
			"Pos_pedale_2_affecte"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8244
		/end MEASUREMENT
		/begin MEASUREMENT Pos_pedale_2_result_ad_conv_
			"Pos_pedale_2_result_ad_conv"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFFF812
		/end MEASUREMENT
		/begin MEASUREMENT Pos_pedale_2_synchro
			"Pos_pedale_2_synchro"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8245
		/end MEASUREMENT
		/begin MEASUREMENT Position_papl_relative_precdente
			"Position_papl_relative_precdente"
			UBYTE
			F_0v4_p0_106
			2
			2
			0
			102
			ECU_ADDRESS 0xFFFF7EFD
		/end MEASUREMENT
		/begin MEASUREMENT Position_ped_moy_local_
			"Position_ped_moy_local"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7FC8
		/end MEASUREMENT
		/begin MEASUREMENT Position_pedale_precedente_
			"Position_pedale_precedente"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF768E
		/end MEASUREMENT
		/begin MEASUREMENT Poursuite_recouvrement_enable
			"Poursuite_recouvrement_enable"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7934
		/end MEASUREMENT
		/begin MEASUREMENT Power_latch_ee_
			"POWER_LATCH_EE"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x8
			ECU_ADDRESS 0xFFFF8151
		/end MEASUREMENT
		/begin MEASUREMENT Pre_injection_
			"PRE_INJECTION"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7AB9
		/end MEASUREMENT
		/begin MEASUREMENT Premier_diag_hip9011
			"Premier_diag_hip9011"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF82B4
		/end MEASUREMENT
		/begin MEASUREMENT Premier_noise_canceler
			"Premier_noise_canceler"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7F1F
		/end MEASUREMENT
		/begin MEASUREMENT Premier_top_vitesse_
			"Premier_top_vitesse"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8286
		/end MEASUREMENT
		/begin MEASUREMENT PREMIERE_ATTENTE
			"PREMIERE_ATTENTE"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x2
			ECU_ADDRESS 0xFFFF6BD0
		/end MEASUREMENT
		/begin MEASUREMENT PREMIERE_CALCULS
			"PREMIERE_CALCULS"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6BD0
		/end MEASUREMENT
		/begin MEASUREMENT Premiere_surveillance
			"Premiere_surveillance"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E74
		/end MEASUREMENT
		/begin MEASUREMENT Premieres_conditions_chauf_amont
			"Premieres_conditions_chauf_amont"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7E97
		/end MEASUREMENT
		/begin MEASUREMENT Premieres_conditions_chauf_aval_
			"Premieres_conditions_chauf_aval"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7E98
		/end MEASUREMENT
		/begin MEASUREMENT Pres_admission_result_ad_conv
			"Pres_admission_result_ad_conv"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFFF84E
		/end MEASUREMENT
		/begin MEASUREMENT Pres_mastervac_brute
			"Pres_mastervac_brute"
			UWORD
			F_4v8828125_p0_11
			2
			2
			0
			319995.1172
			ECU_ADDRESS 0xFFFF7F08
		/end MEASUREMENT
		/begin MEASUREMENT Pres_mastervac_result_ad_conv_
			"Pres_mastervac_result_ad_conv"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFFF842
		/end MEASUREMENT
		/begin MEASUREMENT Pres_sural_result_ad_conv
			"Pres_sural_result_ad_conv"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFFF84C
		/end MEASUREMENT
		/begin MEASUREMENT Presence_opr
			"Presence_opr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6644
		/end MEASUREMENT
		/begin MEASUREMENT Preset
			"Autor_prov_fcnt_mot"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF741C
		/end MEASUREMENT
		/begin MEASUREMENT Pression_autorise_post_injection
			"Pression_autorise_post_injection"
			UWORD
			F_3v7_p103_37
			2
			2
			103
			242582.5
			ECU_ADDRESS 0xFFFF7B1C
		/end MEASUREMENT
		/begin MEASUREMENT Pression_clim_result_ad_conv
			"Pression_clim_result_ad_conv"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFFF814
		/end MEASUREMENT
		/begin MEASUREMENT Pression_collecteur_mesuree_i_1_
			"Pression_collecteur_mesuree_i_1"
			UWORD
			F_3v7_p103_37
			2
			2
			103
			242582.5
			ECU_ADDRESS 0xFFFF8056
		/end MEASUREMENT
		/begin MEASUREMENT Pression_predite_filtree_gpl
			"Pression_predite_filtree_gpl"
			UWORD
			F_3v7_p103_37
			2
			2
			103
			242582.5
			ECU_ADDRESS 0xFFFF798E
		/end MEASUREMENT
		/begin MEASUREMENT Pression_sural_mesuree_i_1
			"Pression_sural_mesuree_i_1"
			UWORD
			F_3v7_p103_37
			2
			2
			103
			242582.5
			ECU_ADDRESS 0xFFFF84CA
		/end MEASUREMENT
		/begin MEASUREMENT Priorite_obd_courante
			"Priorite_obd_courante"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7D7E
		/end MEASUREMENT
		/begin MEASUREMENT Program_return_defaut
			"Program_return_defaut"
			ULONG
			Id_0x00
			2
			2
			0
			4294967295
			ECU_ADDRESS 0xFFFF6510
		/end MEASUREMENT
		/begin MEASUREMENT Program_return_defaut_eep
			"Program_return_defaut_eep"
			ULONG
			Id_0x00
			2
			2
			0
			4294967295
			ECU_ADDRESS 0xFFFF7BF4
		/end MEASUREMENT
		/begin MEASUREMENT Program_return_defaut_lsb
			"Program_return_defaut_lsb"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF8948
		/end MEASUREMENT
		/begin MEASUREMENT Program_return_defaut_msb
			"Program_return_defaut_msb"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF8946
		/end MEASUREMENT
		/begin MEASUREMENT Prsprec
			"Pression_collecteur_precedente"
			UWORD
			F_3v7_p103_37
			2
			2
			103
			242582.5
			ECU_ADDRESS 0xFFFF8058
		/end MEASUREMENT
		/begin MEASUREMENT Psuralprec
			"Pression_sural_precedente"
			UWORD
			F_3v7_p103_37
			2
			2
			103
			242582.5
			ECU_ADDRESS 0xFFFF84CC
		/end MEASUREMENT
		/begin MEASUREMENT Ptc_rov_diag_enable
			"Ptc_rov_diag_enable"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7844
		/end MEASUREMENT
		/begin MEASUREMENT Ptc_seuil_1
			"Ptc_seuil_1"
			UWORD
			F_0v390625_p0_4
			2
			2
			0
			25599.60938
			ECU_ADDRESS 0xFFFF808E
		/end MEASUREMENT
		/begin MEASUREMENT Ptc_seuil_2
			"Ptc_seuil_2"
			UWORD
			F_0v390625_p0_4
			2
			2
			0
			25599.60938
			ECU_ADDRESS 0xFFFF8090
		/end MEASUREMENT
		/begin MEASUREMENT Pump_dsb
			"PUMP_DSB"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7905
		/end MEASUREMENT
		/begin MEASUREMENT Pump_off_prot
			"PUMP_OFF_PROT"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7905
		/end MEASUREMENT
		/begin MEASUREMENT Pump_off_wait
			"PUMP_OFF_WAIT"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7905
		/end MEASUREMENT
		/begin MEASUREMENT Pump_on
			"PUMP_ON"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x2
			ECU_ADDRESS 0xFFFF7905
		/end MEASUREMENT
		/begin MEASUREMENT Purge_adaptative_
			"PURGE_ADAPTATIVE"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x2
			ECU_ADDRESS 0xFFFF80A9
		/end MEASUREMENT
		/begin MEASUREMENT Purge_canister_diag_enable
			"Purge_canister_diag_enable"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7845
		/end MEASUREMENT
		/begin MEASUREMENT Purge_nominale_
			"PURGE_NOMINALE"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x4
			ECU_ADDRESS 0xFFFF80A9
		/end MEASUREMENT
		/begin MEASUREMENT Purge_non_boucle_
			"PURGE_NON_BOUCLE"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x8
			ECU_ADDRESS 0xFFFF80A9
		/end MEASUREMENT
		/begin MEASUREMENT Quatre_cyl_actifs
			"QUATRE_CYL_ACTIFS"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x8
			ECU_ADDRESS 0xFFFF8329
		/end MEASUREMENT
		/begin MEASUREMENT Rapport_de_boite_multiplexee_i_1
			"Rapport_de_boite_multiplexee_i_1"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7309
		/end MEASUREMENT
		/begin MEASUREMENT Rco_applique_purge_
			"Rco_applique_purge"
			UBYTE
			F_0v390625_p0_4
			2
			2
			0
			99.609375
			ECU_ADDRESS 0xFFFF80A7
		/end MEASUREMENT
		/begin MEASUREMENT Rco_applique_vvt_adm
			"Rco_applique_vvt_adm"
			UWORD
			F_0v09756098_p0_55
			2
			2
			0
			6393.658824
			ECU_ADDRESS 0xFFFF854C
		/end MEASUREMENT
		/begin MEASUREMENT Rco_applique_wastegate
			"Rco_applique_wastegate"
			UBYTE
			F_0v390625_p0_4
			2
			2
			0
			99.609375
			ECU_ADDRESS 0xFFFF84B0
		/end MEASUREMENT
		/begin MEASUREMENT Rco_demande_purge_
			"Rco_demande_purge"
			UBYTE
			F_0v390625_p0_4
			2
			2
			0
			99.609375
			ECU_ADDRESS 0xFFFF80A8
		/end MEASUREMENT
		/begin MEASUREMENT Rco_wastegate
			"Rco_wastegate"
			UWORD
			F_0v0032_p0_8
			2
			2
			0
			209.712
			ECU_ADDRESS 0xFFFF84CE
		/end MEASUREMENT
		/begin MEASUREMENT Rech_connexion_ev_iae_en_cours
			"Rech_connexion_ev_iae_en_cours"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8490
		/end MEASUREMENT
		/begin MEASUREMENT Rech_connexion_gmv_en_cours
			"Rech_connexion_gmv_en_cours"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF791E
		/end MEASUREMENT
		/begin MEASUREMENT Rech_connexion_pav_en_cours
			"Rech_connexion_pav_en_cours"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF78EB
		/end MEASUREMENT
		/begin MEASUREMENT Rech_connexion_pmpair_en_cours
			"Rech_connexion_pmpair_en_cours"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8491
		/end MEASUREMENT
		/begin MEASUREMENT Rech_connexion_ptc_rov_en_cours
			"Rech_connexion_ptc_rov_en_cours"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8159
		/end MEASUREMENT
		/begin MEASUREMENT Rech_connexion_thp_en_cours_
			"Rech_connexion_thp_en_cours"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF82D9
		/end MEASUREMENT
		/begin MEASUREMENT Rech_connexion_wpmp_en_cours
			"Rech_connexion_wpmp_en_cours"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7F0D
		/end MEASUREMENT
		/begin MEASUREMENT Recop_calib_r2f_prec
			"Recop_calib_r2f_prec"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7819
		/end MEASUREMENT
		/begin MEASUREMENT Recupere_checksum_rom_hseq
			"Recupere_checksum_rom_hseq"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8246
		/end MEASUREMENT
		/begin MEASUREMENT Regime_moteur_affine_2
			"Regime_moteur_affine_2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF80EC
		/end MEASUREMENT
		/begin MEASUREMENT Regime_nominal_32_memo
			"Regime_nominal_32_memo"
			UBYTE
			F_32_p0_46
			2
			2
			0
			8160
			ECU_ADDRESS 0xFFFF6D9D
		/end MEASUREMENT
		/begin MEASUREMENT Regime_pour_gain_ecart_reg_
			"Regime_pour_gain_ecart_reg"
			UWORD
			F_32_m256_59
			2
			2
			-256
			2096864
			ECU_ADDRESS 0xFFFF79DE
		/end MEASUREMENT
		/begin MEASUREMENT Registre_diag_msf_pollu_
			"Registre_diag_msf_pollu"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7DE4
		/end MEASUREMENT
		/begin MEASUREMENT Regvsc
			"Regime_moteur_vsc"
			UWORD
			F_1_p0_14
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7378
		/end MEASUREMENT
		/begin MEASUREMENT Reload_counter_prev
			"Reload_counter_prev"
			UWORD
			F_0v1_p0_275
			2
			2
			0
			6553.5
			ECU_ADDRESS 0xFFFF7FA6
		/end MEASUREMENT
		/begin MEASUREMENT REPHASAGE_AAC
			"REPHASAGE_AAC"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6BD0
		/end MEASUREMENT
		/begin MEASUREMENT Repnscal
			"Reponse_calculee"
			ULONG
			Id_0x00
			2
			2
			0
			4294967295
			ECU_ADDRESS 0xFFFF6BF4
		/end MEASUREMENT
		/begin MEASUREMENT Repnslu
			"Reponse_lue"
			ULONG
			Id_0x00
			2
			2
			0
			4294967295
			ECU_ADDRESS 0xFFFF7428
		/end MEASUREMENT
		/begin MEASUREMENT Reponse_obd_injection
			"REPONSE_OBD_INJECTION"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x4
			ECU_ADDRESS 0xFFFF75FE
		/end MEASUREMENT
		/begin MEASUREMENT Reponse_obd_mode_9
			"REPONSE_OBD_MODE_9"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x20
			ECU_ADDRESS 0xFFFF75FE
		/end MEASUREMENT
		/begin MEASUREMENT Reponse_obd_passerelle
			"REPONSE_OBD_PASSERELLE"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x8
			ECU_ADDRESS 0xFFFF75FE
		/end MEASUREMENT
		/begin MEASUREMENT Reponse_obd_srv_7
			"REPONSE_OBD_SRV_7"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x40
			ECU_ADDRESS 0xFFFF75FE
		/end MEASUREMENT
		/begin MEASUREMENT Requete_recue
			"REQUETE_RECUE"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x2
			ECU_ADDRESS 0xFFFF75FE
		/end MEASUREMENT
		/begin MEASUREMENT Reset_a_chaud
			"Reset_a_chaud"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF86B2
		/end MEASUREMENT
		/begin MEASUREMENT Reset_moteur_tournant
			"Reset_moteur_tournant"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF86B6
		/end MEASUREMENT
		/begin MEASUREMENT Reset_task_mask
			"Reset_task_mask"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7C20
		/end MEASUREMENT
		/begin MEASUREMENT Reset_task_mask_schedule
			"Reset_task_mask_schedule"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7C22
		/end MEASUREMENT
		/begin MEASUREMENT Resultat_de_test_calcul_mcp
			"Resultat_de_test_calcul_mcp"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF826D
		/end MEASUREMENT
		/begin MEASUREMENT Resultat_de_test_calcul_mcw
			"Resultat_de_test_calcul_mcw"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF826E
		/end MEASUREMENT
		/begin MEASUREMENT Rpobdmx1
			"Rpobdmx1"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7402
		/end MEASUREMENT
		/begin MEASUREMENT Rpobdmx2
			"Rpobdmx2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7403
		/end MEASUREMENT
		/begin MEASUREMENT Rpobdmx3
			"Rpobdmx3"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7404
		/end MEASUREMENT
		/begin MEASUREMENT Rpobdmx4
			"Rpobdmx4"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7405
		/end MEASUREMENT
		/begin MEASUREMENT Rpobdmx5
			"Rpobdmx5"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7406
		/end MEASUREMENT
		/begin MEASUREMENT Rpobdmx6
			"Rpobdmx6"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7407
		/end MEASUREMENT
		/begin MEASUREMENT Rpobdmx7
			"Rpobdmx7"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7408
		/end MEASUREMENT
		/begin MEASUREMENT Rpobdmx8
			"Rpobdmx8"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7409
		/end MEASUREMENT
		/begin MEASUREMENT Rqobdmx1
			"Rqobdmx1"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7609
		/end MEASUREMENT
		/begin MEASUREMENT Rqobdmx2
			"Rqobdmx2"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF760A
		/end MEASUREMENT
		/begin MEASUREMENT Rqobdmx3
			"Rqobdmx3"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF760B
		/end MEASUREMENT
		/begin MEASUREMENT Rqobdmx4
			"Rqobdmx4"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF760C
		/end MEASUREMENT
		/begin MEASUREMENT Rqobdmx5
			"Rqobdmx5"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF760D
		/end MEASUREMENT
		/begin MEASUREMENT Rqobdmx6
			"Rqobdmx6"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF760E
		/end MEASUREMENT
		/begin MEASUREMENT Rqobdmx7
			"Rqobdmx7"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF760F
		/end MEASUREMENT
		/begin MEASUREMENT Rr_arrete_
			"RR_ARRETE"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x2
			ECU_ADDRESS 0xFFFF79C0
		/end MEASUREMENT
		/begin MEASUREMENT Rr_avant_
			"RR_AVANT"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF79C0
		/end MEASUREMENT
		/begin MEASUREMENT Rr_cond_
			"RR_CONDITIONS_DE_RR"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x2
			ECU_ADDRESS 0xFFFF79C2
		/end MEASUREMENT
		/begin MEASUREMENT Rr_dem_
			"RR_DEMARRAGE"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF79C2
		/end MEASUREMENT
		/begin MEASUREMENT Rr_hors_rr_
			"RR_HORS_RR"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x4
			ECU_ADDRESS 0xFFFF79C2
		/end MEASUREMENT
		/begin MEASUREMENT Rr_roulant_
			"RR_ROULANT"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x4
			ECU_ADDRESS 0xFFFF79C0
		/end MEASUREMENT
		/begin MEASUREMENT Running_task
			"Running_task"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7C0F
		/end MEASUREMENT
		/begin MEASUREMENT Rvlv_abs_ecu_stt_cpt
			"Rvlv_abs_ecu_stt_cpt"
			UBYTE
			F_0v032_p0_99
			2
			2
			0
			8.16
			ECU_ADDRESS 0xFFFF81BD
		/end MEASUREMENT
		/begin MEASUREMENT Rvlv_abs_ecu_stt_out
			"Rvlv_abs_ecu_stt_out"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8161
		/end MEASUREMENT
		/begin MEASUREMENT Rvlv_automate_cc_sl_str_whl_swi
			"Rvlv_automate_cc_sl_str_whl_swi"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF81BE
		/end MEASUREMENT
		/begin MEASUREMENT Rvlv_brk_det_cpt
			"Rvlv_brk_det_cpt"
			UBYTE
			F_32_p0_122
			2
			2
			0
			8160
			ECU_ADDRESS 0xFFFF81BF
		/end MEASUREMENT
		/begin MEASUREMENT Rvlv_brk_det_out
			"Rvlv_brk_det_out"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8162
		/end MEASUREMENT
		/begin MEASUREMENT Rvlv_cc_sl_lng_lng_trans_cpt
			"Rvlv_cc_sl_lng_lng_trans_cpt"
			UWORD
			F_0v008_p0_172
			2
			2
			0
			524.28
			ECU_ADDRESS 0xFFFF820C
		/end MEASUREMENT
		/begin MEASUREMENT Rvlv_cc_sl_sht_lng_trans_cpt
			"Rvlv_cc_sl_sht_lng_trans_cpt"
			UBYTE
			F_0v008_p0_172
			2
			2
			0
			2.04
			ECU_ADDRESS 0xFFFF81C0
		/end MEASUREMENT
		/begin MEASUREMENT Rvlv_clu_lk_stt_cpt
			"Rvlv_clu_lk_stt_cpt"
			UBYTE
			F_0v032_p0_99
			2
			2
			0
			8.16
			ECU_ADDRESS 0xFFFF81C1
		/end MEASUREMENT
		/begin MEASUREMENT Rvlv_clu_lk_stt_out
			"Rvlv_clu_lk_stt_out"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8163
		/end MEASUREMENT
		/begin MEASUREMENT Rvlv_cru_lk_stt_cpt
			"Rvlv_cru_lk_stt_cpt"
			UBYTE
			F_0v128_p0_75
			2
			2
			0
			32.64
			ECU_ADDRESS 0xFFFF81C2
		/end MEASUREMENT
		/begin MEASUREMENT Rvlv_cru_on_off_cpt
			"Rvlv_cru_on_off_cpt"
			UBYTE
			F_0v128_p0_75
			2
			2
			0
			32.64
			ECU_ADDRESS 0xFFFF81C3
		/end MEASUREMENT
		/begin MEASUREMENT Rvlv_cru_sl_acel_prev
			"Rvlv_cru_sl_acel_prev"
			SBYTE
			F_0v1_p0v8_293
			2
			2
			-12
			13.5
			ECU_ADDRESS 0xFFFF81B8
		/end MEASUREMENT
		/begin MEASUREMENT Rvlv_cru_sl_lk_ena_2_cpt
			"Rvlv_cru_sl_lk_ena_2_cpt"
			UBYTE
			F_0v032_p0_99
			2
			2
			0
			8.16
			ECU_ADDRESS 0xFFFF81C4
		/end MEASUREMENT
		/begin MEASUREMENT Rvlv_cru_sl_lk_ena_2_out
			"Rvlv_cru_sl_lk_ena_2_out"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8164
		/end MEASUREMENT
		/begin MEASUREMENT Rvlv_cru_sl_lk_ena_8ms_cpt
			"Rvlv_cru_sl_lk_ena_8ms_cpt"
			UWORD
			F_8_p0_56
			2
			2
			0
			524280
			ECU_ADDRESS 0xFFFF820E
		/end MEASUREMENT
		/begin MEASUREMENT Rvlv_cru_sl_lk_ena_cpt
			"Rvlv_cru_sl_lk_ena_cpt"
			UBYTE
			F_0v128_p0_75
			2
			2
			0
			32.64
			ECU_ADDRESS 0xFFFF81C5
		/end MEASUREMENT
		/begin MEASUREMENT Rvlv_cru_sl_on_off_out
			"Rvlv_cru_sl_on_off_out"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8165
		/end MEASUREMENT
		/begin MEASUREMENT Rvlv_cru_sl_on_off_prev
			"Rvlv_cru_sl_on_off_prev"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF81C6
		/end MEASUREMENT
		/begin MEASUREMENT Rvlv_cru_sl_raw_vs_prev
			"Rvlv_cru_sl_raw_vs_prev"
			UWORD
			F_0v01_p0_62
			2
			2
			0
			655.35
			ECU_ADDRESS 0xFFFF8210
		/end MEASUREMENT
		/begin MEASUREMENT Rvlv_cru_sl_vs_mem
			"Rvlv_cru_sl_vs_mem"
			ULONG
			F_0v0000390625_p0_294
			2
			2
			0
			167772.16
			ECU_ADDRESS 0xFFFF81B0
		/end MEASUREMENT
		/begin MEASUREMENT Rvlv_cru_sl_warn_cpt
			"Rvlv_cru_sl_warn_cpt"
			UBYTE
			F_0v1_p0_173
			2
			2
			0
			25.5
			ECU_ADDRESS 0xFFFF81C7
		/end MEASUREMENT
		/begin MEASUREMENT Rvlv_cru_sl_warn_out
			"Rvlv_cru_sl_warn_out"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8166
		/end MEASUREMENT
		/begin MEASUREMENT Rvlv_cru_sl_whl_cmd_stt_prev
			"Rvlv_cru_sl_whl_cmd_stt_prev"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF81C8
		/end MEASUREMENT
		/begin MEASUREMENT Rvlv_cru_whl_cmd_stt_cpt
			"Rvlv_cru_whl_cmd_stt_cpt"
			UBYTE
			F_8_p0_56
			2
			2
			0
			2040
			ECU_ADDRESS 0xFFFF81C9
		/end MEASUREMENT
		/begin MEASUREMENT Rvlv_gear_lih_cpt
			"Rvlv_gear_lih_cpt"
			UBYTE
			F_0v032_p0_99
			2
			2
			0
			8.16
			ECU_ADDRESS 0xFFFF81CA
		/end MEASUREMENT
		/begin MEASUREMENT Rvlv_ip_ecu_stt_cpt
			"Rvlv_ip_ecu_stt_cpt"
			UBYTE
			F_0v032_p0_99
			2
			2
			0
			8.16
			ECU_ADDRESS 0xFFFF81CB
		/end MEASUREMENT
		/begin MEASUREMENT Rvlv_ip_ecu_stt_out
			"Rvlv_ip_ecu_stt_out"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8167
		/end MEASUREMENT
		/begin MEASUREMENT Rvlv_lng_min_out
			"Rvlv_lng_min_out"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8168
		/end MEASUREMENT
		/begin MEASUREMENT Rvlv_lng_plus_out
			"Rvlv_lng_plus_out"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8169
		/end MEASUREMENT
		/begin MEASUREMENT Rvlv_mux_dspl_vs_cpt
			"Rvlv_mux_dspl_vs_cpt"
			UBYTE
			F_0v032_p0_99
			2
			2
			0
			8.16
			ECU_ADDRESS 0xFFFF81CC
		/end MEASUREMENT
		/begin MEASUREMENT Rvlv_mux_vs_cpt
			"Rvlv_mux_vs_cpt"
			UBYTE
			F_0v032_p0_99
			2
			2
			0
			8.16
			ECU_ADDRESS 0xFFFF81CD
		/end MEASUREMENT
		/begin MEASUREMENT Rvlv_no_chr_brk_cpt
			"Rvlv_no_chr_brk_cpt"
			UWORD
			F_0v032_p0_99
			2
			2
			0
			2097.12
			ECU_ADDRESS 0xFFFF8212
		/end MEASUREMENT
		/begin MEASUREMENT Rvlv_no_chr_brk_out
			"Rvlv_no_chr_brk_out"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF816A
		/end MEASUREMENT
		/begin MEASUREMENT Rvlv_options_eeprom
			"Rvlv_options_eeprom"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF86DB
		/end MEASUREMENT
		/begin MEASUREMENT Rvlv_pf_cru_on_off_chr_cpt
			"Rvlv_pf_cru_on_off_chr_cpt"
			UBYTE
			F_0v128_p0_75
			2
			2
			0
			32.64
			ECU_ADDRESS 0xFFFF81CE
		/end MEASUREMENT
		/begin MEASUREMENT Rvlv_pf_cru_on_off_chr_out
			"Rvlv_pf_cru_on_off_chr_out"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF816B
		/end MEASUREMENT
		/begin MEASUREMENT Rvlv_pf_cru_whl_cmd_cpt
			"Rvlv_pf_cru_whl_cmd_cpt"
			UBYTE
			F_8_p0_56
			2
			2
			0
			2040
			ECU_ADDRESS 0xFFFF81CF
		/end MEASUREMENT
		/begin MEASUREMENT Rvlv_pf_cru_whl_cmd_out
			"Rvlv_pf_cru_whl_cmd_out"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF816C
		/end MEASUREMENT
		/begin MEASUREMENT Rvlv_raw_gear_lih_out
			"Rvlv_raw_gear_lih_out"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF816D
		/end MEASUREMENT
		/begin MEASUREMENT Rvlv_set_minus_lng_press_cpt
			"Rvlv_set_minus_lng_press_cpt"
			UBYTE
			F_0v008_p0_172
			2
			2
			0
			2.04
			ECU_ADDRESS 0xFFFF81D0
		/end MEASUREMENT
		/begin MEASUREMENT Rvlv_set_plus_lng_press_cpt
			"Rvlv_set_plus_lng_press_cpt"
			UBYTE
			F_0v008_p0_172
			2
			2
			0
			2.04
			ECU_ADDRESS 0xFFFF81D1
		/end MEASUREMENT
		/begin MEASUREMENT Rvlv_sl_lk_stt_cpt
			"Rvlv_sl_lk_stt_cpt"
			UBYTE
			F_0v128_p0_75
			2
			2
			0
			32.64
			ECU_ADDRESS 0xFFFF81D2
		/end MEASUREMENT
		/begin MEASUREMENT Rvlv_sudn_brk_det_cpt
			"Rvlv_sudn_brk_det_cpt"
			UBYTE
			F_32_p0_122
			2
			2
			0
			8160
			ECU_ADDRESS 0xFFFF81D3
		/end MEASUREMENT
		/begin MEASUREMENT Rvlv_sudn_brk_det_out
			"Rvlv_sudn_brk_det_out"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF816E
		/end MEASUREMENT
		/begin MEASUREMENT Rvlv_time_dspl_vs_nok_out
			"Rvlv_time_dspl_vs_nok_out"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF816F
		/end MEASUREMENT
		/begin MEASUREMENT Rvlv_time_vs_nok_out
			"Rvlv_time_vs_nok_out"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8170
		/end MEASUREMENT
		/begin MEASUREMENT Rvlv_transition_cru_sl
			"Rvlv_transition_cru_sl"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8171
		/end MEASUREMENT
		/begin MEASUREMENT Rvlv_vs_nok_prev
			"Rvlv_vs_nok_prev"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8172
		/end MEASUREMENT
		/begin MEASUREMENT Sample_cliquetis
			"Sample_cliquetis"
			UWORD
			D_2_0v0004_p0_295
			2
			2
			0.03814755474
			2500
			ECU_ADDRESS 0xFFFF74C8
		/end MEASUREMENT
		/begin MEASUREMENT Sauve_eeprom_bool_cible_tlz
			"Sauve_eeprom_bool_cible_tlz"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF88E2
		/end MEASUREMENT
		/begin MEASUREMENT Sauve_eeprom_bool_correc_tlz
			"Sauve_eeprom_bool_correc_tlz"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF88DA
		/end MEASUREMENT
		/begin MEASUREMENT Sauve_eeprom_bool_defaut_trz
			"Sauve_eeprom_bool_defaut_trz"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF861A
		/end MEASUREMENT
		/begin MEASUREMENT Sauve_rco_purge_canister
			"Sauve_rco_purge_canister"
			UWORD
			F_0v0032_p0_8
			2
			2
			0
			209.712
			ECU_ADDRESS 0xFFFF80B8
		/end MEASUREMENT
		/begin MEASUREMENT Sauve_rco_wastegate
			"Sauve_rco_wastegate"
			UWORD
			F_0v0032_p0_8
			2
			2
			0
			209.712
			ECU_ADDRESS 0xFFFF84D0
		/end MEASUREMENT
		/begin MEASUREMENT Sauve_vxx_tlz_ad_b1_fil1
			"Sauve_vxx_tlz_ad_b1_fil1"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF88E4
		/end MEASUREMENT
		/begin MEASUREMENT Sauve_vxx_tlz_ad_b1_fil2
			"Sauve_vxx_tlz_ad_b1_fil2"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF88E6
		/end MEASUREMENT
		/begin MEASUREMENT Sauve_vxx_tlz_ad_b2_fil1
			"Sauve_vxx_tlz_ad_b2_fil1"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF88E8
		/end MEASUREMENT
		/begin MEASUREMENT Sauve_vxx_tlz_ad_b2_fil2
			"Sauve_vxx_tlz_ad_b2_fil2"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF88EA
		/end MEASUREMENT
		/begin MEASUREMENT Sauvegarde_eeprom_deja_lancee_
			"Sauvegarde_eeprom_deja_lancee"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8144
		/end MEASUREMENT
		/begin MEASUREMENT Sauvegarde_nb_ecritures_lancee
			"Sauvegarde_nb_ecritures_lancee"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8145
		/end MEASUREMENT
		/begin MEASUREMENT Sauvegarde_prot_stt_effectuee
			"Sauvegarde_prot_stt_effectuee"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6BEA
		/end MEASUREMENT
		/begin MEASUREMENT Save_hyst_bas_
			"Save_hyst_bas"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF79B3
		/end MEASUREMENT
		/begin MEASUREMENT Save_hyst_haut_
			"Save_hyst_haut"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF79B4
		/end MEASUREMENT
		/begin MEASUREMENT Saved_checksum
			"Saved_checksum"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7C24
		/end MEASUREMENT
		/begin MEASUREMENT Schedule_demande
			"Schedule_demande"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7BE9
		/end MEASUREMENT
		/begin MEASUREMENT Schedule_moniteur
			"Schedule_moniteur"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7E84
		/end MEASUREMENT
		/begin MEASUREMENT Scheduled_task
			"Scheduled_task"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7E88
		/end MEASUREMENT
		/begin MEASUREMENT Sdf_failure_counter_12
			"Sdf_failure_counter_12"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8325
		/end MEASUREMENT
		/begin MEASUREMENT Sdf_failure_counter_22
			"Sdf_failure_counter_22"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8326
		/end MEASUREMENT
		/begin MEASUREMENT Sdf_full_load_cond_hyst_output
			"Sdf_full_load_cond_hyst_output"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF82F4
		/end MEASUREMENT
		/begin MEASUREMENT Sdf_torque_request_bkpt
			"Sdf_torque_request_bkpt"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF8370
		/end MEASUREMENT
		/begin MEASUREMENT Seed_old_alea
			"Seed_old_alea"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF86BC
		/end MEASUREMENT
		/begin MEASUREMENT Seed_timer
			"Seed_timer"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF86BA
		/end MEASUREMENT
		/begin MEASUREMENT Seq_mode_test_obd_fdc_prem_
			"Seq_mode_test_obd_fdc_prem"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7CF5
		/end MEASUREMENT
		/begin MEASUREMENT Seq_mode_test_obd_sav_prem
			"Seq_mode_test_obd_sav_prem"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7CF6
		/end MEASUREMENT
		/begin MEASUREMENT Seuil_amorcage_echap_cata
			"Seuil_amorcage_echap_cata"
			UWORD
			F_1_p0_53
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF6D62
		/end MEASUREMENT
		/begin MEASUREMENT Seuil_amorcage_pauvre_cata_
			"Seuil_amorcage_pauvre_cata"
			UWORD
			F_1_p0_53
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF6D64
		/end MEASUREMENT
		/begin MEASUREMENT Seuil_amorcage_repartition_
			"Seuil_amorcage_repartition"
			UWORD
			F_1_p0_53
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF6D66
		/end MEASUREMENT
		/begin MEASUREMENT Seuil_depollution
			"Seuil_depollution"
			UWORD
			F_1_p0_53
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF6D68
		/end MEASUREMENT
		/begin MEASUREMENT Seuil_rechauffage_cata_
			"Seuil_rechauffage_cata"
			UWORD
			F_1_p0_53
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF6D6A
		/end MEASUREMENT
		/begin MEASUREMENT Seuil_rechauffage_habitacle_
			"Seuil_rechauffage_habitacle"
			UWORD
			F_1_p0_53
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF6D6C
		/end MEASUREMENT
		/begin MEASUREMENT Signal_consommation
			"Signal_consommation"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF75A4
		/end MEASUREMENT
		/begin MEASUREMENT Skeyfaileep
			"Skey_en_defaut"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6BEB
		/end MEASUREMENT
		/begin MEASUREMENT Skeystate
			"Skey_state"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF6C06
		/end MEASUREMENT
		/begin MEASUREMENT Somme_clq
			"Somme_clq"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF74CA
		/end MEASUREMENT
		/begin MEASUREMENT Somme_clq_cyl1
			"Somme_clq_cyl1"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF74CC
		/end MEASUREMENT
		/begin MEASUREMENT Somme_clq_cyl2
			"Somme_clq_cyl2"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF74D2
		/end MEASUREMENT
		/begin MEASUREMENT Somme_clq_cyl3
			"Somme_clq_cyl3"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF74CE
		/end MEASUREMENT
		/begin MEASUREMENT Somme_clq_cyl4
			"Somme_clq_cyl4"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF74D0
		/end MEASUREMENT
		/begin MEASUREMENT Sortie_huile_sommeil_driver
			"Sortie_huile_sommeil_driver"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7C2C
		/end MEASUREMENT
		/begin MEASUREMENT Sortie_regime
			"Sortie_regime"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6BAA
		/end MEASUREMENT
		/begin MEASUREMENT Sortie_regime_sommeil_driver
			"Sortie_regime_sommeil_driver"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7C2D
		/end MEASUREMENT
		/begin MEASUREMENT Sortie_rs_acc_command
			"Sortie_rs_acc_command"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8173
		/end MEASUREMENT
		/begin MEASUREMENT Spi_busy
			"Spi_busy"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF82B5
		/end MEASUREMENT
		/begin MEASUREMENT Spi_num
			"Spi_num"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF82BC
		/end MEASUREMENT
		/begin MEASUREMENT Spi_receive
			"Spi_receive"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF826F
		/end MEASUREMENT
		/begin MEASUREMENT Ssm_closed_throttle_pos_
			"Ssm_closed_throttle_pos"
			UWORD
			F_0v097656_p0_5
			2
			2
			0
			6399.88596
			ECU_ADDRESS 0xFFFF7700
		/end MEASUREMENT
		/begin MEASUREMENT Ssm_filt_throttle_position
			"Ssm_filt_throttle_position"
			UWORD
			F_0v048828125_p0_199
			2
			2
			0
			3199.951172
			ECU_ADDRESS 0xFFFF7702
		/end MEASUREMENT
		/begin MEASUREMENT Ssm_limp_home_throttle_pos_
			"Ssm_limp_home_throttle_pos"
			UWORD
			F_0v097656_p0_5
			2
			2
			0
			6399.88596
			ECU_ADDRESS 0xFFFF7704
		/end MEASUREMENT
		/begin MEASUREMENT Ssm_open_throttle_pos_
			"Ssm_open_throttle_pos"
			UWORD
			F_0v097656_p0_5
			2
			2
			0
			6399.88596
			ECU_ADDRESS 0xFFFF7706
		/end MEASUREMENT
		/begin MEASUREMENT Ssm_pedal_pos_failure_
			"SSM_PEDAL_POS_FAILURE"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x8
			ECU_ADDRESS 0xFFFF7690
		/end MEASUREMENT
		/begin MEASUREMENT Ssm_pedal_pos_normal_
			"SSM_PEDAL_POS_NORMAL"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7690
		/end MEASUREMENT
		/begin MEASUREMENT Ssm_pedal_pos_sens_stat_prec
			"Ssm_pedal_pos_sens_stat_prec"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF768F
		/end MEASUREMENT
		/begin MEASUREMENT Ssm_pedal_pos_sensing_status_
			"Ssm_pedal_pos_sensing_status"
			UBYTE
			Ssm_pedal_pos_sensing_status__conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF7690
		/end MEASUREMENT
		/begin MEASUREMENT Ssm_pedal_pos_single_1_
			"SSM_PEDAL_POS_SINGLE_1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x2
			ECU_ADDRESS 0xFFFF7690
		/end MEASUREMENT
		/begin MEASUREMENT Ssm_pedal_pos_single_1_diag_inh_
			"Ssm_pedal_pos_single_1_diag_inh"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8247
		/end MEASUREMENT
		/begin MEASUREMENT Ssm_pedal_pos_single_2_
			"SSM_PEDAL_POS_SINGLE_2"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x4
			ECU_ADDRESS 0xFFFF7690
		/end MEASUREMENT
		/begin MEASUREMENT Ssm_pedal_pos_single_2_diag_inh_
			"Ssm_pedal_pos_single_2_diag_inh"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8248
		/end MEASUREMENT
		/begin MEASUREMENT Ssm_precise_pedal_position_
			"Ssm_precise_pedal_position"
			UWORD
			F_0v097656_p0_5
			2
			2
			0
			6399.88596
			ECU_ADDRESS 0xFFFF7708
		/end MEASUREMENT
		/begin MEASUREMENT Ssm_precise_pedal_position_temp
			"Ssm_precise_pedal_position_temp"
			UWORD
			F_0v097656_p0_5
			2
			2
			0
			6399.88596
			ECU_ADDRESS 0xFFFF770A
		/end MEASUREMENT
		/begin MEASUREMENT Ssm_raw_filt_throttle_pos_prev
			"Ssm_raw_filt_throttle_pos_prev"
			UWORD
			F_0v048828125_p0_199
			2
			2
			0
			3199.951172
			ECU_ADDRESS 0xFFFF770C
		/end MEASUREMENT
		/begin MEASUREMENT Ssm_raw_filt_throttle_position_
			"Ssm_raw_filt_throttle_position"
			UWORD
			F_0v048828125_p0_199
			2
			2
			0
			3199.951172
			ECU_ADDRESS 0xFFFF770E
		/end MEASUREMENT
		/begin MEASUREMENT Ssm_throt_pos_normal_diag_inh_
			"Ssm_throt_pos_normal_diag_inh"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8249
		/end MEASUREMENT
		/begin MEASUREMENT Ssm_throt_pos_single_1_diag_inh_
			"Ssm_throt_pos_single_1_diag_inh"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF824A
		/end MEASUREMENT
		/begin MEASUREMENT Ssm_throt_pos_single_2_diag_inh_
			"Ssm_throt_pos_single_2_diag_inh"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF824B
		/end MEASUREMENT
		/begin MEASUREMENT Ssm_throttle_pos_failure_
			"SSM_THROTTLE_POS_FAILURE"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x8
			ECU_ADDRESS 0xFFFF7692
		/end MEASUREMENT
		/begin MEASUREMENT Ssm_throttle_pos_normal_
			"SSM_THROTTLE_POS_NORMAL"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7692
		/end MEASUREMENT
		/begin MEASUREMENT Ssm_throttle_pos_sens_stat_prec
			"Ssm_throttle_pos_sens_stat_prec"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7691
		/end MEASUREMENT
		/begin MEASUREMENT Ssm_throttle_pos_sensing_status_
			"Ssm_throttle_pos_sensing_status"
			UBYTE
			Ssm_throttle_pos_sensing_status__conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF7692
		/end MEASUREMENT
		/begin MEASUREMENT Ssm_throttle_pos_single_1_
			"SSM_THROTTLE_POS_SINGLE_1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x2
			ECU_ADDRESS 0xFFFF7692
		/end MEASUREMENT
		/begin MEASUREMENT SSM_THROTTLE_POS_SINGLE_2
			"SSM_THROTTLE_POS_SINGLE_2"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x4
			ECU_ADDRESS 0xFFFF7692
		/end MEASUREMENT
		/begin MEASUREMENT Sstavrp
			"Seuil_stabilite_reco_rapport"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF80CB
		/end MEASUREMENT
		/begin MEASUREMENT Statudem
			"Starter_status"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF730A
		/end MEASUREMENT
		/begin MEASUREMENT Status_register_defaut
			"Status_register_defaut"
			ULONG
			Id_0x00
			2
			2
			0
			4294967295
			ECU_ADDRESS 0xFFFF6508
		/end MEASUREMENT
		/begin MEASUREMENT Status_register_defaut_eep
			"Status_register_defaut_eep"
			ULONG
			Id_0x00
			2
			2
			0
			4294967295
			ECU_ADDRESS 0xFFFF7BF8
		/end MEASUREMENT
		/begin MEASUREMENT Status_register_defaut_lsb
			"Status_register_defaut_lsb"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF8944
		/end MEASUREMENT
		/begin MEASUREMENT Status_register_defaut_msb
			"Status_register_defaut_msb"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF8942
		/end MEASUREMENT
		/begin MEASUREMENT Surveillance_gmv1_
			"SURVEILLANCE_GMV1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF792A
		/end MEASUREMENT
		/begin MEASUREMENT Sxx_vf_dtc_0
			"Sxx_vf_dtc_0"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF881E
		/end MEASUREMENT
		/begin MEASUREMENT Sxx_vf_dtc_1
			"Sxx_vf_dtc_1"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF8820
		/end MEASUREMENT
		/begin MEASUREMENT Sxx_vf_dtc_2
			"Sxx_vf_dtc_2"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF8822
		/end MEASUREMENT
		/begin MEASUREMENT Sxx_vf_dtc_3
			"Sxx_vf_dtc_3"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF8824
		/end MEASUREMENT
		/begin MEASUREMENT Sxx_vf_dtc_4
			"Sxx_vf_dtc_4"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF8826
		/end MEASUREMENT
		/begin MEASUREMENT Sxx_vf_dtc_5
			"Sxx_vf_dtc_5"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF8828
		/end MEASUREMENT
		/begin MEASUREMENT Sxx_vf_dtc_6
			"Sxx_vf_dtc_6"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF882A
		/end MEASUREMENT
		/begin MEASUREMENT Sxx_vf_dtc_7
			"Sxx_vf_dtc_7"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF882C
		/end MEASUREMENT
		/begin MEASUREMENT Sxx_vf_dtc_8
			"Sxx_vf_dtc_8"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF882E
		/end MEASUREMENT
		/begin MEASUREMENT Sxx_vf_dtc_9
			"Sxx_vf_dtc_9"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF8830
		/end MEASUREMENT
		/begin MEASUREMENT Synchro_perdu_lis
			"Synchro_perdu_lis"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7F20
		/end MEASUREMENT
		/begin MEASUREMENT Tab_memorisation_charge_a
			"Tab_memorisation_charge_a"
			UWORD
			F_0v003_p0_297
			2
			2
			0
			196.605
			ECU_ADDRESS 0xFFFF8372
		/end MEASUREMENT
		/begin MEASUREMENT Tab_memorisation_charge_b
			"Tab_memorisation_charge_b"
			UWORD
			F_0v003_p0_297
			2
			2
			0
			196.605
			ECU_ADDRESS 0xFFFF8374
		/end MEASUREMENT
		/begin MEASUREMENT Tab_memorisation_charge_c
			"Tab_memorisation_charge_c"
			UWORD
			F_0v003_p0_297
			2
			2
			0
			196.605
			ECU_ADDRESS 0xFFFF8376
		/end MEASUREMENT
		/begin MEASUREMENT Tab_memorisation_charge_d
			"Tab_memorisation_charge_d"
			UWORD
			F_0v003_p0_297
			2
			2
			0
			196.605
			ECU_ADDRESS 0xFFFF8378
		/end MEASUREMENT
		/begin MEASUREMENT Table_conver_na
			"Table_conver_na"
			ULONG
			Id_0x00
			2
			2
			0
			4294967295
			ECU_ADDRESS 0x100000
		/end MEASUREMENT
		/begin MEASUREMENT Table_des_codes_test_act_
			"Table_des_codes_test_act"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xA254
		/end MEASUREMENT
		/begin MEASUREMENT Table_des_codes_test_act_can
			"Table_des_codes_test_act_can"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xA265
		/end MEASUREMENT
		/begin MEASUREMENT Table_resultat_test_mcw_mcp_
			"Table_resultat_test_mcw_mcp"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0x8B7D
		/end MEASUREMENT
		/begin MEASUREMENT Table_top_pmh
			"Table_top_pmh"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xA24C
		/end MEASUREMENT
		/begin MEASUREMENT Table_vecteur_calcul_mcw_mcp_
			"Table_vecteur_calcul_mcw_mcp"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0x8B7A
		/end MEASUREMENT
		/begin MEASUREMENT Take_off_condition_pos_pedale
			"Take_off_condition_pos_pedale"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8087
		/end MEASUREMENT
		/begin MEASUREMENT Take_off_condition_rap_boite
			"Take_off_condition_rap_boite"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8088
		/end MEASUREMENT
		/begin MEASUREMENT Take_off_condition_regime
			"Take_off_condition_regime"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8089
		/end MEASUREMENT
		/begin MEASUREMENT Take_off_condition_vitesse
			"Take_off_condition_vitesse"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF808A
		/end MEASUREMENT
		/begin MEASUREMENT Tdecrpda
			"Tempo_decrem_reg_pda"
			UBYTE
			F_0v128_p0_75
			2
			2
			0
			32.64
			ECU_ADDRESS 0xFFFF80EF
		/end MEASUREMENT
		/begin MEASUREMENT Tdmrisda1
			"Tempo_maintien_reg_pda"
			UBYTE
			F_0v128_p0_75
			2
			2
			0
			32.64
			ECU_ADDRESS 0xFFFF80F1
		/end MEASUREMENT
		/begin MEASUREMENT Temp_ub_debug
			"Temp_ub_debug"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7CE8
		/end MEASUREMENT
		/begin MEASUREMENT Temp_uw_debug
			"Temp_uw_debug"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7CEA
		/end MEASUREMENT
		/begin MEASUREMENT Temperature_air_brute_
			"Temperature_air_brute"
			UWORD
			F_0v0048828125_p0_281
			2
			2
			0
			319.9951172
			ECU_ADDRESS 0xFFFF6D10
		/end MEASUREMENT
		/begin MEASUREMENT Temperature_air_result_ad_conv_
			"Temperature_air_result_ad_conv"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFFF82C
		/end MEASUREMENT
		/begin MEASUREMENT Temperature_eau_brute_
			"Temperature_eau_brute"
			UWORD
			F_0v0048828125_p0_281
			2
			2
			0
			319.9951172
			ECU_ADDRESS 0xFFFF8596
		/end MEASUREMENT
		/begin MEASUREMENT Temperature_eau_result_ad_conv_
			"Temperature_eau_result_ad_conv"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFFF82A
		/end MEASUREMENT
		/begin MEASUREMENT Tempo_active_diag_cat_prem_
			"Tempo_active_diag_cat_prem"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7CF7
		/end MEASUREMENT
		/begin MEASUREMENT Tempo_active_diag_fsys_prem
			"Tempo_active_diag_fsys_prem"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7CF8
		/end MEASUREMENT
		/begin MEASUREMENT Tempo_active_diag_msf_prem_
			"Tempo_active_diag_msf_prem"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7CF9
		/end MEASUREMENT
		/begin MEASUREMENT Tempo_active_diag_sondes_prem_
			"Tempo_active_diag_sondes_prem"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7CFA
		/end MEASUREMENT
		/begin MEASUREMENT Tempo_autorise_diagnostic
			"Tempo_autorise_diagnostic"
			UBYTE
			F_0v256_p0_299
			2
			2
			0
			65.28
			ECU_ADDRESS 0xFFFF7851
		/end MEASUREMENT
		/begin MEASUREMENT Tempo_boucle_rapide_cyl_1_
			"Tempo_boucle_rapide_cyl_1"
			UBYTE
			F_16_p0_10
			2
			2
			0
			4080
			ECU_ADDRESS 0xFFFF6D9E
		/end MEASUREMENT
		/begin MEASUREMENT Tempo_boucle_rapide_cyl_2_
			"Tempo_boucle_rapide_cyl_2"
			UBYTE
			F_16_p0_10
			2
			2
			0
			4080
			ECU_ADDRESS 0xFFFF6DA1
		/end MEASUREMENT
		/begin MEASUREMENT Tempo_boucle_rapide_cyl_3_
			"Tempo_boucle_rapide_cyl_3"
			UBYTE
			F_16_p0_10
			2
			2
			0
			4080
			ECU_ADDRESS 0xFFFF6D9F
		/end MEASUREMENT
		/begin MEASUREMENT Tempo_boucle_rapide_cyl_4_
			"Tempo_boucle_rapide_cyl_4"
			UBYTE
			F_16_p0_10
			2
			2
			0
			4080
			ECU_ADDRESS 0xFFFF6DA0
		/end MEASUREMENT
		/begin MEASUREMENT Tempo_change_oten_
			"Tempo_change_oten"
			UBYTE
			F_256_p0_142
			2
			2
			0
			65280
			ECU_ADDRESS 0xFFFF7D82
		/end MEASUREMENT
		/begin MEASUREMENT Tempo_connexion_ev_iae_1
			"Tempo_connexion_ev_iae_1"
			UBYTE
			F_8_p0_56
			2
			2
			0
			2040
			ECU_ADDRESS 0xFFFF84B1
		/end MEASUREMENT
		/begin MEASUREMENT Tempo_connexion_ev_iae_2
			"Tempo_connexion_ev_iae_2"
			UBYTE
			F_8_p0_56
			2
			2
			0
			2040
			ECU_ADDRESS 0xFFFF84B2
		/end MEASUREMENT
		/begin MEASUREMENT Tempo_connexion_gmv_1
			"Tempo_connexion_gmv_1"
			UBYTE
			F_8_p0_56
			2
			2
			0
			2040
			ECU_ADDRESS 0xFFFF7928
		/end MEASUREMENT
		/begin MEASUREMENT Tempo_connexion_gmv_2
			"Tempo_connexion_gmv_2"
			UBYTE
			F_8_p0_56
			2
			2
			0
			2040
			ECU_ADDRESS 0xFFFF7929
		/end MEASUREMENT
		/begin MEASUREMENT Tempo_connexion_pav_1
			"Tempo_connexion_pav_1"
			UBYTE
			F_8_p0_56
			2
			2
			0
			2040
			ECU_ADDRESS 0xFFFF7903
		/end MEASUREMENT
		/begin MEASUREMENT Tempo_connexion_pav_2
			"Tempo_connexion_pav_2"
			UBYTE
			F_8_p0_56
			2
			2
			0
			2040
			ECU_ADDRESS 0xFFFF7904
		/end MEASUREMENT
		/begin MEASUREMENT Tempo_connexion_pmpair_1
			"Tempo_connexion_pmpair_1"
			UBYTE
			F_8_p0_56
			2
			2
			0
			2040
			ECU_ADDRESS 0xFFFF84B3
		/end MEASUREMENT
		/begin MEASUREMENT Tempo_connexion_pmpair_2
			"Tempo_connexion_pmpair_2"
			UBYTE
			F_8_p0_56
			2
			2
			0
			2040
			ECU_ADDRESS 0xFFFF84B4
		/end MEASUREMENT
		/begin MEASUREMENT Tempo_connexion_ptc_rov_1
			"Tempo_connexion_ptc_rov_1"
			UBYTE
			F_8_p0_56
			2
			2
			0
			2040
			ECU_ADDRESS 0xFFFF815B
		/end MEASUREMENT
		/begin MEASUREMENT Tempo_connexion_ptc_rov_2
			"Tempo_connexion_ptc_rov_2"
			UBYTE
			F_8_p0_56
			2
			2
			0
			2040
			ECU_ADDRESS 0xFFFF815C
		/end MEASUREMENT
		/begin MEASUREMENT Tempo_connexion_thp_1_
			"Tempo_connexion_thp_1"
			UBYTE
			F_8_p0_56
			2
			2
			0
			2040
			ECU_ADDRESS 0xFFFF82E0
		/end MEASUREMENT
		/begin MEASUREMENT Tempo_connexion_thp_2_
			"Tempo_connexion_thp_2"
			UBYTE
			F_8_p0_56
			2
			2
			0
			2040
			ECU_ADDRESS 0xFFFF82E1
		/end MEASUREMENT
		/begin MEASUREMENT Tempo_connexion_wpmp_1
			"Tempo_connexion_wpmp_1"
			UBYTE
			F_8_p0_56
			2
			2
			0
			2040
			ECU_ADDRESS 0xFFFF7F15
		/end MEASUREMENT
		/begin MEASUREMENT Tempo_connexion_wpmp_2
			"Tempo_connexion_wpmp_2"
			UBYTE
			F_8_p0_56
			2
			2
			0
			2040
			ECU_ADDRESS 0xFFFF7F16
		/end MEASUREMENT
		/begin MEASUREMENT Tempo_correction_tempo
			"Tempo_correction_tempo"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF79C1
		/end MEASUREMENT
		/begin MEASUREMENT Tempo_coupure_cmd_gpl
			"Tempo_coupure_cmd_gpl"
			UBYTE
			F_4_p0_128
			2
			2
			0
			1020
			ECU_ADDRESS 0xFFFF7EBC
		/end MEASUREMENT
		/begin MEASUREMENT Tempo_coupure_relais_pompe
			"Tempo_coupure_relais_pompe"
			UBYTE
			F_8_p0_56
			2
			2
			0
			2040
			ECU_ADDRESS 0xFFFF8152
		/end MEASUREMENT
		/begin MEASUREMENT Tempo_coupure_relais_pwrl
			"Tempo_coupure_relais_pwrl"
			UBYTE
			F_8_p0_56
			2
			2
			0
			2040
			ECU_ADDRESS 0xFFFF8153
		/end MEASUREMENT
		/begin MEASUREMENT Tempo_decrem_el_wind
			"Tempo_decrem_el_wind"
			UBYTE
			F_128_p0_125
			2
			2
			0
			32640
			ECU_ADDRESS 0xFFFF80ED
		/end MEASUREMENT
		/begin MEASUREMENT Tempo_decrem_reg_bva_
			"Tempo_decrem_reg_bva"
			UBYTE
			F_128_p0_125
			2
			2
			0
			32640
			ECU_ADDRESS 0xFFFF80EE
		/end MEASUREMENT
		/begin MEASUREMENT Tempo_decrem_reg_ptc
			"Tempo_decrem_reg_ptc"
			UBYTE
			F_128_p0_125
			2
			2
			0
			32640
			ECU_ADDRESS 0xFFFF80F0
		/end MEASUREMENT
		/begin MEASUREMENT Tempo_diag_etat_bas_wpmp
			"Tempo_diag_etat_bas_wpmp"
			UBYTE
			F_16_p0_10
			2
			2
			0
			4080
			ECU_ADDRESS 0xFFFF7852
		/end MEASUREMENT
		/begin MEASUREMENT Tempo_edic_
			"Tempo_edic"
			UWORD
			F_32_p0_122
			2
			2
			0
			2097120
			ECU_ADDRESS 0xFFFF7DE6
		/end MEASUREMENT
		/begin MEASUREMENT Tempo_inc_dec_ret_av_pda_
			"Tempo_inc_dec_ret_av_pda"
			UBYTE
			F_16_p0_10
			2
			2
			0
			4080
			ECU_ADDRESS 0xFFFF6DA2
		/end MEASUREMENT
		/begin MEASUREMENT Tempo_mask_time
			"Tempo_mask_time"
			UBYTE
			F_16_p0_10
			2
			2
			0
			4080
			ECU_ADDRESS 0xFFFF8327
		/end MEASUREMENT
		/begin MEASUREMENT Tempo_max_sauvegarde_eeprom
			"Tempo_max_sauvegarde_eeprom"
			UBYTE
			F_128_p0_125
			2
			2
			0
			32640
			ECU_ADDRESS 0xFFFF8154
		/end MEASUREMENT
		/begin MEASUREMENT Tempo_oten_
			"Tempo_oten"
			UWORD
			F_8_p0_56
			2
			2
			0
			524280
			ECU_ADDRESS 0xFFFF7DE8
		/end MEASUREMENT
		/begin MEASUREMENT Tempo_oten_continu_
			"Tempo_oten_continu"
			UWORD
			F_1_p0_53
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7DEA
		/end MEASUREMENT
		/begin MEASUREMENT Tempo_pas_duree_retrait_max_lh_
			"Tempo_pas_duree_retrait_max_lh"
			UBYTE
			F_32_p0_122
			2
			2
			0
			8160
			ECU_ADDRESS 0xFFFF6DA3
		/end MEASUREMENT
		/begin MEASUREMENT Tempo_sdf_test_actionneur_
			"Tempo_sdf_test_actionneur"
			UBYTE
			F_64_p0_145
			2
			2
			0
			16320
			ECU_ADDRESS 0xFFFF82CB
		/end MEASUREMENT
		/begin MEASUREMENT Tempo_srv_abs_br
			"Tempo_srv_abs_br"
			UBYTE
			F_8_p0_56
			2
			2
			0
			2040
			ECU_ADDRESS 0xFFFF73B0
		/end MEASUREMENT
		/begin MEASUREMENT Tempo_srv_acc
			"Tempo_srv_acc"
			UBYTE
			F_8_p0_56
			2
			2
			0
			2040
			ECU_ADDRESS 0xFFFF73C1
		/end MEASUREMENT
		/begin MEASUREMENT Tempo_srv_bva_br
			"Tempo_srv_bva_br"
			UBYTE
			F_8_p0_56
			2
			2
			0
			2040
			ECU_ADDRESS 0xFFFF73CE
		/end MEASUREMENT
		/begin MEASUREMENT Tempo_srv_clim_base
			"Tempo_srv_clim_base"
			UBYTE
			F_8_p0_56
			2
			2
			0
			2040
			ECU_ADDRESS 0xFFFF73E4
		/end MEASUREMENT
		/begin MEASUREMENT Tempo_srv_gpl
			"Tempo_srv_gpl"
			UBYTE
			F_8_p0_56
			2
			2
			0
			2040
			ECU_ADDRESS 0xFFFF73FB
		/end MEASUREMENT
		/begin MEASUREMENT Tempo_srv_tdb
			"Tempo_srv_tdb"
			UBYTE
			F_8_p0_56
			2
			2
			0
			2040
			ECU_ADDRESS 0xFFFF7413
		/end MEASUREMENT
		/begin MEASUREMENT Tempo_srv_uch
			"Tempo_srv_uch"
			UBYTE
			F_8_p0_56
			2
			2
			0
			2040
			ECU_ADDRESS 0xFFFF7432
		/end MEASUREMENT
		/begin MEASUREMENT Tempo_surveillance_liaison_
			"Tempo_surveillance_liaison"
			UBYTE
			F_128_p0_125
			2
			2
			0
			32640
			ECU_ADDRESS 0xFFFF7318
		/end MEASUREMENT
		/begin MEASUREMENT Tempo_test_actionneur_
			"Tempo_test_actionneur"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF82CC
		/end MEASUREMENT
		/begin MEASUREMENT Tempo_throt_closing
			"Tempo_throt_closing"
			UWORD
			F_8_p0_56
			2
			2
			0
			524280
			ECU_ADDRESS 0xFFFF837A
		/end MEASUREMENT
		/begin MEASUREMENT Tempo_transition_inj_a_
			"TEMPO_TRANSITION_INJ_A"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x2
			ECU_ADDRESS 0xFFFF7AA5
		/end MEASUREMENT
		/begin MEASUREMENT Tempo_transition_inj_b_
			"TEMPO_TRANSITION_INJ_B"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x8
			ECU_ADDRESS 0xFFFF7AA5
		/end MEASUREMENT
		/begin MEASUREMENT Tempo_transition_inj_c_
			"TEMPO_TRANSITION_INJ_C"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x20
			ECU_ADDRESS 0xFFFF7AA5
		/end MEASUREMENT
		/begin MEASUREMENT Tempo_transition_inj_d_
			"TEMPO_TRANSITION_INJ_D"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x80
			ECU_ADDRESS 0xFFFF7AA5
		/end MEASUREMENT
		/begin MEASUREMENT Temps_8_signaux_vit_precedent_
			"Temps_8_signaux_vit_precedent"
			UWORD
			F_1_p0_54
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF8298
		/end MEASUREMENT
		/begin MEASUREMENT Temps_courant_vit_
			"Temps_courant_vit"
			UWORD
			F_1_p0_54
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF829A
		/end MEASUREMENT
		/begin MEASUREMENT Temps_cp_1
			"Temps_cp_1"
			UWORD
			F_3v2_p0_152
			2
			2
			0
			209712
			ECU_ADDRESS 0xFFFF7860
		/end MEASUREMENT
		/begin MEASUREMENT Temps_de_dwell_bob_a_c_
			"Temps_de_dwell_bob_a_c"
			UWORD
			F_0v0032_p0_8
			2
			2
			0
			209.712
			ECU_ADDRESS 0xFFFF6E4A
		/end MEASUREMENT
		/begin MEASUREMENT Temps_de_dwell_bob_b_d_
			"Temps_de_dwell_bob_b_d"
			UWORD
			F_0v0032_p0_8
			2
			2
			0
			209.712
			ECU_ADDRESS 0xFFFF6E4C
		/end MEASUREMENT
		/begin MEASUREMENT Temps_ev_iae_1
			"Temps_ev_iae_1"
			UWORD
			F_3v2_p0_152
			2
			2
			0
			209712
			ECU_ADDRESS 0xFFFF7862
		/end MEASUREMENT
		/begin MEASUREMENT Temps_fenetrage
			"Temps_fenetrage"
			UWORD
			D_2_0v0004_p0v054_181
			2
			2
			0.03806913355
			18.51851852
			ECU_ADDRESS 0xFFFF74D4
		/end MEASUREMENT
		/begin MEASUREMENT Temps_horloge_d_avant
			"Temps_horloge_d_avant"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7FA8
		/end MEASUREMENT
		/begin MEASUREMENT Temps_horloge_mcp_mcp_
			"Temps_horloge_mcp_mcp"
			UWORD
			F_4_p0_149
			2
			2
			0
			262140
			ECU_ADDRESS 0xFFFF827C
		/end MEASUREMENT
		/begin MEASUREMENT Temps_horloge_mcw_mcp_
			"Temps_horloge_mcw_mcp"
			UWORD
			F_4_p0_149
			2
			2
			0
			262140
			ECU_ADDRESS 0xFFFF827E
		/end MEASUREMENT
		/begin MEASUREMENT Temps_normal_
			"Temps_normal"
			UWORD
			F_0v004_p0_201
			2
			2
			0
			262.14
			ECU_ADDRESS 0xFFFF7B20
		/end MEASUREMENT
		/begin MEASUREMENT Temps_overboost
			"Temps_overboost"
			UWORD
			F_0v125_p0_300
			2
			2
			0
			8191.875
			ECU_ADDRESS 0xFFFF837C
		/end MEASUREMENT
		/begin MEASUREMENT Temps_panne_vitesse_
			"Temps_panne_vitesse"
			UBYTE
			F_0v128_p0_75
			2
			2
			0
			32.64
			ECU_ADDRESS 0xFFFF828E
		/end MEASUREMENT
		/begin MEASUREMENT Temps_ptc_rov_1
			"Temps_ptc_rov_1"
			UWORD
			F_3v2_p0_152
			2
			2
			0
			209712
			ECU_ADDRESS 0xFFFF7864
		/end MEASUREMENT
		/begin MEASUREMENT Temps_signal_vitesse_precedent_
			"Temps_signal_vitesse_precedent"
			UWORD
			F_1_p0_54
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF829C
		/end MEASUREMENT
		/begin MEASUREMENT Temps_wgc_1_etat_bas
			"Temps_wgc_1_etat_bas"
			UWORD
			F_3v2_p0_152
			2
			2
			0
			209712
			ECU_ADDRESS 0xFFFF7866
		/end MEASUREMENT
		/begin MEASUREMENT Temps_wgc_1_etat_haut
			"Temps_wgc_1_etat_haut"
			UWORD
			F_3v2_p0_152
			2
			2
			0
			209712
			ECU_ADDRESS 0xFFFF7868
		/end MEASUREMENT
		/begin MEASUREMENT Temps_wpmp_1
			"Temps_wpmp_1"
			UWORD
			F_3v2_p0_152
			2
			2
			0
			209712
			ECU_ADDRESS 0xFFFF786A
		/end MEASUREMENT
		/begin MEASUREMENT Ten_ms_counter
			"Ten_ms_counter"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7319
		/end MEASUREMENT
		/begin MEASUREMENT Tension_alim_1_result_ad_conv_
			"Tension_alim_1_result_ad_conv"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFFF800
		/end MEASUREMENT
		/begin MEASUREMENT Tension_alim_2_result_ad_conv_
			"Tension_alim_2_result_ad_conv"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFFF846
		/end MEASUREMENT
		/begin MEASUREMENT Tension_alimentation_1_
			"Tension_alimentation_1"
			UWORD
			F_0v0049_p0_301
			2
			2
			0
			321.1215
			ECU_ADDRESS 0xFFFF6D16
		/end MEASUREMENT
		/begin MEASUREMENT Tension_alimentation_1_brute_
			"Tension_alimentation_1_brute"
			UWORD
			F_0v0048828_p0_302
			2
			2
			0
			319.994298
			ECU_ADDRESS 0xFFFF6D18
		/end MEASUREMENT
		/begin MEASUREMENT Tension_alimentation_1_filtree
			"Tension_alimentation_1_filtree"
			UWORD
			F_0v0001525875_p0_303
			2
			2
			0
			9.999821812
			ECU_ADDRESS 0xFFFF6D1A
		/end MEASUREMENT
		/begin MEASUREMENT Tension_alimentation_1_mesuree_
			"Tension_alimentation_1_mesuree"
			UWORD
			F_0v0049_p0_301
			2
			2
			0
			321.1215
			ECU_ADDRESS 0xFFFF6D1C
		/end MEASUREMENT
		/begin MEASUREMENT Tension_alimentation_2_brute_
			"Tension_alimentation_2_brute"
			UWORD
			F_0v0048828_p0_302
			2
			2
			0
			319.994298
			ECU_ADDRESS 0xFFFF6D20
		/end MEASUREMENT
		/begin MEASUREMENT Tension_alimentation_2_mesuree_
			"Tension_alimentation_2_mesuree"
			UWORD
			F_0v0049_p0_301
			2
			2
			0
			321.1215
			ECU_ADDRESS 0xFFFF6D22
		/end MEASUREMENT
		/begin MEASUREMENT Tension_alimentation_capt2
			"Tension_alimentation_2"
			UWORD
			F_0v0049_p0_301
			2
			2
			0
			321.1215
			ECU_ADDRESS 0xFFFF6D1E
		/end MEASUREMENT
		/begin MEASUREMENT Tension_batterie_1mv
			"Tension_batterie_1mv"
			UWORD
			F_0v001_p0_284
			2
			2
			0
			65.535
			ECU_ADDRESS 0xFFFF6DE6
		/end MEASUREMENT
		/begin MEASUREMENT Tension_batterie_brute_
			"Tension_batterie_brute"
			UWORD
			F_0v023583984_p0_196
			2
			2
			0
			1545.576391
			ECU_ADDRESS 0xFFFF6DE8
		/end MEASUREMENT
		/begin MEASUREMENT Tension_batterie_para_
			"Tension_batterie_para"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF6DEA
		/end MEASUREMENT
		/begin MEASUREMENT Tension_batterie_result_ad_conv_
			"Tension_batterie_result_ad_conv"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFFF806
		/end MEASUREMENT
		/begin MEASUREMENT Tension_sonde_amont_1_precedent_
			"Tension_sonde_amont_1_precedent"
			UWORD
			F_9v76_p0_45
			2
			2
			0
			639621.6
			ECU_ADDRESS 0xFFFF7EE2
		/end MEASUREMENT
		/begin MEASUREMENT Test_actionneur_en_cours_
			"Test_actionneur_en_cours"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF82C6
		/end MEASUREMENT
		/begin MEASUREMENT Test_actionneur_on_
			"Test_actionneur_on"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF82C7
		/end MEASUREMENT
		/begin MEASUREMENT Test_stat_cpt_cyc_
			"Test_stat_cpt_cyc"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF82CD
		/end MEASUREMENT
		/begin MEASUREMENT Test_stat_duree_
			"Test_stat_duree"
			UWORD
			F_8_p0_56
			2
			2
			0
			524280
			ECU_ADDRESS 0xFFFF82D4
		/end MEASUREMENT
		/begin MEASUREMENT Test_stat_etat_
			"Test_stat_etat"
			UBYTE
			Test_stat_etat__conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF82CE
		/end MEASUREMENT
		/begin MEASUREMENT Test_statique_on_
			"Test_statique_on"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF82C8
		/end MEASUREMENT
		/begin MEASUREMENT Test_trame_crash_coh_eep
			"Test_trame_crash_coh_eep"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF88CA
		/end MEASUREMENT
		/begin MEASUREMENT Testnumber
			"Testnumber"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			BIT_MASK 0xF
			ECU_ADDRESS 0xFFFF7E7C
		/end MEASUREMENT
		/begin MEASUREMENT Teststatus
			"Teststatus"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			BIT_MASK 0xFFFFFFF0
			ECU_ADDRESS 0xFFFF7E7C
		/end MEASUREMENT
		/begin MEASUREMENT Timeout_freeze_counter
			"Timeout_freeze_counter"
			UWORD
			F_8_p0_56
			2
			2
			0
			524280
			ECU_ADDRESS 0xFFFF8092
		/end MEASUREMENT
		/begin MEASUREMENT Timer_autonomous_counter
			"Timer_autonomous_counter"
			UBYTE
			F_1v024_p0_119
			2
			2
			0
			261.12
			ECU_ADDRESS 0xFFFF808B
		/end MEASUREMENT
		/begin MEASUREMENT Tmpabsct
			"Tempo_panne_cont_trajectoire"
			UBYTE
			F_16_p0_10
			2
			2
			0
			4080
			ECU_ADDRESS 0xFFFF7315
		/end MEASUREMENT
		/begin MEASUREMENT Tmpatuch
			"Tempo_attente_reponse_uch"
			UBYTE
			F_10_p0_306
			2
			2
			0
			2550
			ECU_ADDRESS 0xFFFF6C07
		/end MEASUREMENT
		/begin MEASUREMENT Tmpatvsc
			"Tempo_attente_vsc"
			UBYTE
			F_8_p0_56
			2
			2
			0
			2040
			ECU_ADDRESS 0xFFFF7312
		/end MEASUREMENT
		/begin MEASUREMENT Tmpchgra
			"Tempo_changement_de_rapport"
			UBYTE
			F_128_p0_125
			2
			2
			0
			32640
			ECU_ADDRESS 0xFFFF7314
		/end MEASUREMENT
		/begin MEASUREMENT Tmpcnx
			"Tempo_autor_connex_uce_can"
			UBYTE
			F_128_p0_125
			2
			2
			0
			32640
			ECU_ADDRESS 0xFFFF7313
		/end MEASUREMENT
		/begin MEASUREMENT Tmpcoup
			"Tempo_avant_coupure"
			UBYTE
			F_0v032_p0_99
			2
			2
			0
			8.16
			ECU_ADDRESS 0xFFFF7AAD
		/end MEASUREMENT
		/begin MEASUREMENT Tmpcut
			"Tempo_interdit_coupure"
			UBYTE
			F_1v024_p0_119
			2
			2
			0
			261.12
			ECU_ADDRESS 0xFFFF7AAE
		/end MEASUREMENT
		/begin MEASUREMENT Tmpdem
			"Tmp1_attente_coupur_dem"
			UBYTE
			F_128_p0_125
			2
			2
			0
			32640
			ECU_ADDRESS 0xFFFF731B
		/end MEASUREMENT
		/begin MEASUREMENT Tmpmonat
			"Tim_srv_at_diag_off"
			UBYTE
			F_64_p0_145
			2
			2
			0
			16320
			ECU_ADDRESS 0xFFFF73CF
		/end MEASUREMENT
		/begin MEASUREMENT Tmpmxvsc
			"Tempo_reg_max_vsc"
			UBYTE
			F_128_p0_125
			2
			2
			0
			32640
			ECU_ADDRESS 0xFFFF7316
		/end MEASUREMENT
		/begin MEASUREMENT Tmpmyvsc
			"Tempo_reg_moyen_vsc"
			UBYTE
			F_32_p0_122
			2
			2
			0
			8160
			ECU_ADDRESS 0xFFFF7317
		/end MEASUREMENT
		/begin MEASUREMENT Tmpotpro
			"Tempo_fonct_mot_provisoire"
			UBYTE
			F_10_p0_306
			2
			2
			0
			2550
			ECU_ADDRESS 0xFFFF6C08
		/end MEASUREMENT
		/begin MEASUREMENT Tmpouto
			"Tmp2_attente_coupur_dem"
			UBYTE
			F_128_p0_125
			2
			2
			0
			32640
			ECU_ADDRESS 0xFFFF731C
		/end MEASUREMENT
		/begin MEASUREMENT Tmpsta
			"Tmp_attente_stop_dem"
			UBYTE
			F_8_p0_56
			2
			2
			0
			2040
			ECU_ADDRESS 0xFFFF731A
		/end MEASUREMENT
		/begin MEASUREMENT Tmpwlvl
			"Tempo_power_latch_vl"
			UBYTE
			F_100_p0_305
			2
			2
			0
			25500
			ECU_ADDRESS 0xFFFF6C09
		/end MEASUREMENT
		/begin MEASUREMENT Top_horloge_mcp1_
			"Top_horloge_mcp1"
			UWORD
			F_3v2_p0_152
			2
			2
			0
			209712
			ECU_ADDRESS 0xFFFF8280
		/end MEASUREMENT
		/begin MEASUREMENT Top_horloge_mcp2_
			"Top_horloge_mcp2"
			UWORD
			F_3v2_p0_152
			2
			2
			0
			209712
			ECU_ADDRESS 0xFFFF8282
		/end MEASUREMENT
		/begin MEASUREMENT Top_vitesse_vehicule_int_enable_
			"Top_vitesse_vehicule_int_enable"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8287
		/end MEASUREMENT
		/begin MEASUREMENT Topecm
			"Cranking_autorisation_ecm"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF72EB
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_1_filt_filt_position_
			"Tpac_1_filt_filt_position"
			UWORD
			F_0v097656_p0_5
			2
			2
			0
			6399.88596
			ECU_ADDRESS 0xFFFF7710
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_1_lh_measured_position
			"Tpac_1_lh_measured_position"
			UWORD
			F_0v09765625_p0_71
			2
			2
			0
			6399.902344
			ECU_ADDRESS 0xFFFF7712
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_1_max_measured_position_
			"Tpac_1_max_measured_position"
			UWORD
			F_0v097656_p0_5
			2
			2
			0
			6399.88596
			ECU_ADDRESS 0xFFFF7714
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_1_min_measured_position_
			"Tpac_1_min_measured_position"
			UWORD
			F_0v097656_p0_5
			2
			2
			0
			6399.88596
			ECU_ADDRESS 0xFFFF7716
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_2_filt_filt_position_
			"Tpac_2_filt_filt_position"
			UWORD
			F_0v097656_p0_5
			2
			2
			0
			6399.88596
			ECU_ADDRESS 0xFFFF7718
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_2_lh_measured_position
			"Tpac_2_lh_measured_position"
			UWORD
			F_0v09765625_p0_71
			2
			2
			0
			6399.902344
			ECU_ADDRESS 0xFFFF771A
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_2_max_measured_position_
			"Tpac_2_max_measured_position"
			UWORD
			F_0v097656_p0_5
			2
			2
			0
			6399.88596
			ECU_ADDRESS 0xFFFF771C
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_2_min_measured_position_
			"Tpac_2_min_measured_position"
			UWORD
			F_0v097656_p0_5
			2
			2
			0
			6399.88596
			ECU_ADDRESS 0xFFFF771E
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_abs_integral
			"Tpac_abs_integral"
			UWORD
			F_0v0003125_p0_307
			2
			2
			0
			20.4796875
			ECU_ADDRESS 0xFFFF7720
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_attenuation_gain_
			"Tpac_attenuation_gain"
			UBYTE
			F_0v00390625_p0_90
			2
			2
			0
			0.99609375
			ECU_ADDRESS 0xFFFF7693
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_battery_voltage_gain_
			"Tpac_battery_voltage_gain"
			UWORD
			F_0v000149_p0_309
			2
			2
			0
			9.764715
			ECU_ADDRESS 0xFFFF7722
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_check_limp_home_tempo
			"Tpac_check_limp_home_tempo"
			UBYTE
			F_32_p0_122
			2
			2
			0
			8160
			ECU_ADDRESS 0xFFFF7694
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_check_springs_state
			"Tpac_check_springs_state"
			UBYTE
			Tpac_check_springs_state_conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF7695
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_compute_ref_enab
			"Tpac_compute_ref_enab"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7654
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_derivative_gain_
			"Tpac_derivative_gain"
			UWORD
			F_0v61_p0_313
			2
			2
			0
			39976.35
			ECU_ADDRESS 0xFFFF7726
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_derivative_output
			"Tpac_derivative_output"
			SWORD
			F_0v625_p0_258
			2
			2
			-20480
			20479.375
			ECU_ADDRESS 0xFFFF76BE
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_distance_to_limp_home_
			"Tpac_distance_to_limp_home"
			UBYTE
			F_0v09765625_p0_71
			2
			2
			0
			24.90234375
			ECU_ADDRESS 0xFFFF7696
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_dyn_test_bed_abs_ref
			"Tpac_dyn_test_bed_abs_ref"
			UWORD
			F_0v09765625_p0_71
			2
			2
			0
			6399.902344
			ECU_ADDRESS 0xFFFF7728
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_dyn_test_bed_duration
			"Tpac_dyn_test_bed_duration"
			UBYTE
			F_0v128_p0_75
			2
			2
			0
			32.64
			ECU_ADDRESS 0xFFFF7697
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_dyn_test_bed_increment
			"Tpac_dyn_test_bed_increment"
			SLONG
			F_0v0000000466_p0_314
			2
			2
			-99.99998125
			99.9999812
			ECU_ADDRESS 0xFFFF779C
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_dyn_test_bed_next_abs_ref
			"Tpac_dyn_test_bed_next_abs_ref"
			UWORD
			F_0v09765625_p0_71
			2
			2
			0
			6399.902344
			ECU_ADDRESS 0xFFFF772A
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_dyn_test_bed_next_offset
			"Tpac_dyn_test_bed_next_offset"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7698
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_dyn_test_bed_next_rel_ref
			"Tpac_dyn_test_bed_next_rel_ref"
			SWORD
			F_0v09765625_p0_71
			2
			2
			-3200
			3199.902344
			ECU_ADDRESS 0xFFFF76C0
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_dyn_test_bed_offset
			"Tpac_dyn_test_bed_offset"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF7699
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_dyn_test_bed_ref_mem
			"Tpac_dyn_test_bed_ref_mem"
			ULONG
			F_0v0000000466_p0_314
			2
			2
			0
			199.9999625
			ECU_ADDRESS 0xFFFF7680
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_dyn_test_bed_rel_ref
			"Tpac_dyn_test_bed_rel_ref"
			SWORD
			F_0v09765625_p0_71
			2
			2
			-3200
			3199.902344
			ECU_ADDRESS 0xFFFF76C2
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_dyn_test_bed_tempo
			"Tpac_dyn_test_bed_tempo"
			UBYTE
			F_0v128_p0_75
			2
			2
			0
			32.64
			ECU_ADDRESS 0xFFFF769A
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_dyn_test_bed_type_ref
			"Tpac_dyn_test_bed_type_ref"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7655
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_estimated_velocity_
			"Tpac_estimated_velocity"
			SWORD
			F_0v0625_p0_316
			2
			2
			-2048
			2047.9375
			ECU_ADDRESS 0xFFFF76C4
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_estimated_velocity_1
			"Tpac_estimated_velocity_1"
			SWORD
			F_0v0625_p0_316
			2
			2
			-2048
			2047.9375
			ECU_ADDRESS 0xFFFF76C6
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_estimated_velocity_2
			"Tpac_estimated_velocity_2"
			SWORD
			F_0v0625_p0_316
			2
			2
			-2048
			2047.9375
			ECU_ADDRESS 0xFFFF76C8
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_exit_thrusts_tempo
			"Tpac_exit_thrusts_tempo"
			UBYTE
			F_32_p0_122
			2
			2
			0
			8160
			ECU_ADDRESS 0xFFFF769B
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_feed_forward_spring_comp_
			"Tpac_feed_forward_spring_comp"
			SWORD
			F_0v625_p0_258
			2
			2
			-20480
			20479.375
			ECU_ADDRESS 0xFFFF76CA
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_feed_forward_spring_old
			"Tpac_feed_forward_spring_old"
			SWORD
			F_0v625_p0_258
			2
			2
			-20480
			20479.375
			ECU_ADDRESS 0xFFFF76CC
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_high_thrust_detect_tempo
			"Tpac_high_thrust_detect_tempo"
			UBYTE
			F_8v192_p0_248
			2
			2
			0
			2088.96
			ECU_ADDRESS 0xFFFF769C
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_high_thrust_voltage
			"Tpac_high_thrust_voltage"
			SWORD
			F_0v625_p0_258
			2
			2
			-20480
			20479.375
			ECU_ADDRESS 0xFFFF76CE
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_inhibit_tempo
			"Tpac_inhibit_tempo"
			UBYTE
			F_32_p0_122
			2
			2
			0
			8160
			ECU_ADDRESS 0xFFFF769D
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_integral_controler_output_
			"Tpac_integral_controller_output"
			SLONG
			F_0v0095367_p0_320
			2
			2
			-20479907.31
			20479907.3
			ECU_ADDRESS 0xFFFF77A0
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_integral_controller_out_msb
			"Tpac_integral_controller_out_MSB"
			SWORD
			F_0v625_p0_258
			2
			2
			-20480
			20479.375
			ECU_ADDRESS 0xFFFF77A0
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_integral_failure_tempo_
			"Tpac_integral_failure_tempo"
			UBYTE
			F_2_p0_249
			2
			2
			0
			510
			ECU_ADDRESS 0xFFFF769E
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_integral_gain_
			"Tpac_integral_gain"
			UWORD
			F_0v15_p0_321
			2
			2
			0
			9830.25
			ECU_ADDRESS 0xFFFF772C
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_learn_limp_home_tempo
			"Tpac_learn_limp_home_tempo"
			UBYTE
			F_32_p0_122
			2
			2
			0
			8160
			ECU_ADDRESS 0xFFFF769F
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_low_thrust_detect_tempo
			"Tpac_low_thrust_detect_tempo"
			UBYTE
			F_8v192_p0_248
			2
			2
			0
			2088.96
			ECU_ADDRESS 0xFFFF76A0
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_low_thrust_voltage
			"Tpac_low_thrust_voltage"
			SWORD
			F_0v625_p0_258
			2
			2
			-20480
			20479.375
			ECU_ADDRESS 0xFFFF76D0
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_open_loop_control_
			"Tpac_open_loop_control"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7656
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_open_loop_control_exit
			"Tpac_open_loop_control_exit"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7657
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_open_loop_control_prec
			"Tpac_open_loop_control_prec"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7658
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_open_loop_control_voltage_
			"Tpac_open_loop_control_voltage"
			SWORD
			F_0v625_p0_258
			2
			2
			-20480
			20479.375
			ECU_ADDRESS 0xFFFF76D2
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_porteur
			"Tpac_porteur"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF864E
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_position_error
			"Tpac_position_error"
			SWORD
			F_0v097656_p0_5
			2
			2
			-3199.991808
			3199.894152
			ECU_ADDRESS 0xFFFF76D4
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_position_error_vdo
			"Tpac_position_error_vdo"
			SWORD
			F_0v0488281_p0_323
			2
			2
			-1599.999181
			1599.950353
			ECU_ADDRESS 0xFFFF76D6
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_previous_estimated_vel_1
			"Tpac_previous_estimated_vel_1"
			SWORD
			F_0v0625_p0_316
			2
			2
			-2048
			2047.9375
			ECU_ADDRESS 0xFFFF76DA
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_previous_estimated_vel_2
			"Tpac_previous_estimated_vel_2"
			SWORD
			F_0v0625_p0_316
			2
			2
			-2048
			2047.9375
			ECU_ADDRESS 0xFFFF76DC
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_previous_throttle_pos_1_
			"Tpac_previous_throttle_pos_1"
			UWORD
			F_0v048828125_p0_199
			2
			2
			0
			3199.951172
			ECU_ADDRESS 0xFFFF772E
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_previous_throttle_pos_2_
			"Tpac_previous_throttle_pos_2"
			UWORD
			F_0v048828125_p0_199
			2
			2
			0
			3199.951172
			ECU_ADDRESS 0xFFFF7730
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_previous_throttle_pos_3_
			"Tpac_previous_throttle_pos_3"
			UWORD
			F_0v048828125_p0_199
			2
			2
			0
			3199.951172
			ECU_ADDRESS 0xFFFF7732
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_previous_velocity_error
			"Tpac_previous_velocity_error"
			SWORD
			F_0v0625_p0_316
			2
			2
			-2048
			2047.9375
			ECU_ADDRESS 0xFFFF76DE
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_proportional_output
			"Tpac_proportional_output"
			SWORD
			F_0v625_p0_258
			2
			2
			-20480
			20479.375
			ECU_ADDRESS 0xFFFF76E0
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_proportionnal_gain_
			"Tpac_proportionnal_gain"
			UWORD
			F_0v15_p0_324
			2
			2
			0
			9830.25
			ECU_ADDRESS 0xFFFF7734
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_relative_lh_throttle_pos
			"Tpac_relative_lh_throttle_pos"
			UWORD
			F_0v097656_m100_77
			2
			2
			-100
			6299.88596
			ECU_ADDRESS 0xFFFF7736
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_request_thr_vdo_duty_cycle
			"Tpac_request_thr_vdo_duty_cycle"
			SWORD
			F_0v0061035156_p0_23
			2
			2
			-200
			199.9938965
			ECU_ADDRESS 0xFFFF76E2
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_request_throttle_duty_cycle
			"Tpac_request_throttle_duty_cycle"
			UWORD
			F_0v0061035156_p0_23
			2
			2
			0
			399.9938965
			ECU_ADDRESS 0xFFFF7738
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_servo_failure_detect_tempo_
			"Tpac_servo_failure_detect_tempo"
			UBYTE
			F_2_p0_249
			2
			2
			0
			510
			ECU_ADDRESS 0xFFFF76A1
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_servo_failure_diag_tempo
			"Tpac_servo_failure_diag_tempo"
			UBYTE
			F_2_p0_249
			2
			2
			0
			510
			ECU_ADDRESS 0xFFFF76A2
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_smoothing_ratio
			"Tpac_smoothing_ratio"
			UWORD
			F_0v00097656_p0_325
			2
			2
			0
			63.9988596
			ECU_ADDRESS 0xFFFF773A
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_somme_positions_1
			"Tpac_somme_positions_1"
			UWORD
			F_0v09765625_p0_71
			2
			2
			0
			6399.902344
			ECU_ADDRESS 0xFFFF773C
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_somme_positions_2
			"Tpac_somme_positions_2"
			UWORD
			F_0v09765625_p0_71
			2
			2
			0
			6399.902344
			ECU_ADDRESS 0xFFFF773E
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_test_bed_table_counter
			"Tpac_test_bed_table_counter"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF76A3
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_throttle_control_state
			"Tpac_throttle_control_state"
			UBYTE
			Tpac_throttle_control_state_conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF76A4
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_throttle_control_voltage
			"Tpac_throttle_control_voltage"
			SWORD
			F_0v625_p0_258
			2
			2
			-20480
			20479.375
			ECU_ADDRESS 0xFFFF76E4
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_throttle_ctrl_voltage_deci
			"Tpac_throttle_ctrl_voltage_deci"
			SWORD
			Id_0x00
			2
			2
			-32768
			32767
			ECU_ADDRESS 0xFFFF76E6
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_throttle_position_reference
			"Tpac_throttle_position_reference"
			UWORD
			F_0v097656_p0_5
			2
			2
			0
			6399.88596
			ECU_ADDRESS 0xFFFF7740
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_throttle_stab_tempo
			"Tpac_throttle_stab_tempo"
			UBYTE
			F_8_p0_56
			2
			2
			0
			2040
			ECU_ADDRESS 0xFFFF76A5
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_thrust_search_cleoff_tempo
			"Tpac_thrust_search_cleoff_tempo"
			UBYTE
			F_32_p0_122
			2
			2
			0
			8160
			ECU_ADDRESS 0xFFFF76A6
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_thrust_search_test_bed_mode
			"Tpac_thrust_search_test_bed_mode"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7659
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_thrusts_search_diag_inh_
			"Tpac_thrusts_search_diag_inh"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7BD0
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_thrusts_search_tempo
			"Tpac_thrusts_search_tempo"
			UBYTE
			F_32_p0_122
			2
			2
			0
			8160
			ECU_ADDRESS 0xFFFF76A7
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_trt_accost_ctr
			"Tpac_trt_accost_ctr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF76A8
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_trt_mesures_ctr
			"Tpac_trt_mesures_ctr"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF76A9
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_trt_mesures_ctr_prec
			"Tpac_trt_mesures_ctr_prec"
			UBYTE
			F_1_p0_9
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF76AA
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_velocity_error
			"Tpac_velocity_error"
			SWORD
			F_0v0625_p0_316
			2
			2
			-2048
			2047.9375
			ECU_ADDRESS 0xFFFF76E8
		/end MEASUREMENT
		/begin MEASUREMENT Tpac_velocity_limit_bound
			"Tpac_velocity_limit_bound"
			UWORD
			F_0v0625_p0_316
			2
			2
			0
			4095.9375
			ECU_ADDRESS 0xFFFF7742
		/end MEASUREMENT
		/begin MEASUREMENT Tpc_comp_diag_inh_tempo_
			"Tpc_comp_diag_inh_tempo"
			UBYTE
			F_32_p0_122
			2
			2
			0
			8160
			ECU_ADDRESS 0xFFFF76AB
		/end MEASUREMENT
		/begin MEASUREMENT Tpc_compteur_pwm_
			"Tpc_compteur_pwm"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF76AC
		/end MEASUREMENT
		/begin MEASUREMENT Tpc_etu_diagnostic_filt_input_
			"Tpc_etu_diagnostic_filt_input"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF765A
		/end MEASUREMENT
		/begin MEASUREMENT Tpc_free_wheeling_
			"TPC_FREE_WHEELING"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x4
			ECU_ADDRESS 0xFFFF76AE
		/end MEASUREMENT
		/begin MEASUREMENT Tpc_free_wheeling_tempo_
			"Tpc_free_wheeling_tempo"
			UBYTE
			F_32_p0_122
			2
			2
			0
			8160
			ECU_ADDRESS 0xFFFF76AD
		/end MEASUREMENT
		/begin MEASUREMENT Tpc_no_throt
			"TPC_NO_THROT"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x2
			ECU_ADDRESS 0xFFFF76AE
		/end MEASUREMENT
		/begin MEASUREMENT Tpc_normal_throt_
			"TPC_NORMAL_THROT"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF76AE
		/end MEASUREMENT
		/begin MEASUREMENT Tpc_throt_applicated_rco_1_
			"Tpc_throt_applicated_rco_1"
			UWORD
			F_0v0061035156_p0_23
			2
			2
			0
			399.9938965
			ECU_ADDRESS 0xFFFF7744
		/end MEASUREMENT
		/begin MEASUREMENT Tpc_throt_applicated_rco_2_
			"Tpc_throt_applicated_rco_2"
			UWORD
			F_0v0061035156_p0_23
			2
			2
			0
			399.9938965
			ECU_ADDRESS 0xFFFF7746
		/end MEASUREMENT
		/begin MEASUREMENT Tpc_throt_on_off_request_
			"Tpc_throt_on_off_request"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF765B
		/end MEASUREMENT
		/begin MEASUREMENT Tpc_throttle_status_
			"Tpc_throttle_status"
			UBYTE
			Tpc_throttle_status__conv
			2
			2
			0
			0
			ECU_ADDRESS 0xFFFF76AE
		/end MEASUREMENT
		/begin MEASUREMENT Tpim_filtered_inhibit_input_
			"Tpim_filtered_inhibit_input"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF765C
		/end MEASUREMENT
		/begin MEASUREMENT Tpim_filtered_inhibit_output
			"Tpim_filtered_inhibit_output"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF765D
		/end MEASUREMENT
		/begin MEASUREMENT Tps_1_raw_memo1_
			"Tps_1_raw_memo1"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7748
		/end MEASUREMENT
		/begin MEASUREMENT Tps_1_raw_memo2_
			"Tps_1_raw_memo2"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF774A
		/end MEASUREMENT
		/begin MEASUREMENT Tps_2_raw_memo1_
			"Tps_2_raw_memo1"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF774C
		/end MEASUREMENT
		/begin MEASUREMENT Tps_2_raw_memo2_
			"Tps_2_raw_memo2"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF774E
		/end MEASUREMENT
		/begin MEASUREMENT Tps_2_raw_position_mcp_mcp_
			"Tps_2_raw_position_mcp_mcp"
			UBYTE
			F_0v390625_p0_4
			2
			2
			0
			99.609375
			ECU_ADDRESS 0xFFFF76AF
		/end MEASUREMENT
		/begin MEASUREMENT Tps_2_raw_position_mcw_mcp_
			"Tps_2_raw_position_mcw_mcp"
			UBYTE
			F_0v390625_p0_4
			2
			2
			0
			99.609375
			ECU_ADDRESS 0xFFFF8274
		/end MEASUREMENT
		/begin MEASUREMENT Tps_coh_filt_abs_error_
			"Tps_coh_filt_abs_error"
			UWORD
			F_0v097656_p0_5
			2
			2
			0
			6399.88596
			ECU_ADDRESS 0xFFFF7750
		/end MEASUREMENT
		/begin MEASUREMENT Tps_sensing_coh_diag_inh_
			"Tps_sensing_coh_diag_inh"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7BD1
		/end MEASUREMENT
		/begin MEASUREMENT Tps_sensing_default_diag_inh_
			"Tps_sensing_default_diag_inh"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7BD2
		/end MEASUREMENT
		/begin MEASUREMENT Tps_throttle_position_memory_
			"Tps_throttle_position_memory"
			UWORD
			F_0v048828125_p0_199
			2
			2
			0
			3199.951172
			ECU_ADDRESS 0xFFFF7752
		/end MEASUREMENT
		/begin MEASUREMENT Trait_pmh_avance_glisse
			"Trait_pmh_avance_glisse"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E03
		/end MEASUREMENT
		/begin MEASUREMENT Trait_pompe_air_fin
			"TRAIT_POMPE_AIR_FIN"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x20
			ECU_ADDRESS 0xFFFF84B6
		/end MEASUREMENT
		/begin MEASUREMENT Traitement_dent_longue_
			"Traitement_dent_longue"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7F21
		/end MEASUREMENT
		/begin MEASUREMENT Traitement_pmh_
			"Traitement_pmh"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7F22
		/end MEASUREMENT
		/begin MEASUREMENT Trame_obd_can_en_attente
			"Trame_obd_can_en_attente"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7400
		/end MEASUREMENT
		/begin MEASUREMENT Transition_inj_a_
			"TRANSITION_INJ_A"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7AA5
		/end MEASUREMENT
		/begin MEASUREMENT Transition_inj_b_
			"TRANSITION_INJ_B"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x4
			ECU_ADDRESS 0xFFFF7AA5
		/end MEASUREMENT
		/begin MEASUREMENT Transition_inj_c_
			"TRANSITION_INJ_C"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x10
			ECU_ADDRESS 0xFFFF7AA5
		/end MEASUREMENT
		/begin MEASUREMENT Transition_inj_d_
			"TRANSITION_INJ_D"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x40
			ECU_ADDRESS 0xFFFF7AA5
		/end MEASUREMENT
		/begin MEASUREMENT Transmission_can_complete_
			"Transmission_can_complete"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E75
		/end MEASUREMENT
		/begin MEASUREMENT Transmission_can_status_
			"Transmission_can_status"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E76
		/end MEASUREMENT
		/begin MEASUREMENT Trois_cyl_actifs
			"TROIS_CYL_ACTIFS"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x4
			ECU_ADDRESS 0xFFFF8329
		/end MEASUREMENT
		/begin MEASUREMENT Type_de_defaut_
			"Type_de_defaut"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF6554
		/end MEASUREMENT
		/begin MEASUREMENT Type_de_defaut_eep
			"Type_de_defaut_eep"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF8938
		/end MEASUREMENT
		/begin MEASUREMENT Type_emission_obd
			"Type_emission_obd"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF731D
		/end MEASUREMENT
		/begin MEASUREMENT Type_gpl_para
			"Type_gpl_para"
			UWORD
			Id_0x00
			2
			2
			0
			65535
			ECU_ADDRESS 0xFFFF7990
		/end MEASUREMENT
		/begin MEASUREMENT Uchvlabs
			"Uch_verlog_frame_absent"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6BEC
		/end MEASUREMENT
		/begin MEASUREMENT Unusual_eng_stop_vl
			"Unusual_eng_stop_vl"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6BED
		/end MEASUREMENT
		/begin MEASUREMENT Unusual_eng_stop_vl_old
			"Unusual_eng_stop_vl_old"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E77
		/end MEASUREMENT
		/begin MEASUREMENT Valeur_pour_test_calcul_mcp
			"Valeur_pour_test_calcul_mcp"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8275
		/end MEASUREMENT
		/begin MEASUREMENT Valeur_pour_test_calcul_mcw
			"Valeur_pour_test_calcul_mcw"
			UBYTE
			Id_0x00
			2
			2
			0
			255
			ECU_ADDRESS 0xFFFF8276
		/end MEASUREMENT
		/begin MEASUREMENT Valid_panne_rebond
			"Valid_panne_rebond"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF765E
		/end MEASUREMENT
		/begin MEASUREMENT Valid_panne_rebond_prec
			"Valid_panne_rebond_prec"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF765F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_ac_acel_is_req
			"Vbx_ac_acel_is_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF743C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_ac_acel_is_req_prev
			"Vbx_ac_acel_is_req_prev"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF743D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_ac_dsb
			"Vbx_ac_dsb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF743E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_ac_eng_dsb
			"Vbx_ac_eng_dsb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF743F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_ac_in_mem
			"Vbx_ac_in_mem"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6BB4
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_ac_lk_stt
			"Vbx_ac_lk_stt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E78
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_ac_mdf1_req
			"Vbx_ac_mdf1_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7440
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_ac_mdf2_req
			"Vbx_ac_mdf2_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7441
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_ac_mvac_dsb
			"Vbx_ac_mvac_dsb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7442
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_ac_out_mem
			"Vbx_ac_out_mem"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6BB5
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_ac_req
			"Vbx_ac_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7443
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_acc_clu_dyn_iga_req
			"Vbx_acc_clu_dyn_iga_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7444
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_acc_clu_ena
			"Vbx_acc_clu_ena"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7445
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_acc_ctr
			"Vbx_acc_ctr"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8174
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_acc_lk_stt
			"Vbx_acc_lk_stt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8175
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_acc_tq_ack
			"Vbx_acc_tq_ack"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8176
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_acc_tq_ctl_dsb
			"Vbx_acc_tq_ctl_dsb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8177
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_acc_tq_ena
			"Vbx_acc_tq_ena"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8178
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_acc_typ
			"Vbx_acc_typ"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8179
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_acel_aj_fil
			"Vbx_acel_aj_fil"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF82F5
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_acel_is_ac_dsb
			"Vbx_acel_is_ac_dsb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7446
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_acel_pdl_fail_cru_dsb
			"Vbx_acel_pdl_fail_cru_dsb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF817A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_acel_pdl_kd
			"Vbx_acel_pdl_kd"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF817B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_acel_pdl_up
			"Vbx_acel_pdl_up"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF817C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_act1_cor_thr_adj
			"Vbx_act1_cor_thr_adj"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6C11
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_act2_cor_thr_adj
			"Vbx_act2_cor_thr_adj"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6C12
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_act_cor_thr_adj
			"Vbx_act_cor_thr_adj"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6C10
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_act_is
			"Vbx_act_is"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF79B5
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_act_test_asd_cata
			"Vbx_act_test_asd_cata"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7CFB
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_act_test_asd_lbup
			"Vbx_act_test_asd_lbup"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7CFC
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_act_test_asd_sa
			"Vbx_act_test_asd_sa"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7CFD
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_act_test_eol
			"Vbx_act_test_eol"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7CFE
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_act_vvt
			"Vbx_act_vvt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6D7D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_act_vvt_req
			"Vbx_act_vvt_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6D7E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_actr_rly_cmd
			"Vbx_actr_rly_cmd"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8146
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_actr_spg_dsb
			"Vbx_actr_spg_dsb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7BD3
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_ad_dft_in_req
			"Vbx_ad_dft_in_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF75C0
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_ad_lsm_ena
			"Vbx_ad_lsm_ena"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A5A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_ad_lsm_req
			"Vbx_ad_lsm_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A5B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_agb_ac_dsb
			"Vbx_agb_ac_dsb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E79
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_agb_acel_is_req
			"Vbx_agb_acel_is_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E7A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_agb_ack
			"Vbx_agb_ack"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E7B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_agb_clck_ok
			"Vbx_agb_clck_ok"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E7C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_agb_conv_trs
			"Vbx_agb_conv_trs"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E7D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_agb_dft
			"Vbx_agb_dft"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF73CA
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_agb_diag_ini
			"Vbx_agb_diag_ini"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E7E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_agb_gear_mod_ok
			"Vbx_agb_gear_mod_ok"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E7F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_agb_mdf_req
			"Vbx_agb_mdf_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E80
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_agb_tq_max_lim
			"Vbx_agb_tq_max_lim"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E81
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_agb_tq_sp_ovs_lim
			"Vbx_agb_tq_sp_ovs_lim"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E82
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_agb_tq_sp_req
			"Vbx_agb_tq_sp_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E83
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_air_pump_cmd
			"Vbx_air_pump_cmd"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8492
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_air_pump_is_cor1
			"Vbx_air_pump_is_cor1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8493
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_air_pump_is_cor2
			"Vbx_air_pump_is_cor2"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8494
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_alt_crt_bool
			"Vbx_alt_crt_bool"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF731E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_alt_crt_clc_ena
			"Vbx_alt_crt_clc_ena"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6D24
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_alt_crt_ecu_bool
			"Vbx_alt_crt_ecu_bool"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x2
			ECU_ADDRESS 0xFFFF6D38
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_alt_ecu_ok
			"Vbx_alt_ecu_ok"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6D25
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_alt_lk_stt
			"Vbx_alt_lk_stt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E84
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_alt_load_input_lvl
			"Vbx_alt_load_input_lvl"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6D26
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_alt_mux_lk_stt
			"Vbx_alt_mux_lk_stt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E85
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_alt_pwm_acq_per
			"Vbx_alt_pwm_acq_per"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6D27
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_alt_pwm_frst_per
			"Vbx_alt_pwm_frst_per"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6D28
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_alt_pwm_sig_avl
			"Vbx_alt_pwm_sig_avl"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6D29
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_alt_rat_fail_dly_ini
			"Vbx_alt_rat_fail_dly_ini"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6D2A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_alti_upd
			"Vbx_alti_upd"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7EF5
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_alti_upd_prec
			"Vbx_alti_upd_prec"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6C13
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_amp_ad_kd_thr
			"Vbx_amp_ad_kd_thr"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7FB4
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_asr_cnd
			"Vbx_asr_cnd"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E86
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_asr_ctr_dft
			"Vbx_asr_ctr_dft"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E87
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_asr_in_reg
			"Vbx_asr_in_reg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF73AD
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_asr_msr_cnd
			"Vbx_asr_msr_cnd"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E88
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_asr_sp_vld
			"Vbx_asr_sp_vld"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E89
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_aut_eng
			"Vbx_aut_eng"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF78D8
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_automate_aac_transition
			"Vbx_automate_aac_transition"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF82F6
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_avl_lbup
			"Vbx_avl_lbup"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A5C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_ayc_in_reg
			"Vbx_ayc_in_reg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF73AE
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_blk_n
			"Vbx_blk_n"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF79B6
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_brk_abst
			"Vbx_brk_abst"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF817D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_brk_ct_pdl
			"Vbx_brk_ct_pdl"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7FB5
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_brk_det
			"Vbx_brk_det"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF817E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_brk_in
			"Vbx_brk_in"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF78EC
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_brk_pdl
			"Vbx_brk_pdl"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF78ED
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_brk_pdl_prec
			"Vbx_brk_pdl_prec"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF78EE
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_can_diag
			"Vbx_can_diag"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E8A
		/end MEASUREMENT
		/begin MEASUREMENT VBX_CART_DYN_IGA
			"VBX_CART_DYN_IGA"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x2
			ECU_ADDRESS 0xFFFF6D9B
		/end MEASUREMENT
		/begin MEASUREMENT VBX_CART_IGA_STT
			"VBX_CART_IGA_STT"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x4
			ECU_ADDRESS 0xFFFF6DA4
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cata_diag_ok
			"Vbx_cata_diag_ok"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7CFF
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cata_diag_stop
			"Vbx_cata_diag_stop"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D00
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cata_lbdw_stt_1
			"Vbx_cata_lbdw_stt_1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D01
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cata_lbdw_stt_2
			"Vbx_cata_lbdw_stt_2"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D02
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cata_lbup_trs_det
			"Vbx_cata_lbup_trs_det"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D03
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cata_mes
			"Vbx_cata_mes"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D04
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cata_ol_cl_ti_fac
			"Vbx_cata_ol_cl_ti_fac"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D05
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cata_ol_stop
			"Vbx_cata_ol_stop"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D06
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cata_req
			"Vbx_cata_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D07
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cata_rich_dstb_efv
			"Vbx_cata_rich_dstb_efv"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6D58
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cata_stab_rich
			"Vbx_cata_stab_rich"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D08
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cata_stab_rich_dsb
			"Vbx_cata_stab_rich_dsb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D09
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cata_wup_cold
			"Vbx_cata_wup_cold"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6D59
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cata_wup_eai
			"Vbx_cata_wup_eai"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6D5A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cata_wup_eng
			"Vbx_cata_wup_eng"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6D5B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cata_wup_lean
			"Vbx_cata_wup_lean"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6D5C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cata_wup_rich_dstb
			"Vbx_cata_wup_rich_dstb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6D5D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cdn_ok_diag_sa
			"Vbx_cdn_ok_diag_sa"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D0A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cl_cdn
			"Vbx_cl_cdn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A5D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cl_lean_cdn
			"Vbx_cl_lean_cdn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A5E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cl_phs
			"Vbx_cl_phs"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A5F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cl_ti_fac_diag_ini
			"Vbx_cl_ti_fac_diag_ini"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A60
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_clc_ct_pdl
			"Vbx_clc_ct_pdl"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E8B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_clc_kd_pdl
			"Vbx_clc_kd_pdl"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF817F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_clc_pwst_prs
			"Vbx_clc_pwst_prs"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF77B4
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_clos_agb_conv
			"Vbx_clos_agb_conv"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E8C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_clos_brk
			"Vbx_clos_brk"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8180
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_clos_brk_nok
			"Vbx_clos_brk_nok"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8181
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_clos_thr_dly_stop
			"Vbx_clos_thr_dly_stop"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF82F7
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_clos_thr_stop
			"Vbx_clos_thr_stop"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF82F8
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_clu_lk_stt
			"Vbx_clu_lk_stt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8182
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_clu_stal
			"Vbx_clu_stal"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF78D9
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_clu_stal_ctr
			"Vbx_clu_stal_ctr"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6BB6
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_clu_swi
			"Vbx_clu_swi"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF78B4
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_clu_swi_prec
			"Vbx_clu_swi_prec"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF78B5
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_clu_swi_prev
			"Vbx_clu_swi_prev"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF78B6
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_comp_hot
			"Vbx_comp_hot"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6D5E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cor_map_thr_adj
			"Vbx_cor_map_thr_adj"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6C30
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cor_n_thr_adj
			"Vbx_cor_n_thr_adj"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6C31
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cp_ad
			"Vbx_cp_ad"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8099
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cp_ad_ena
			"Vbx_cp_ad_ena"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A61
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cp_cmd_frq
			"Vbx_cp_cmd_frq"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF809A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cp_ena
			"Vbx_cp_ena"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A62
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cp_eng_cdn_cl_ena
			"Vbx_cp_eng_cdn_cl_ena"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF809B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cp_eng_cdn_is_ena
			"Vbx_cp_eng_cdn_is_ena"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF809C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cp_eng_cdn_ol_ena
			"Vbx_cp_eng_cdn_ol_ena"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF809D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cp_eng_cdn_sp_ena
			"Vbx_cp_eng_cdn_sp_ena"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF809E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cp_fct
			"Vbx_cp_fct"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF809F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cp_fct_ad
			"Vbx_cp_fct_ad"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF80A0
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cp_load_ad
			"Vbx_cp_load_ad"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF80A1
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cp_lsm_ad_ena
			"Vbx_cp_lsm_ad_ena"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A63
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cp_req
			"Vbx_cp_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF80A2
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cp_req_ad
			"Vbx_cp_req_ad"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF80A3
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cp_rich_cge
			"Vbx_cp_rich_cge"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A64
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cp_stop_ad
			"Vbx_cp_stop_ad"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF80A4
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cp_stt
			"Vbx_cp_stt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF80A5
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cpl_sta_gas_pump
			"Vbx_cpl_sta_gas_pump"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8147
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_crk
			"Vbx_crk"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7F23
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cru_asr_ayc_dacn
			"Vbx_cru_asr_ayc_dacn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8183
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cru_brk
			"Vbx_cru_brk"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8184
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cru_brk_dacn
			"Vbx_cru_brk_dacn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8185
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cru_cmf_cut
			"Vbx_cru_cmf_cut"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8186
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cru_gear_dacn
			"Vbx_cru_gear_dacn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8187
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cru_lk_stt
			"Vbx_cru_lk_stt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8188
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cru_mf_det
			"Vbx_cru_mf_det"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8189
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cru_mstr
			"Vbx_cru_mstr"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF818A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cru_on_off_in
			"Vbx_cru_on_off_in"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF818B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cru_oor_vs
			"Vbx_cru_oor_vs"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF818C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cru_pf_det
			"Vbx_cru_pf_det"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF818D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cru_rat_dacn
			"Vbx_cru_rat_dacn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF818E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cru_sl_acel_swi
			"Vbx_cru_sl_acel_swi"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF818F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cru_sl_decl_swi
			"Vbx_cru_sl_decl_swi"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8190
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cru_sl_dft_daca
			"Vbx_cru_sl_dft_daca"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8191
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cru_sl_ecm_daca
			"Vbx_cru_sl_ecm_daca"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8192
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cru_sl_eng_dsb
			"Vbx_cru_sl_eng_dsb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8193
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cru_sl_lih_daca
			"Vbx_cru_sl_lih_daca"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8194
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cru_sl_lk_ena
			"Vbx_cru_sl_lk_ena"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8195
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cru_sl_neut_rvr_dacn
			"Vbx_cru_sl_neut_rvr_dacn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8196
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cru_sl_resu_swi
			"Vbx_cru_sl_resu_swi"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8197
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cru_sl_susp_dacn
			"Vbx_cru_sl_susp_dacn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8198
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cru_sl_susp_swi
			"Vbx_cru_sl_susp_swi"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8199
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cru_sl_svkl_act
			"Vbx_cru_sl_svkl_act"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF819A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cru_sl_vs_daca
			"Vbx_cru_sl_vs_daca"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF819B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cru_sl_warn
			"Vbx_cru_sl_warn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF819C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cru_smal_vs_sp_rat
			"Vbx_cru_smal_vs_sp_rat"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF819D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_csm_fuel
			"Vbx_csm_fuel"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E8D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_ct1
			"Vbx_ct1"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A65
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_ct_pdl
			"Vbx_ct_pdl"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7FB6
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_ct_pdl_0
			"Vbx_ct_pdl_0"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7FB7
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_ct_pdl_thr
			"Vbx_ct_pdl_thr"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7FB8
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cut_act
			"Vbx_cut_act"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A66
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cut_cdn
			"Vbx_cut_cdn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A67
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cylr_diag_req
			"Vbx_cylr_diag_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF75C1
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cylr_is_run_ctl_ini
			"Vbx_cylr_is_run_ctl_ini"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6BB7
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cylr_is_run_mes
			"Vbx_cylr_is_run_mes"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6BB8
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cylr_is_run_req
			"Vbx_cylr_is_run_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6BB9
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cylr_is_run_stab_cdn
			"Vbx_cylr_is_run_stab_cdn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6BBA
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cylr_is_run_stop
			"Vbx_cylr_is_run_stop"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6BBB
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cylr_run_loop_stop
			"Vbx_cylr_run_loop_stop"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6BBC
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cylr_run_stab_cdn
			"Vbx_cylr_run_stab_cdn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6BBD
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cylr_stab_cdn
			"Vbx_cylr_stab_cdn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6BBE
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cylr_stab_cdn_rtn
			"Vbx_cylr_stab_cdn_rtn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6BBF
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cylr_stop
			"Vbx_cylr_stop"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6BC0
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_cylr_tot_stab_cdn
			"Vbx_cylr_tot_stab_cdn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6BC1
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_dec_out_ovt
			"Vbx_dec_out_ovt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF82F9
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_decl_inj1_cut_req
			"Vbx_decl_inj1_cut_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A69
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_decl_inj2_cut_req
			"Vbx_decl_inj2_cut_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A6A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_decl_inj3_cut_req
			"Vbx_decl_inj3_cut_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A6B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_decl_inj4_cut_req
			"Vbx_decl_inj4_cut_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A6C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_decl_inj_cut
			"Vbx_decl_inj_cut"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A68
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_decl_prs_lean_ena
			"Vbx_decl_prs_lean_ena"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8024
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_dft_ini_req
			"Vbx_dft_ini_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF75C2
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_dft_inj1_cut
			"Vbx_dft_inj1_cut"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A6D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_dft_inj2_cut
			"Vbx_dft_inj2_cut"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A6E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_dft_inj3_cut
			"Vbx_dft_inj3_cut"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A6F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_dft_inj4_cut
			"Vbx_dft_inj4_cut"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A70
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_dft_lght_wal_2
			"Vbx_dft_lght_wal_2"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E8E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_diag_lbup_down_stt
			"Vbx_diag_lbup_down_stt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7E99
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_diag_lbup_up_stt
			"Vbx_diag_lbup_up_stt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7E9A
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_diag_obd_ena
			"Vbx_diag_obd_ena"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF786E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_diag_obd_ena_gas
			"Vbx_diag_obd_ena_gas"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF786F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_diag_obd_ena_lpg
			"Vbx_diag_obd_ena_lpg"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7870
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_diag_pws_rtn
			"Vbx_diag_pws_rtn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8148
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_diag_stop_pwl_cmd
			"Vbx_diag_stop_pwl_cmd"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF75C3
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_diag_stop_pwl_dsb
			"Vbx_diag_stop_pwl_dsb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8149
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_dly_ac_dsb
			"Vbx_dly_ac_dsb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7447
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_dly_ocl_cdn
			"Vbx_dly_ocl_cdn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A71
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_down_prmt_hot_cmd
			"Vbx_down_prmt_hot_cmd"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7E9B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_down_tq_req
			"Vbx_down_tq_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF82FA
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_drag_red_agb
			"Vbx_drag_red_agb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E8F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_dri_neut_trs_agb
			"Vbx_dri_neut_trs_agb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E90
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_driv_acel_req
			"Vbx_driv_acel_req"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF82FB
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_driv_tq_req_dsb
			"Vbx_driv_tq_req_dsb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7BD4
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_dsb_asd
			"Vbx_dsb_asd"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D0B
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_dsb_diag_cata
			"Vbx_dsb_diag_cata"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D0C
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_dsb_diag_fsys
			"Vbx_dsb_diag_fsys"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D0D
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_dsb_diag_lamb
			"Vbx_dsb_diag_lamb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D0E
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_dsb_diag_mis
			"Vbx_dsb_diag_mis"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D0F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_dsb_diag_polu_mis
			"Vbx_dsb_diag_polu_mis"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D10
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_dsb_diag_sa
			"Vbx_dsb_diag_sa"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D11
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_dsb_schd_mis
			"Vbx_dsb_schd_mis"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7D12
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_dyn_iga_efy_cdn
			"Vbx_dyn_iga_efy_cdn"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7A18
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_dyn_iga_fil_ok
			"Vbx_dyn_iga_fil_ok"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6D7F
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_dyn_iga_fil_ok_prev
			"Vbx_dyn_iga_fil_ok_prev"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6D80
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_dyn_iga_sta_ini
			"Vbx_dyn_iga_sta_ini"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6D81
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_dz_iga_efv_ena
			"Vbx_dz_iga_efv_ena"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF82FC
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_eai_dsb
			"Vbx_eai_dsb"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF8495
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_eep_abs
			"Vbx_eep_abs"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6BEE
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_eep_virgin
			"Vbx_eep_virgin"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6BEF
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_el_bk_wind
			"Vbx_el_bk_wind"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF6E91
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_el_bk_wind_is_cor
			"Vbx_el_bk_wind_is_cor"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF79B7
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_el_wind
			"Vbx_el_wind"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7448
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_el_wind_is_cor
			"Vbx_el_wind_is_cor"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF79B8
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_el_wind_lk_stt
			"Vbx_el_wind_lk_stt"
			UBYTE
			Bool_ON_OFF
			2
			2
			0
			1
			BIT_MASK 0x1
			ECU_ADDRESS 0xFFFF7449
		/end MEASUREMENT
		/begin MEASUREMENT Vbx_ena_inj1
			"Vbx_ena_inj1"
			UBYTE
			Bool_ON_OFF
			2
