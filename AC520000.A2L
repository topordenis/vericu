"/* Genebase version 1.8.0.1 */
ASAP2_VERSION 1 3
/begin PROJECT AC "S3000AC"
	/begin HEADER "Projet AC"
		VERSION "AC52.00#00"
		PROJECT_NO 75
	/end HEADER
	/begin MODULE AC "JCAE Pontoise"
		/begin A2ML
			taggedunion if_data {
				/include "ccp.aml"
			}
		/end A2ML
		/begin MOD_PAR "CCP"
			USER "AC"
			ECU "AC"
			/begin MEMORY_SEGMENT
				DATA1 "Page de reference"
				DATA
				FLASH
				EXTERN
				0x70000 0xFF80
				-1 -1 -1 -1 -1
				/begin IF_DATA ASAP1B_CCP
					ADDRESS_MAPPING 0x70000 0x70000 0xFF80
				/end IF_DATA
				/begin IF_DATA ASAP1B_KWP2000
					ADDRESS_MAPPING 0x70000 0x70000 0xFF80
				/end IF_DATA
			/end MEMORY_SEGMENT
			/begin MEMORY_SEGMENT
				CODESEG1 "Program-Part1"
				CODE
				FLASH
				INTERN
				0x8000 0x67FF0
				-1 -1 -1 -1 -1
			/end MEMORY_SEGMENT
		/end MOD_PAR
		/begin MOD_COMMON ""
			DEPOSIT ABSOLUTE
			ALIGNMENT_FLOAT32_IEEE 4
			BYTE_ORDER MSB_FIRST
		/end MOD_COMMON
		/begin IF_DATA ASAP1B_CCP
			/begin SOURCE
				"4 ms"
				2
				1
				/begin QP_BLOB
					30
					LENGTH 7
					CAN_ID_FIXED 0x102
					RASTER 2
				/end QP_BLOB
			/end SOURCE
			/begin SOURCE
				"256 ms"
				3
				1
				/begin QP_BLOB
					31
					LENGTH 7
					CAN_ID_FIXED 0x104
					RASTER 3
				/end QP_BLOB
			/end SOURCE
			/begin SOURCE
				"Synchro PMH"
				1
				1
				/begin QP_BLOB
					1
					LENGTH 7
					CAN_ID_FIXED 0x103
					RASTER 1
				/end QP_BLOB
			/end SOURCE
			/begin RASTER
				"Timer 4 ms"
				"4 ms"
				2
				3
				4
			/end RASTER
			/begin RASTER
				"Timer 256 ms"
				"256 ms"
				3
				3
				256
			/end RASTER
			/begin RASTER
				"Synchro PMH"
				"PMH"
				1
				103
				1
			/end RASTER
			/begin TP_BLOB
				0x0201
				0x0202
				0x100
				0x101
				57
				1
				STORE_SUPPORTED
				/begin CAN_PARAM
					0x03E8
					0x40
					0x16
				/end CAN_PARAM
				/begin CHECKSUM_PARAM
					0x8001
					0x200
					CHECKSUM_CALCULATION ACTIVE_PAGE
				/end CHECKSUM_PARAM
				/begin DEFINED_PAGES
					2
					"Page de travail"
					0x0000
					0x70000
					0x7FFF
					RAM
					FLASH_BACK
					RAM_INIT_BY_ECU
				/end DEFINED_PAGES
				OPTIONAL_CMD 0x0C
				OPTIONAL_CMD 0x23
				OPTIONAL_CMD 0x0D
				OPTIONAL_CMD 0x0E
			/end TP_BLOB
		/end IF_DATA
		/begin IF_DATA ASAP1B_KWP2000
			/begin SOURCE
				Timer
				4
				1
				/begin QP_BLOB
					1 BLOCKMODE 0xE0 0 26
				/end QP_BLOB
			/end SOURCE
			/begin TP_BLOB
				0x101
				0x10
				0xF1
				WUP
				MSB_FIRST
				0
				/begin DIAG_BAUD
					10400 0xA1
					BD_PARA 0x14
				/end DIAG_BAUD
				DATA_ACCESS 0x0000 0x0000 1 0 0 1
				/begin CHECKSUM
					0x010201 1 0xA2 CodedResult
				/end CHECKSUM
				/begin FLASH_COPY
					TOOLFLASHBACK
					3
					StartRoutine
					RAM_INITBYECU
					0xA2
					COPY_FRAME 1
					COPY_PARA 0x14
				/end FLASH_COPY
				/begin PAGE_SWITCH
					LOCAL_ROUTINE
					/begin ROUTINE_PARA
						0xA1 StartRoutine
					/end ROUTINE_PARA
					PAGE_CODE 0x00 0x01
				/end PAGE_SWITCH
			/end TP_BLOB
		/end IF_DATA
		/begin CHARACTERISTIC Adinjban
			"Selection_adapt_injection_banc"
			VALUE
			0x75949
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Aps_coh_filter_gain_
			"Aps_coh_filter_gain"
			VALUE
			0x73240
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Autorisation_misfire_
			"Autorisation_misfire"
			VALUE
			0x71DF0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Autorisation_test_power_latch_
			"Autorisation_test_power_latch"
			CURVE
			0x79044
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				NO_INPUT_QUANTITY
				Id_0x00
				17
				0
				16
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 1 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Autorise_clq_num
			"Autorise_clq_num"
			VALUE
			0x721A8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Autorise_raz_eeprom
			"Autorise_raz_eeprom"
			VALUE
			0x736D0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Autorise_test_id_pour_raz_eeprom
			"Autorise_test_id_pour_raz_eeprom"
			VALUE
			0x736D1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Avbanc
			"Avance_banc"
			VALUE
			0x70FD2
			DATA_RECORD_UBYTE
			95.625
			F_0v375_m23v625_6
			-23.625
			72
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Avbanc1
			"Banc_avance_actif"
			VALUE
			0x70FD3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Avmanu
			"Banc_avance_manuel"
			VALUE
			0x70FD4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Avoffset
			"Banc_avance_offset"
			VALUE
			0x70FD5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Batcdmux
			"Seuil_bat_connex_liaison_mux"
			VALUE
			0x720E8
			DATA_RECORD_UWORD
			8.191875
			F_0v000125_p8_7
			8
			16.191875
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cadgainm
			"Valeur_banc_gain_adaptatif"
			VALUE
			0x7594A
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cadzerom
			"Valeur_banc_offset_adaptatif"
			VALUE
			0x7594B
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Calib_mask_inhibe_sdf_
			"Calib_mask_inhibe_sdf"
			VALUE
			0x78FF4
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Calibration_debut
			"Calibration_debut"
			VALUE
			0x70000
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Can_rx_block_size
			"Can_rx_block_size"
			VALUE
			0x71E90
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Can_rx_stmin
			"Can_rx_stmin"
			VALUE
			0x71E91
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ac_l_vc_eng_conf
			"Cbx_ac_l_vc_eng_conf"
			VALUE
			0x72134
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ac_load_dft_ena
			"Cbx_ac_load_dft_ena"
			VALUE
			0x72135
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ac_mdf1_cmd
			"Cbx_ac_mdf1_cmd"
			VALUE
			0x72136
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x2
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ac_mux
			"Cbx_ac_mux"
			VALUE
			0x71E92
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ac_vld_conf
			"Cbx_ac_vld_conf"
			VALUE
			0x72137
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_act_edic
			"Cbx_act_edic"
			VALUE
			0x7701D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_act_oten
			"Cbx_act_oten"
			VALUE
			0x7701E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_actr_spg_dsb
			"Cbx_actr_spg_dsb"
			VALUE
			0x76FA0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ad1_zon0_ini_req
			"Cbx_ad1_zon0_ini_req"
			VALUE
			0x731C2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ad1_zon1_ini_req
			"Cbx_ad1_zon1_ini_req"
			VALUE
			0x731C2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x2
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ad1_zon2_ini_req
			"Cbx_ad1_zon2_ini_req"
			VALUE
			0x731C2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x4
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ad1_zon3_ini_req
			"Cbx_ad1_zon3_ini_req"
			VALUE
			0x731C2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x8
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ad1_zon4_ini_req
			"Cbx_ad1_zon4_ini_req"
			VALUE
			0x731C2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x10
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ad_dft_ini_req
			"Cbx_ad_dft_ini_req"
			VALUE
			0x73194
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ad_ini_req
			"Cbx_ad_ini_req"
			VALUE
			0x73195
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ad_tq_agb_conf
			"Cbx_ad_tq_agb_conf"
			VALUE
			0x790E8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_agb_clck_test_ena
			"Cbx_agb_clck_test_ena"
			VALUE
			0x71E93
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_agb_conf
			"Cbx_agb_conf"
			VALUE
			0x7311C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_agb_csm_tq_conf
			"Cbx_agb_csm_tq_conf"
			VALUE
			0x71E94
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_agb_dyn_iga_conf
			"Cbx_agb_dyn_iga_conf"
			VALUE
			0x73C18
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_agb_is_n_req
			"Cbx_agb_is_n_req"
			VALUE
			0x71E95
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_agb_mdf2_conf
			"Cbx_agb_mdf2_conf"
			VALUE
			0x7372C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_agb_min_tqe_dsb
			"Cbx_agb_min_tqe_dsb"
			VALUE
			0x790E9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_air_pump_conf
			"Cbx_air_pump_conf"
			VALUE
			0x7AC48
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_aj_dsb_conf
			"Cbx_aj_dsb_conf"
			VALUE
			0x790EA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_alt_pwm_frst_lvl_act
			"Cbx_alt_pwm_frst_lvl_act"
			VALUE
			0x70DE1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_alt_pwm_per_on_ris_edg
			"Cbx_alt_pwm_per_on_ris_edg"
			VALUE
			0x70DE2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_alt_rat_mux_dsb
			"Cbx_alt_rat_mux_dsb"
			VALUE
			0x70DE3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_alt_tco_cor_vld
			"Cbx_alt_tco_cor_vld"
			VALUE
			0x790EB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_alt_tq_conf
			"Cbx_alt_tq_conf"
			VALUE
			0x790EC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_alt_typ_tco_cor
			"Cbx_alt_typ_tco_cor"
			VALUE
			0x790ED
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_alt_v_fil_ena
			"Cbx_alt_v_fil_ena"
			VALUE
			0x70DE4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_bch_cp_thr_adj
			"Cbx_bch_cp_thr_adj"
			VALUE
			0x70D24
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_bch_cylr
			"Cbx_bch_cylr"
			VALUE
			0x70CA8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_bch_dsb_thr_adj
			"Cbx_bch_dsb_thr_adj"
			VALUE
			0x70D25
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_bch_dsb_thr_adj_val
			"Cbx_bch_dsb_thr_adj_val"
			VALUE
			0x70D26
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_bch_in_angl
			"Cbx_bch_in_angl"
			VALUE
			0x7351C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_bch_inj1_cut_req
			"Cbx_bch_inj1_cut_req"
			VALUE
			0x7486E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_bch_inj2_cut_req
			"Cbx_bch_inj2_cut_req"
			VALUE
			0x7486F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_bch_inj3_cut_req
			"Cbx_bch_inj3_cut_req"
			VALUE
			0x74870
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_bch_inj4_cut_req
			"Cbx_bch_inj4_cut_req"
			VALUE
			0x74871
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_bch_mod
			"Cbx_bch_mod"
			VALUE
			0x70FD6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_bch_mod_dyn_tq
			"Cbx_bch_mod_dyn_tq"
			VALUE
			0x790EE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_bch_mod_stat_tq
			"Cbx_bch_mod_stat_tq"
			VALUE
			0x790EF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_bch_mod_tq
			"Cbx_bch_mod_tq"
			VALUE
			0x790F0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_bch_rst_thr_adj
			"Cbx_bch_rst_thr_adj"
			VALUE
			0x70D27
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_bch_tco_toil
			"Cbx_bch_tco_toil"
			VALUE
			0x7351D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_bch_tco_toil_2
			"Cbx_bch_tco_toil_2"
			VALUE
			0x7351E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_brk_pdl_conf
			"Cbx_brk_pdl_conf"
			VALUE
			0x73704
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cam_dft_ini_req
			"Cbx_cam_dft_ini_req"
			VALUE
			0x73196
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cam_long_toth_conf
			"Cbx_cam_long_toth_conf"
			VALUE
			0x7B0C8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_can_emt_flow
			"Cbx_can_emt_flow"
			VALUE
			0x71E96
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cart_iga_bch_mod
			"Cbx_cart_iga_bch_mod"
			VALUE
			0x73C19
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_ac_prs_pf
			"Cbx_cata_ac_prs_pf"
			VALUE
			0x70179
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_ac_rcpt_pf
			"Cbx_cata_ac_rcpt_pf"
			VALUE
			0x7017A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_acr_pf
			"Cbx_cata_acr_pf"
			VALUE
			0x7017B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_actr_rly_cut_pf
			"Cbx_cata_actr_rly_cut_pf"
			VALUE
			0x7017D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_actr_rly_pf
			"Cbx_cata_actr_rly_pf"
			VALUE
			0x7017C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_agb_pf
			"Cbx_cata_agb_pf"
			VALUE
			0x7017E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_agb_rcpt_mfo
			"Cbx_cata_agb_rcpt_mfo"
			VALUE
			0x706D9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_agb_rcpt_vf
			"Cbx_cata_agb_rcpt_vf"
			VALUE
			0x7047C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_air_mfo
			"Cbx_cata_air_mfo"
			VALUE
			0x706DA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_air_pf
			"Cbx_cata_air_pf"
			VALUE
			0x7017F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_air_vf
			"Cbx_cata_air_vf"
			VALUE
			0x7047D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_alt_load_in_pf
			"Cbx_cata_alt_load_in_pf"
			VALUE
			0x70181
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_alt_pf
			"Cbx_cata_alt_pf"
			VALUE
			0x70180
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_bkup_mem_mfo
			"Cbx_cata_bkup_mem_mfo"
			VALUE
			0x706DB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_bkup_mem_pf
			"Cbx_cata_bkup_mem_pf"
			VALUE
			0x70182
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_bkup_mem_vf
			"Cbx_cata_bkup_mem_vf"
			VALUE
			0x7047E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_checksum_pf
			"Cbx_cata_checksum_pf"
			VALUE
			0x70183
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_clu_mfo
			"Cbx_cata_clu_mfo"
			VALUE
			0x706DC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_clu_pf
			"Cbx_cata_clu_pf"
			VALUE
			0x70184
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_clu_vf
			"Cbx_cata_clu_vf"
			VALUE
			0x7047F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_cp_mfo
			"Cbx_cata_cp_mfo"
			VALUE
			0x70620
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_cp_pf
			"Cbx_cata_cp_pf"
			VALUE
			0x70185
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_cp_vf
			"Cbx_cata_cp_vf"
			VALUE
			0x70465
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_crk_mfo
			"Cbx_cata_crk_mfo"
			VALUE
			0x706DD
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_crk_nr_mfo
			"Cbx_cata_crk_nr_mfo"
			VALUE
			0x706DE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_crk_nr_pf
			"Cbx_cata_crk_nr_pf"
			VALUE
			0x70187
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_crk_nr_vf
			"Cbx_cata_crk_nr_vf"
			VALUE
			0x70481
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_crk_pf
			"Cbx_cata_crk_pf"
			VALUE
			0x70186
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_crk_vf
			"Cbx_cata_crk_vf"
			VALUE
			0x70480
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_cru_pf
			"Cbx_cata_cru_pf"
			VALUE
			0x70188
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_diag_stg_bch_mod
			"Cbx_cata_diag_stg_bch_mod"
			VALUE
			0x7701F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_el_wind_rcpt_pf
			"Cbx_cata_el_wind_rcpt_pf"
			VALUE
			0x70189
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_eng_temp_pf
			"Cbx_cata_eng_temp_pf"
			VALUE
			0x7018A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_eng_whl_mfo
			"Cbx_cata_eng_whl_mfo"
			VALUE
			0x706DF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_eng_whl_pf
			"Cbx_cata_eng_whl_pf"
			VALUE
			0x7018B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_eng_whl_vf
			"Cbx_cata_eng_whl_vf"
			VALUE
			0x70482
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_fsys_lpg_mfo
			"Cbx_cata_fsys_lpg_mfo"
			VALUE
			0x706E1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_fsys_lpg_pf
			"Cbx_cata_fsys_lpg_pf"
			VALUE
			0x7018D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_fsys_lpg_vf
			"Cbx_cata_fsys_lpg_vf"
			VALUE
			0x70484
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_fsys_mfo
			"Cbx_cata_fsys_mfo"
			VALUE
			0x706E0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_fsys_pf
			"Cbx_cata_fsys_pf"
			VALUE
			0x7018C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_fsys_vf
			"Cbx_cata_fsys_vf"
			VALUE
			0x70483
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_gas_pump_mfo
			"Cbx_cata_gas_pump_mfo"
			VALUE
			0x70621
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_gas_pump_pf
			"Cbx_cata_gas_pump_pf"
			VALUE
			0x7018E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_gas_pump_vf
			"Cbx_cata_gas_pump_vf"
			VALUE
			0x70466
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_igc_1_mfo
			"Cbx_cata_igc_1_mfo"
			VALUE
			0x70622
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_igc_1_pf
			"Cbx_cata_igc_1_pf"
			VALUE
			0x7018F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_igc_1_vf
			"Cbx_cata_igc_1_vf"
			VALUE
			0x70467
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_igc_2_mfo
			"Cbx_cata_igc_2_mfo"
			VALUE
			0x70623
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_igc_2_pf
			"Cbx_cata_igc_2_pf"
			VALUE
			0x70190
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_igc_2_vf
			"Cbx_cata_igc_2_vf"
			VALUE
			0x70468
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_igc_3_mfo
			"Cbx_cata_igc_3_mfo"
			VALUE
			0x70624
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_igc_3_pf
			"Cbx_cata_igc_3_pf"
			VALUE
			0x70191
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_igc_3_vf
			"Cbx_cata_igc_3_vf"
			VALUE
			0x70469
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_igc_4_mfo
			"Cbx_cata_igc_4_mfo"
			VALUE
			0x70625
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_igc_4_pf
			"Cbx_cata_igc_4_pf"
			VALUE
			0x70192
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_igc_4_vf
			"Cbx_cata_igc_4_vf"
			VALUE
			0x7046A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_inj1_mfo
			"Cbx_cata_inj1_mfo"
			VALUE
			0x70626
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_inj1_pf
			"Cbx_cata_inj1_pf"
			VALUE
			0x70193
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_inj1_vf
			"Cbx_cata_inj1_vf"
			VALUE
			0x7046B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_inj2_mfo
			"Cbx_cata_inj2_mfo"
			VALUE
			0x70627
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_inj2_pf
			"Cbx_cata_inj2_pf"
			VALUE
			0x70194
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_inj2_vf
			"Cbx_cata_inj2_vf"
			VALUE
			0x7046C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_inj3_mfo
			"Cbx_cata_inj3_mfo"
			VALUE
			0x70628
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_inj3_pf
			"Cbx_cata_inj3_pf"
			VALUE
			0x70195
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_inj3_vf
			"Cbx_cata_inj3_vf"
			VALUE
			0x7046D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_inj4_mfo
			"Cbx_cata_inj4_mfo"
			VALUE
			0x70629
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_inj4_pf
			"Cbx_cata_inj4_pf"
			VALUE
			0x70196
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_inj4_vf
			"Cbx_cata_inj4_vf"
			VALUE
			0x7046E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_inj_ecu_mfo
			"Cbx_cata_inj_ecu_mfo"
			VALUE
			0x706E2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_inj_ecu_pf
			"Cbx_cata_inj_ecu_pf"
			VALUE
			0x70197
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_inj_ecu_vf
			"Cbx_cata_inj_ecu_vf"
			VALUE
			0x70485
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_ip_inj_cnt_pf
			"Cbx_cata_ip_inj_cnt_pf"
			VALUE
			0x70198
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_knk_mfo
			"Cbx_cata_knk_mfo"
			VALUE
			0x706E3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_knk_pf
			"Cbx_cata_knk_pf"
			VALUE
			0x70199
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_knk_vf
			"Cbx_cata_knk_vf"
			VALUE
			0x70486
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_lbdw_hot_mfo
			"Cbx_cata_lbdw_hot_mfo"
			VALUE
			0x7062B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_lbdw_hot_pf
			"Cbx_cata_lbdw_hot_pf"
			VALUE
			0x7019B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_lbdw_hot_vf
			"Cbx_cata_lbdw_hot_vf"
			VALUE
			0x70470
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_lbdw_mfo
			"Cbx_cata_lbdw_mfo"
			VALUE
			0x7062A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_lbdw_pf
			"Cbx_cata_lbdw_pf"
			VALUE
			0x7019A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_lbdw_pump_crt_pf
			"Cbx_cata_lbdw_pump_crt_pf"
			VALUE
			0x7019C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_lbdw_vf
			"Cbx_cata_lbdw_vf"
			VALUE
			0x7046F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_lbup_hot_mfo
			"Cbx_cata_lbup_hot_mfo"
			VALUE
			0x7062D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_lbup_hot_pf
			"Cbx_cata_lbup_hot_pf"
			VALUE
			0x7019E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_lbup_hot_vf
			"Cbx_cata_lbup_hot_vf"
			VALUE
			0x70472
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_lbup_mfo
			"Cbx_cata_lbup_mfo"
			VALUE
			0x7062C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_lbup_pf
			"Cbx_cata_lbup_pf"
			VALUE
			0x7019D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_lbup_pump_crt_pf
			"Cbx_cata_lbup_pump_crt_pf"
			VALUE
			0x7019F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_lbup_vf
			"Cbx_cata_lbup_vf"
			VALUE
			0x70471
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_lpg_rcpt_mfo
			"Cbx_cata_lpg_rcpt_mfo"
			VALUE
			0x706E4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_lpg_rcpt_pf
			"Cbx_cata_lpg_rcpt_pf"
			VALUE
			0x701A0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_lpg_rcpt_vf
			"Cbx_cata_lpg_rcpt_vf"
			VALUE
			0x70487
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_map_chr_pf
			"Cbx_cata_map_chr_pf"
			VALUE
			0x701A2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_map_mfo
			"Cbx_cata_map_mfo"
			VALUE
			0x706E5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_map_pf
			"Cbx_cata_map_pf"
			VALUE
			0x701A1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_map_vf
			"Cbx_cata_map_vf"
			VALUE
			0x70488
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mastervac_pf
			"Cbx_cata_mastervac_pf"
			VALUE
			0x701A3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mcut_sens1_pf
			"Cbx_cata_mcut_sens1_pf"
			VALUE
			0x701A4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mdf1_pf
			"Cbx_cata_mdf1_pf"
			VALUE
			0x701A5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mdf2_pf
			"Cbx_cata_mdf2_pf"
			VALUE
			0x701A6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_min_gas_lvl_mfo
			"Cbx_cata_min_gas_lvl_mfo"
			VALUE
			0x706E6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_min_gas_lvl_pf
			"Cbx_cata_min_gas_lvl_pf"
			VALUE
			0x701A7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_min_gas_lvl_vf
			"Cbx_cata_min_gas_lvl_vf"
			VALUE
			0x70489
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_min_lpg_lvl_pf
			"Cbx_cata_min_lpg_lvl_pf"
			VALUE
			0x701A8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_cata_1_lpg_mfo
			"Cbx_cata_mis_cata_1_lpg_mfo"
			VALUE
			0x706E9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_cata_1_lpg_pf
			"Cbx_cata_mis_cata_1_lpg_pf"
			VALUE
			0x701AB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_cata_1_lpg_vf
			"Cbx_cata_mis_cata_1_lpg_vf"
			VALUE
			0x7048C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_cata_1_mfo
			"Cbx_cata_mis_cata_1_mfo"
			VALUE
			0x706E8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_cata_1_pf
			"Cbx_cata_mis_cata_1_pf"
			VALUE
			0x701AA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_cata_1_vf
			"Cbx_cata_mis_cata_1_vf"
			VALUE
			0x7048B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_cata_2_lpg_mfo
			"Cbx_cata_mis_cata_2_lpg_mfo"
			VALUE
			0x706EB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_cata_2_lpg_pf
			"Cbx_cata_mis_cata_2_lpg_pf"
			VALUE
			0x701AD
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_cata_2_lpg_vf
			"Cbx_cata_mis_cata_2_lpg_vf"
			VALUE
			0x7048E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_cata_2_mfo
			"Cbx_cata_mis_cata_2_mfo"
			VALUE
			0x706EA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_cata_2_pf
			"Cbx_cata_mis_cata_2_pf"
			VALUE
			0x701AC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_cata_2_vf
			"Cbx_cata_mis_cata_2_vf"
			VALUE
			0x7048D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_cata_3_lpg_mfo
			"Cbx_cata_mis_cata_3_lpg_mfo"
			VALUE
			0x706ED
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_cata_3_lpg_pf
			"Cbx_cata_mis_cata_3_lpg_pf"
			VALUE
			0x701AF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_cata_3_lpg_vf
			"Cbx_cata_mis_cata_3_lpg_vf"
			VALUE
			0x70490
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_cata_3_mfo
			"Cbx_cata_mis_cata_3_mfo"
			VALUE
			0x706EC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_cata_3_pf
			"Cbx_cata_mis_cata_3_pf"
			VALUE
			0x701AE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_cata_3_vf
			"Cbx_cata_mis_cata_3_vf"
			VALUE
			0x7048F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_cata_4_lpg_mfo
			"Cbx_cata_mis_cata_4_lpg_mfo"
			VALUE
			0x706EF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_cata_4_lpg_pf
			"Cbx_cata_mis_cata_4_lpg_pf"
			VALUE
			0x701B1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_cata_4_lpg_vf
			"Cbx_cata_mis_cata_4_lpg_vf"
			VALUE
			0x70492
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_cata_4_mfo
			"Cbx_cata_mis_cata_4_mfo"
			VALUE
			0x706EE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_cata_4_pf
			"Cbx_cata_mis_cata_4_pf"
			VALUE
			0x701B0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_cata_4_vf
			"Cbx_cata_mis_cata_4_vf"
			VALUE
			0x70491
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_cata_gas_mfo
			"Cbx_cata_mis_cata_gas_mfo"
			VALUE
			0x706F0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_cata_gas_pf
			"Cbx_cata_mis_cata_gas_pf"
			VALUE
			0x701B2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_cata_gas_vf
			"Cbx_cata_mis_cata_gas_vf"
			VALUE
			0x70493
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_cata_lpg_mfo
			"Cbx_cata_mis_cata_lpg_mfo"
			VALUE
			0x706F1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_cata_lpg_pf
			"Cbx_cata_mis_cata_lpg_pf"
			VALUE
			0x701B3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_cata_lpg_vf
			"Cbx_cata_mis_cata_lpg_vf"
			VALUE
			0x70494
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_cata_mfo
			"Cbx_cata_mis_cata_mfo"
			VALUE
			0x706E7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_cata_pf
			"Cbx_cata_mis_cata_pf"
			VALUE
			0x701A9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_cata_vf
			"Cbx_cata_mis_cata_vf"
			VALUE
			0x7048A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_fast_pf
			"Cbx_cata_mis_fast_pf"
			VALUE
			0x701B4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_lih_pf
			"Cbx_cata_mis_lih_pf"
			VALUE
			0x701B5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_polu_1_lpg_mfo
			"Cbx_cata_mis_polu_1_lpg_mfo"
			VALUE
			0x706F4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_polu_1_lpg_pf
			"Cbx_cata_mis_polu_1_lpg_pf"
			VALUE
			0x701B8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_polu_1_lpg_vf
			"Cbx_cata_mis_polu_1_lpg_vf"
			VALUE
			0x70497
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_polu_1_mfo
			"Cbx_cata_mis_polu_1_mfo"
			VALUE
			0x706F3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_polu_1_pf
			"Cbx_cata_mis_polu_1_pf"
			VALUE
			0x701B7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_polu_1_vf
			"Cbx_cata_mis_polu_1_vf"
			VALUE
			0x70496
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_polu_2_lpg_mfo
			"Cbx_cata_mis_polu_2_lpg_mfo"
			VALUE
			0x706F6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_polu_2_lpg_pf
			"Cbx_cata_mis_polu_2_lpg_pf"
			VALUE
			0x701BA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_polu_2_lpg_vf
			"Cbx_cata_mis_polu_2_lpg_vf"
			VALUE
			0x70499
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_polu_2_mfo
			"Cbx_cata_mis_polu_2_mfo"
			VALUE
			0x706F5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_polu_2_pf
			"Cbx_cata_mis_polu_2_pf"
			VALUE
			0x701B9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_polu_2_vf
			"Cbx_cata_mis_polu_2_vf"
			VALUE
			0x70498
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_polu_3_lpg_mfo
			"Cbx_cata_mis_polu_3_lpg_mfo"
			VALUE
			0x706F8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_polu_3_lpg_pf
			"Cbx_cata_mis_polu_3_lpg_pf"
			VALUE
			0x701BC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_polu_3_lpg_vf
			"Cbx_cata_mis_polu_3_lpg_vf"
			VALUE
			0x7049B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_polu_3_mfo
			"Cbx_cata_mis_polu_3_mfo"
			VALUE
			0x706F7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_polu_3_pf
			"Cbx_cata_mis_polu_3_pf"
			VALUE
			0x701BB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_polu_3_vf
			"Cbx_cata_mis_polu_3_vf"
			VALUE
			0x7049A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_polu_4_lpg_mfo
			"Cbx_cata_mis_polu_4_lpg_mfo"
			VALUE
			0x706FA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_polu_4_lpg_pf
			"Cbx_cata_mis_polu_4_lpg_pf"
			VALUE
			0x701BE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_polu_4_lpg_vf
			"Cbx_cata_mis_polu_4_lpg_vf"
			VALUE
			0x7049D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_polu_4_mfo
			"Cbx_cata_mis_polu_4_mfo"
			VALUE
			0x706F9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_polu_4_pf
			"Cbx_cata_mis_polu_4_pf"
			VALUE
			0x701BD
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_polu_4_vf
			"Cbx_cata_mis_polu_4_vf"
			VALUE
			0x7049C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_polu_gas_mfo
			"Cbx_cata_mis_polu_gas_mfo"
			VALUE
			0x706FB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_polu_gas_pf
			"Cbx_cata_mis_polu_gas_pf"
			VALUE
			0x701BF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_polu_gas_vf
			"Cbx_cata_mis_polu_gas_vf"
			VALUE
			0x7049E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_polu_lpg_mfo
			"Cbx_cata_mis_polu_lpg_mfo"
			VALUE
			0x706FC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_polu_lpg_pf
			"Cbx_cata_mis_polu_lpg_pf"
			VALUE
			0x701C0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_polu_lpg_vf
			"Cbx_cata_mis_polu_lpg_vf"
			VALUE
			0x7049F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_polu_mfo
			"Cbx_cata_mis_polu_mfo"
			VALUE
			0x706F2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_polu_pf
			"Cbx_cata_mis_polu_pf"
			VALUE
			0x701B6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mis_polu_vf
			"Cbx_cata_mis_polu_vf"
			VALUE
			0x70495
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mvac_pump_pf
			"Cbx_cata_mvac_pump_pf"
			VALUE
			0x701C1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_mvac_sys_pf
			"Cbx_cata_mvac_sys_pf"
			VALUE
			0x701C2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_obd_cata_mfo
			"Cbx_cata_obd_cata_mfo"
			VALUE
			0x706FD
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_obd_cata_pf
			"Cbx_cata_obd_cata_pf"
			VALUE
			0x701C3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_obd_cata_vf
			"Cbx_cata_obd_cata_vf"
			VALUE
			0x704A0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_obd_lamb_mfo
			"Cbx_cata_obd_lamb_mfo"
			VALUE
			0x706FE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_obd_lamb_pf
			"Cbx_cata_obd_lamb_pf"
			VALUE
			0x701C4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_obd_lamb_vf
			"Cbx_cata_obd_lamb_vf"
			VALUE
			0x704A1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_obd_sa_mfo
			"Cbx_cata_obd_sa_mfo"
			VALUE
			0x706FF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_obd_sa_pf
			"Cbx_cata_obd_sa_pf"
			VALUE
			0x701C5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_obd_sa_vf
			"Cbx_cata_obd_sa_vf"
			VALUE
			0x704A2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_oil_pf
			"Cbx_cata_oil_pf"
			VALUE
			0x701C6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_pdl_pf
			"Cbx_cata_pdl_pf"
			VALUE
			0x701C7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_pmh_pf
			"Cbx_cata_pmh_pf"
			VALUE
			0x701C8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_pow_lbdw_mfo
			"Cbx_cata_pow_lbdw_mfo"
			VALUE
			0x70700
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_pow_lbdw_pf
			"Cbx_cata_pow_lbdw_pf"
			VALUE
			0x701C9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_pow_lbdw_vf
			"Cbx_cata_pow_lbdw_vf"
			VALUE
			0x704A3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_pow_lbup_mfo
			"Cbx_cata_pow_lbup_mfo"
			VALUE
			0x70701
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_pow_lbup_pf
			"Cbx_cata_pow_lbup_pf"
			VALUE
			0x701CA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_pow_lbup_vf
			"Cbx_cata_pow_lbup_vf"
			VALUE
			0x704A4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_ptc_pf
			"Cbx_cata_ptc_pf"
			VALUE
			0x701CB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_ptc_rov_pf
			"Cbx_cata_ptc_rov_pf"
			VALUE
			0x701CC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_pws_pf
			"Cbx_cata_pws_pf"
			VALUE
			0x701CD
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_rams_pdl_mfo
			"Cbx_cata_rams_pdl_mfo"
			VALUE
			0x70702
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_rams_pdl_pf
			"Cbx_cata_rams_pdl_pf"
			VALUE
			0x701CF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_rams_pdl_vf
			"Cbx_cata_rams_pdl_vf"
			VALUE
			0x704A5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_rams_pf
			"Cbx_cata_rams_pf"
			VALUE
			0x701CE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_reserve_3_pf
			"Cbx_cata_reserve_3_pf"
			VALUE
			0x701D0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_rmc_pf
			"Cbx_cata_rmc_pf"
			VALUE
			0x701D1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_sa_ev_mfo
			"Cbx_cata_sa_ev_mfo"
			VALUE
			0x7062F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_sa_ev_pf
			"Cbx_cata_sa_ev_pf"
			VALUE
			0x701D3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_sa_ev_vf
			"Cbx_cata_sa_ev_vf"
			VALUE
			0x70474
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_sa_mfo
			"Cbx_cata_sa_mfo"
			VALUE
			0x7062E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_sa_pf
			"Cbx_cata_sa_pf"
			VALUE
			0x701D2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_sa_vf
			"Cbx_cata_sa_vf"
			VALUE
			0x70473
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_spg_mfo
			"Cbx_cata_spg_mfo"
			VALUE
			0x70703
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_spg_pf
			"Cbx_cata_spg_pf"
			VALUE
			0x701D4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_spg_sys_mfo
			"Cbx_cata_spg_sys_mfo"
			VALUE
			0x70704
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_spg_sys_pf
			"Cbx_cata_spg_sys_pf"
			VALUE
			0x701D5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_spg_sys_vf
			"Cbx_cata_spg_sys_vf"
			VALUE
			0x704A7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_spg_vf
			"Cbx_cata_spg_vf"
			VALUE
			0x704A6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_spi_cc_pf
			"Cbx_cata_spi_cc_pf"
			VALUE
			0x701D6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_svkl_pf
			"Cbx_cata_svkl_pf"
			VALUE
			0x701D7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_swlk_pf
			"Cbx_cata_swlk_pf"
			VALUE
			0x701D8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_tco_mfo
			"Cbx_cata_tco_mfo"
			VALUE
			0x70630
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_tco_pf
			"Cbx_cata_tco_pf"
			VALUE
			0x701D9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_tco_vf
			"Cbx_cata_tco_vf"
			VALUE
			0x70475
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_thpl_pf
			"Cbx_cata_thpl_pf"
			VALUE
			0x701DA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_thr_cmd_pf
			"Cbx_cata_thr_cmd_pf"
			VALUE
			0x701DC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_thr_pf
			"Cbx_cata_thr_pf"
			VALUE
			0x701DB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_tia_mfo
			"Cbx_cata_tia_mfo"
			VALUE
			0x70631
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_tia_pf
			"Cbx_cata_tia_pf"
			VALUE
			0x701DD
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_tia_vf
			"Cbx_cata_tia_vf"
			VALUE
			0x70476
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_tjy_ctl_pf
			"Cbx_cata_tjy_ctl_pf"
			VALUE
			0x701DE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_tlz_ad_b_mfo
			"Cbx_cata_tlz_ad_b_mfo"
			VALUE
			0x70705
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_tlz_ad_b_pf
			"Cbx_cata_tlz_ad_b_pf"
			VALUE
			0x701DF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_tlz_ad_b_vf
			"Cbx_cata_tlz_ad_b_vf"
			VALUE
			0x704A8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_vb_pf
			"Cbx_cata_vb_pf"
			VALUE
			0x701E0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_vs_mfo
			"Cbx_cata_vs_mfo"
			VALUE
			0x70632
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_vs_pf
			"Cbx_cata_vs_pf"
			VALUE
			0x701E1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_vs_vf
			"Cbx_cata_vs_vf"
			VALUE
			0x70477
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_vta_intake_mfo
			"Cbx_cata_vta_intake_mfo"
			VALUE
			0x70633
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_vta_intake_pf
			"Cbx_cata_vta_intake_pf"
			VALUE
			0x701E2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_vta_intake_vf
			"Cbx_cata_vta_intake_vf"
			VALUE
			0x70478
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_vvt_int_ev_mfo
			"Cbx_cata_vvt_int_ev_mfo"
			VALUE
			0x70634
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_vvt_int_ev_pf
			"Cbx_cata_vvt_int_ev_pf"
			VALUE
			0x701E4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_vvt_int_ev_vf
			"Cbx_cata_vvt_int_ev_vf"
			VALUE
			0x70479
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_vvt_int_old_off_mfo
			"Cbx_cata_vvt_int_old_off_mfo"
			VALUE
			0x70706
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_vvt_int_old_off_vf
			"Cbx_cata_vvt_int_old_off_vf"
			VALUE
			0x704A9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_vvt_int_pf
			"Cbx_cata_vvt_int_pf"
			VALUE
			0x701E3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_vvt_intake_mfo
			"Cbx_cata_vvt_intake_mfo"
			VALUE
			0x70635
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_vvt_intake_pf
			"Cbx_cata_vvt_intake_pf"
			VALUE
			0x701E5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_vvt_intake_vf
			"Cbx_cata_vvt_intake_vf"
			VALUE
			0x7047A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_vvtc_toth_3_mfo
			"Cbx_cata_vvtc_toth_3_mfo"
			VALUE
			0x70707
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_vvtc_toth_3_pf
			"Cbx_cata_vvtc_toth_3_pf"
			VALUE
			0x701E6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_vvtc_toth_3_vf
			"Cbx_cata_vvtc_toth_3_vf"
			VALUE
			0x704AA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_wat_temp_pf
			"Cbx_cata_wat_temp_pf"
			VALUE
			0x701E7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_wgc_mfo
			"Cbx_cata_wgc_mfo"
			VALUE
			0x70636
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_wgc_pf
			"Cbx_cata_wgc_pf"
			VALUE
			0x701E8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_wgc_vf
			"Cbx_cata_wgc_vf"
			VALUE
			0x7047B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cata_wpmp_pf
			"Cbx_cata_wpmp_pf"
			VALUE
			0x701E9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_clos_thr_dsb
			"Cbx_clos_thr_dsb"
			VALUE
			0x790F1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_clos_typ_prs_cnt
			"Cbx_clos_typ_prs_cnt"
			VALUE
			0x73705
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_clu_cnt_inv
			"Cbx_clu_cnt_inv"
			VALUE
			0x736E4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cold_loop_ac
			"Cbx_cold_loop_ac"
			VALUE
			0x72138
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_conf_schd_diag_cata
			"Cbx_conf_schd_diag_cata"
			VALUE
			0x77020
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_conf_schd_diag_fsys
			"Cbx_conf_schd_diag_fsys"
			VALUE
			0x77021
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_conf_schd_diag_lamb
			"Cbx_conf_schd_diag_lamb"
			VALUE
			0x77022
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_conf_schd_diag_mis
			"Cbx_conf_schd_diag_mis"
			VALUE
			0x77023
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_conf_schd_diag_sa
			"Cbx_conf_schd_diag_sa"
			VALUE
			0x77024
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_crsh_typ_phs_1
			"Cbx_crsh_typ_phs_1"
			VALUE
			0x71E97
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cru_sl_dspl_pres
			"Cbx_cru_sl_dspl_pres"
			VALUE
			0x78D66
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cru_sl_dspl_vs
			"Cbx_cru_sl_dspl_vs"
			VALUE
			0x78D67
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cru_sl_lk_rls_ena
			"Cbx_cru_sl_lk_rls_ena"
			VALUE
			0x78D68
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cru_sl_no_lim_grd
			"Cbx_cru_sl_no_lim_grd"
			VALUE
			0x78D69
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cru_sl_stt_ip
			"Cbx_cru_sl_stt_ip"
			VALUE
			0x78D6A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cru_sl_wit_vs_n_rat
			"Cbx_cru_sl_wit_vs_n_rat"
			VALUE
			0x78D6B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ctl_mux_dyn_iga_conf
			"Cbx_ctl_mux_dyn_iga_conf"
			VALUE
			0x73C1A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cylr_bas_conf
			"Cbx_cylr_bas_conf"
			VALUE
			0x73197
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cylr_bch_mod
			"Cbx_cylr_bch_mod"
			VALUE
			0x70CA9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cylr_dyn_iga_off
			"Cbx_cylr_dyn_iga_off"
			VALUE
			0x70FD7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cylr_ena_re_phs
			"Cbx_cylr_ena_re_phs"
			VALUE
			0x70CAA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cylr_is_run_gex_appl
			"Cbx_cylr_is_run_gex_appl"
			VALUE
			0x70CAB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cylr_loop
			"Cbx_cylr_loop"
			VALUE
			0x70CAC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_cylr_run_ol
			"Cbx_cylr_run_ol"
			VALUE
			0x70CAD
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_df_in_fil_ena
			"Cbx_df_in_fil_ena"
			VALUE
			0x70DE5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_driv_tq_req_dsb
			"Cbx_driv_tq_req_dsb"
			VALUE
			0x76FA1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_dyn_iga_cor_conf
			"Cbx_dyn_iga_cor_conf"
			VALUE
			0x73C1B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_dyn_tq_tqr_conf
			"Cbx_dyn_tq_tqr_conf"
			VALUE
			0x790F2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ena_appl_thr_adj
			"Cbx_ena_appl_thr_adj"
			VALUE
			0x70D28
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_eng_tq_loss_ad_dsb
			"Cbx_eng_tq_loss_ad_dsb"
			VALUE
			0x76FA2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fail_dft_ini_req
			"Cbx_fail_dft_ini_req"
			VALUE
			0x73198
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_ac_prs
			"Cbx_ffm1_ac_prs"
			VALUE
			0x707F3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_ac_rcpt
			"Cbx_ffm1_ac_rcpt"
			VALUE
			0x707F4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_acr
			"Cbx_ffm1_acr"
			VALUE
			0x707F5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_actr_rly
			"Cbx_ffm1_actr_rly"
			VALUE
			0x707F6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_actr_rly_cut
			"Cbx_ffm1_actr_rly_cut"
			VALUE
			0x707F7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_agb
			"Cbx_ffm1_agb"
			VALUE
			0x707F8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_air
			"Cbx_ffm1_air"
			VALUE
			0x707F9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_alt
			"Cbx_ffm1_alt"
			VALUE
			0x707FA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_alt_load_in
			"Cbx_ffm1_alt_load_in"
			VALUE
			0x707FB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_bkup_mem
			"Cbx_ffm1_bkup_mem"
			VALUE
			0x707FC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_checksum
			"Cbx_ffm1_checksum"
			VALUE
			0x707FD
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_clu
			"Cbx_ffm1_clu"
			VALUE
			0x707FE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_cp
			"Cbx_ffm1_cp"
			VALUE
			0x707FF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_crk
			"Cbx_ffm1_crk"
			VALUE
			0x70800
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_crk_nr
			"Cbx_ffm1_crk_nr"
			VALUE
			0x70801
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_cru
			"Cbx_ffm1_cru"
			VALUE
			0x70802
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_el_wind_rcpt
			"Cbx_ffm1_el_wind_rcpt"
			VALUE
			0x70803
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_eng_temp
			"Cbx_ffm1_eng_temp"
			VALUE
			0x70804
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_eng_whl
			"Cbx_ffm1_eng_whl"
			VALUE
			0x70805
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_fsys
			"Cbx_ffm1_fsys"
			VALUE
			0x70806
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_fsys_lpg
			"Cbx_ffm1_fsys_lpg"
			VALUE
			0x70807
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_gas_pump
			"Cbx_ffm1_gas_pump"
			VALUE
			0x70808
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_igc_1
			"Cbx_ffm1_igc_1"
			VALUE
			0x70809
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_igc_2
			"Cbx_ffm1_igc_2"
			VALUE
			0x7080A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_igc_3
			"Cbx_ffm1_igc_3"
			VALUE
			0x7080B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_igc_4
			"Cbx_ffm1_igc_4"
			VALUE
			0x7080C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_inj1
			"Cbx_ffm1_inj1"
			VALUE
			0x7080D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_inj2
			"Cbx_ffm1_inj2"
			VALUE
			0x7080E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_inj3
			"Cbx_ffm1_inj3"
			VALUE
			0x7080F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_inj4
			"Cbx_ffm1_inj4"
			VALUE
			0x70810
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_inj_ecu
			"Cbx_ffm1_inj_ecu"
			VALUE
			0x70811
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_ip_inj_cnt
			"Cbx_ffm1_ip_inj_cnt"
			VALUE
			0x70812
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_knk
			"Cbx_ffm1_knk"
			VALUE
			0x70813
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_lbdw
			"Cbx_ffm1_lbdw"
			VALUE
			0x70814
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_lbdw_hot
			"Cbx_ffm1_lbdw_hot"
			VALUE
			0x70815
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_lbdw_pump_crt
			"Cbx_ffm1_lbdw_pump_crt"
			VALUE
			0x70816
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_lbup
			"Cbx_ffm1_lbup"
			VALUE
			0x70817
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_lbup_hot
			"Cbx_ffm1_lbup_hot"
			VALUE
			0x70818
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_lbup_pump_crt
			"Cbx_ffm1_lbup_pump_crt"
			VALUE
			0x70819
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_lpg_rcpt
			"Cbx_ffm1_lpg_rcpt"
			VALUE
			0x7081A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_map
			"Cbx_ffm1_map"
			VALUE
			0x7081B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_map_chr
			"Cbx_ffm1_map_chr"
			VALUE
			0x7081C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_mastervac
			"Cbx_ffm1_mastervac"
			VALUE
			0x7081D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_mcut_sens1
			"Cbx_ffm1_mcut_sens1"
			VALUE
			0x7081E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_mdf1
			"Cbx_ffm1_mdf1"
			VALUE
			0x7081F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_mdf2
			"Cbx_ffm1_mdf2"
			VALUE
			0x70820
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_min_gas_lvl
			"Cbx_ffm1_min_gas_lvl"
			VALUE
			0x70821
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_min_lpg_lvl
			"Cbx_ffm1_min_lpg_lvl"
			VALUE
			0x70822
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_mis_cata
			"Cbx_ffm1_mis_cata"
			VALUE
			0x70823
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_mis_cata_1
			"Cbx_ffm1_mis_cata_1"
			VALUE
			0x70824
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_mis_cata_1_lpg
			"Cbx_ffm1_mis_cata_1_lpg"
			VALUE
			0x70825
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_mis_cata_2
			"Cbx_ffm1_mis_cata_2"
			VALUE
			0x70826
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_mis_cata_2_lpg
			"Cbx_ffm1_mis_cata_2_lpg"
			VALUE
			0x70827
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_mis_cata_3
			"Cbx_ffm1_mis_cata_3"
			VALUE
			0x70828
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_mis_cata_3_lpg
			"Cbx_ffm1_mis_cata_3_lpg"
			VALUE
			0x70829
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_mis_cata_4
			"Cbx_ffm1_mis_cata_4"
			VALUE
			0x7082A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_mis_cata_4_lpg
			"Cbx_ffm1_mis_cata_4_lpg"
			VALUE
			0x7082B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_mis_cata_gas
			"Cbx_ffm1_mis_cata_gas"
			VALUE
			0x7082C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_mis_cata_lpg
			"Cbx_ffm1_mis_cata_lpg"
			VALUE
			0x7082D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_mis_fast
			"Cbx_ffm1_mis_fast"
			VALUE
			0x7082E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_mis_lih
			"Cbx_ffm1_mis_lih"
			VALUE
			0x7082F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_mis_polu
			"Cbx_ffm1_mis_polu"
			VALUE
			0x70830
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_mis_polu_1
			"Cbx_ffm1_mis_polu_1"
			VALUE
			0x70831
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_mis_polu_1_lpg
			"Cbx_ffm1_mis_polu_1_lpg"
			VALUE
			0x70832
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_mis_polu_2
			"Cbx_ffm1_mis_polu_2"
			VALUE
			0x70833
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_mis_polu_2_lpg
			"Cbx_ffm1_mis_polu_2_lpg"
			VALUE
			0x70834
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_mis_polu_3
			"Cbx_ffm1_mis_polu_3"
			VALUE
			0x70835
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_mis_polu_3_lpg
			"Cbx_ffm1_mis_polu_3_lpg"
			VALUE
			0x70836
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_mis_polu_4
			"Cbx_ffm1_mis_polu_4"
			VALUE
			0x70837
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_mis_polu_4_lpg
			"Cbx_ffm1_mis_polu_4_lpg"
			VALUE
			0x70838
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_mis_polu_gas
			"Cbx_ffm1_mis_polu_gas"
			VALUE
			0x70839
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_mis_polu_lpg
			"Cbx_ffm1_mis_polu_lpg"
			VALUE
			0x7083A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_mvac_pump
			"Cbx_ffm1_mvac_pump"
			VALUE
			0x7083B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_mvac_sys
			"Cbx_ffm1_mvac_sys"
			VALUE
			0x7083C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_obd_cata
			"Cbx_ffm1_obd_cata"
			VALUE
			0x7083D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_obd_lamb
			"Cbx_ffm1_obd_lamb"
			VALUE
			0x7083E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_obd_sa
			"Cbx_ffm1_obd_sa"
			VALUE
			0x7083F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_oil
			"Cbx_ffm1_oil"
			VALUE
			0x70840
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_pdl
			"Cbx_ffm1_pdl"
			VALUE
			0x70841
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_pmh
			"Cbx_ffm1_pmh"
			VALUE
			0x70842
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_pow_lbdw
			"Cbx_ffm1_pow_lbdw"
			VALUE
			0x70843
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_pow_lbup
			"Cbx_ffm1_pow_lbup"
			VALUE
			0x70844
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_ptc
			"Cbx_ffm1_ptc"
			VALUE
			0x70845
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_ptc_rov
			"Cbx_ffm1_ptc_rov"
			VALUE
			0x70846
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_pws
			"Cbx_ffm1_pws"
			VALUE
			0x70847
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_rams
			"Cbx_ffm1_rams"
			VALUE
			0x70848
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_rams_pdl
			"Cbx_ffm1_rams_pdl"
			VALUE
			0x70849
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_reserve_3
			"Cbx_ffm1_reserve_3"
			VALUE
			0x7084A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_rmc
			"Cbx_ffm1_rmc"
			VALUE
			0x7084B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_sa
			"Cbx_ffm1_sa"
			VALUE
			0x7084C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_sa_ev
			"Cbx_ffm1_sa_ev"
			VALUE
			0x7084D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_spg
			"Cbx_ffm1_spg"
			VALUE
			0x7084E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_spg_sys
			"Cbx_ffm1_spg_sys"
			VALUE
			0x7084F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_spi_cc
			"Cbx_ffm1_spi_cc"
			VALUE
			0x70850
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_svkl
			"Cbx_ffm1_svkl"
			VALUE
			0x70851
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_swlk
			"Cbx_ffm1_swlk"
			VALUE
			0x70852
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_tco
			"Cbx_ffm1_tco"
			VALUE
			0x70853
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_thpl
			"Cbx_ffm1_thpl"
			VALUE
			0x70854
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_thr
			"Cbx_ffm1_thr"
			VALUE
			0x70855
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_thr_cmd
			"Cbx_ffm1_thr_cmd"
			VALUE
			0x70856
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_tia
			"Cbx_ffm1_tia"
			VALUE
			0x70857
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_tjy_ctl
			"Cbx_ffm1_tjy_ctl"
			VALUE
			0x70858
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_tlz_ad_b
			"Cbx_ffm1_tlz_ad_b"
			VALUE
			0x70859
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_vb
			"Cbx_ffm1_vb"
			VALUE
			0x7085A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_vs
			"Cbx_ffm1_vs"
			VALUE
			0x7085B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_vta_intake
			"Cbx_ffm1_vta_intake"
			VALUE
			0x7085C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_vvt_int
			"Cbx_ffm1_vvt_int"
			VALUE
			0x7085D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_vvt_int_ev
			"Cbx_ffm1_vvt_int_ev"
			VALUE
			0x7085E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_vvt_intake
			"Cbx_ffm1_vvt_intake"
			VALUE
			0x7085F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_vvtc_toth_3
			"Cbx_ffm1_vvtc_toth_3"
			VALUE
			0x70860
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_wat_temp
			"Cbx_ffm1_wat_temp"
			VALUE
			0x70861
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_wgc
			"Cbx_ffm1_wgc"
			VALUE
			0x70862
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm1_wpmp
			"Cbx_ffm1_wpmp"
			VALUE
			0x70863
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_ac_prs
			"Cbx_ffm2_ac_prs"
			VALUE
			0x70864
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_ac_rcpt
			"Cbx_ffm2_ac_rcpt"
			VALUE
			0x70865
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_acr
			"Cbx_ffm2_acr"
			VALUE
			0x70866
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_actr_rly
			"Cbx_ffm2_actr_rly"
			VALUE
			0x70867
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_actr_rly_cut
			"Cbx_ffm2_actr_rly_cut"
			VALUE
			0x70868
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_agb
			"Cbx_ffm2_agb"
			VALUE
			0x70869
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_air
			"Cbx_ffm2_air"
			VALUE
			0x7086A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_alt
			"Cbx_ffm2_alt"
			VALUE
			0x7086B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_alt_load_in
			"Cbx_ffm2_alt_load_in"
			VALUE
			0x7086C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_bkup_mem
			"Cbx_ffm2_bkup_mem"
			VALUE
			0x7086D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_checksum
			"Cbx_ffm2_checksum"
			VALUE
			0x7086E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_clu
			"Cbx_ffm2_clu"
			VALUE
			0x7086F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_cp
			"Cbx_ffm2_cp"
			VALUE
			0x70870
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_crk
			"Cbx_ffm2_crk"
			VALUE
			0x70871
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_crk_nr
			"Cbx_ffm2_crk_nr"
			VALUE
			0x70872
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_cru
			"Cbx_ffm2_cru"
			VALUE
			0x70873
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_el_wind_rcpt
			"Cbx_ffm2_el_wind_rcpt"
			VALUE
			0x70874
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_eng_temp
			"Cbx_ffm2_eng_temp"
			VALUE
			0x70875
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_eng_whl
			"Cbx_ffm2_eng_whl"
			VALUE
			0x70876
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_fsys
			"Cbx_ffm2_fsys"
			VALUE
			0x70877
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_fsys_lpg
			"Cbx_ffm2_fsys_lpg"
			VALUE
			0x70878
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_gas_pump
			"Cbx_ffm2_gas_pump"
			VALUE
			0x70879
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_igc_1
			"Cbx_ffm2_igc_1"
			VALUE
			0x7087A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_igc_2
			"Cbx_ffm2_igc_2"
			VALUE
			0x7087B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_igc_3
			"Cbx_ffm2_igc_3"
			VALUE
			0x7087C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_igc_4
			"Cbx_ffm2_igc_4"
			VALUE
			0x7087D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_inj1
			"Cbx_ffm2_inj1"
			VALUE
			0x7087E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_inj2
			"Cbx_ffm2_inj2"
			VALUE
			0x7087F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_inj3
			"Cbx_ffm2_inj3"
			VALUE
			0x70880
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_inj4
			"Cbx_ffm2_inj4"
			VALUE
			0x70881
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_inj_ecu
			"Cbx_ffm2_inj_ecu"
			VALUE
			0x70882
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_ip_inj_cnt
			"Cbx_ffm2_ip_inj_cnt"
			VALUE
			0x70883
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_knk
			"Cbx_ffm2_knk"
			VALUE
			0x70884
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_lbdw
			"Cbx_ffm2_lbdw"
			VALUE
			0x70885
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_lbdw_hot
			"Cbx_ffm2_lbdw_hot"
			VALUE
			0x70886
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_lbdw_pump_crt
			"Cbx_ffm2_lbdw_pump_crt"
			VALUE
			0x70887
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_lbup
			"Cbx_ffm2_lbup"
			VALUE
			0x70888
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_lbup_hot
			"Cbx_ffm2_lbup_hot"
			VALUE
			0x70889
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_lbup_pump_crt
			"Cbx_ffm2_lbup_pump_crt"
			VALUE
			0x7088A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_lpg_rcpt
			"Cbx_ffm2_lpg_rcpt"
			VALUE
			0x7088B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_map
			"Cbx_ffm2_map"
			VALUE
			0x7088C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_map_chr
			"Cbx_ffm2_map_chr"
			VALUE
			0x7088D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_mastervac
			"Cbx_ffm2_mastervac"
			VALUE
			0x7088E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_mcut_sens1
			"Cbx_ffm2_mcut_sens1"
			VALUE
			0x7088F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_mdf1
			"Cbx_ffm2_mdf1"
			VALUE
			0x70890
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_mdf2
			"Cbx_ffm2_mdf2"
			VALUE
			0x70891
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_min_gas_lvl
			"Cbx_ffm2_min_gas_lvl"
			VALUE
			0x70892
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_min_lpg_lvl
			"Cbx_ffm2_min_lpg_lvl"
			VALUE
			0x70893
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_mis_cata
			"Cbx_ffm2_mis_cata"
			VALUE
			0x70894
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_mis_cata_1
			"Cbx_ffm2_mis_cata_1"
			VALUE
			0x70895
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_mis_cata_1_lpg
			"Cbx_ffm2_mis_cata_1_lpg"
			VALUE
			0x70896
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_mis_cata_2
			"Cbx_ffm2_mis_cata_2"
			VALUE
			0x70897
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_mis_cata_2_lpg
			"Cbx_ffm2_mis_cata_2_lpg"
			VALUE
			0x70898
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_mis_cata_3
			"Cbx_ffm2_mis_cata_3"
			VALUE
			0x70899
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_mis_cata_3_lpg
			"Cbx_ffm2_mis_cata_3_lpg"
			VALUE
			0x7089A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_mis_cata_4
			"Cbx_ffm2_mis_cata_4"
			VALUE
			0x7089B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_mis_cata_4_lpg
			"Cbx_ffm2_mis_cata_4_lpg"
			VALUE
			0x7089C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_mis_cata_gas
			"Cbx_ffm2_mis_cata_gas"
			VALUE
			0x7089D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_mis_cata_lpg
			"Cbx_ffm2_mis_cata_lpg"
			VALUE
			0x7089E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_mis_fast
			"Cbx_ffm2_mis_fast"
			VALUE
			0x7089F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_mis_lih
			"Cbx_ffm2_mis_lih"
			VALUE
			0x708A0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_mis_polu
			"Cbx_ffm2_mis_polu"
			VALUE
			0x708A1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_mis_polu_1
			"Cbx_ffm2_mis_polu_1"
			VALUE
			0x708A2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_mis_polu_1_lpg
			"Cbx_ffm2_mis_polu_1_lpg"
			VALUE
			0x708A3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_mis_polu_2
			"Cbx_ffm2_mis_polu_2"
			VALUE
			0x708A4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_mis_polu_2_lpg
			"Cbx_ffm2_mis_polu_2_lpg"
			VALUE
			0x708A5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_mis_polu_3
			"Cbx_ffm2_mis_polu_3"
			VALUE
			0x708A6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_mis_polu_3_lpg
			"Cbx_ffm2_mis_polu_3_lpg"
			VALUE
			0x708A7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_mis_polu_4
			"Cbx_ffm2_mis_polu_4"
			VALUE
			0x708A8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_mis_polu_4_lpg
			"Cbx_ffm2_mis_polu_4_lpg"
			VALUE
			0x708A9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_mis_polu_gas
			"Cbx_ffm2_mis_polu_gas"
			VALUE
			0x708AA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_mis_polu_lpg
			"Cbx_ffm2_mis_polu_lpg"
			VALUE
			0x708AB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_mvac_pump
			"Cbx_ffm2_mvac_pump"
			VALUE
			0x708AC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_mvac_sys
			"Cbx_ffm2_mvac_sys"
			VALUE
			0x708AD
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_obd_cata
			"Cbx_ffm2_obd_cata"
			VALUE
			0x708AE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_obd_lamb
			"Cbx_ffm2_obd_lamb"
			VALUE
			0x708AF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_obd_sa
			"Cbx_ffm2_obd_sa"
			VALUE
			0x708B0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_oil
			"Cbx_ffm2_oil"
			VALUE
			0x708B1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_pdl
			"Cbx_ffm2_pdl"
			VALUE
			0x708B2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_pmh
			"Cbx_ffm2_pmh"
			VALUE
			0x708B3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_pow_lbdw
			"Cbx_ffm2_pow_lbdw"
			VALUE
			0x708B4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_pow_lbup
			"Cbx_ffm2_pow_lbup"
			VALUE
			0x708B5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_ptc
			"Cbx_ffm2_ptc"
			VALUE
			0x708B6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_ptc_rov
			"Cbx_ffm2_ptc_rov"
			VALUE
			0x708B7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_pws
			"Cbx_ffm2_pws"
			VALUE
			0x708B8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_rams
			"Cbx_ffm2_rams"
			VALUE
			0x708B9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_rams_pdl
			"Cbx_ffm2_rams_pdl"
			VALUE
			0x708BA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_reserve_3
			"Cbx_ffm2_reserve_3"
			VALUE
			0x708BB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_rmc
			"Cbx_ffm2_rmc"
			VALUE
			0x708BC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_sa
			"Cbx_ffm2_sa"
			VALUE
			0x708BD
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_sa_ev
			"Cbx_ffm2_sa_ev"
			VALUE
			0x708BE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_spg
			"Cbx_ffm2_spg"
			VALUE
			0x708BF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_spg_sys
			"Cbx_ffm2_spg_sys"
			VALUE
			0x708C0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_spi_cc
			"Cbx_ffm2_spi_cc"
			VALUE
			0x708C1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_svkl
			"Cbx_ffm2_svkl"
			VALUE
			0x708C2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_swlk
			"Cbx_ffm2_swlk"
			VALUE
			0x708C3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_tco
			"Cbx_ffm2_tco"
			VALUE
			0x708C4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_thpl
			"Cbx_ffm2_thpl"
			VALUE
			0x708C5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_thr
			"Cbx_ffm2_thr"
			VALUE
			0x708C6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_thr_cmd
			"Cbx_ffm2_thr_cmd"
			VALUE
			0x708C7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_tia
			"Cbx_ffm2_tia"
			VALUE
			0x708C8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_tjy_ctl
			"Cbx_ffm2_tjy_ctl"
			VALUE
			0x708C9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_tlz_ad_b
			"Cbx_ffm2_tlz_ad_b"
			VALUE
			0x708CA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_vb
			"Cbx_ffm2_vb"
			VALUE
			0x708CB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_vs
			"Cbx_ffm2_vs"
			VALUE
			0x708CC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_vta_intake
			"Cbx_ffm2_vta_intake"
			VALUE
			0x708CD
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_vvt_int
			"Cbx_ffm2_vvt_int"
			VALUE
			0x708CE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_vvt_int_ev
			"Cbx_ffm2_vvt_int_ev"
			VALUE
			0x708CF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_vvt_intake
			"Cbx_ffm2_vvt_intake"
			VALUE
			0x708D0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_vvtc_toth_3
			"Cbx_ffm2_vvtc_toth_3"
			VALUE
			0x708D1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_wat_temp
			"Cbx_ffm2_wat_temp"
			VALUE
			0x708D2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_wgc
			"Cbx_ffm2_wgc"
			VALUE
			0x708D3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ffm2_wpmp
			"Cbx_ffm2_wpmp"
			VALUE
			0x708D4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fl_kd_thr_conf
			"Cbx_fl_kd_thr_conf"
			VALUE
			0x74872
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_ac_prs_pf
			"Cbx_fsys_ac_prs_pf"
			VALUE
			0x702CC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_ac_rcpt_pf
			"Cbx_fsys_ac_rcpt_pf"
			VALUE
			0x702CD
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_acr_pf
			"Cbx_fsys_acr_pf"
			VALUE
			0x702CE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_actr_rly_cut_pf
			"Cbx_fsys_actr_rly_cut_pf"
			VALUE
			0x702D0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_actr_rly_pf
			"Cbx_fsys_actr_rly_pf"
			VALUE
			0x702CF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_agb_pf
			"Cbx_fsys_agb_pf"
			VALUE
			0x702D1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_agb_rcpt_mfo
			"Cbx_fsys_agb_rcpt_mfo"
			VALUE
			0x70766
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_agb_rcpt_vf
			"Cbx_fsys_agb_rcpt_vf"
			VALUE
			0x7054E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_air_mfo
			"Cbx_fsys_air_mfo"
			VALUE
			0x70767
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_air_pf
			"Cbx_fsys_air_pf"
			VALUE
			0x702D2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_air_vf
			"Cbx_fsys_air_vf"
			VALUE
			0x7054F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_alt_load_in_pf
			"Cbx_fsys_alt_load_in_pf"
			VALUE
			0x702D4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_alt_pf
			"Cbx_fsys_alt_pf"
			VALUE
			0x702D3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_bkup_mem_mfo
			"Cbx_fsys_bkup_mem_mfo"
			VALUE
			0x70768
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_bkup_mem_pf
			"Cbx_fsys_bkup_mem_pf"
			VALUE
			0x702D5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_bkup_mem_vf
			"Cbx_fsys_bkup_mem_vf"
			VALUE
			0x70550
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_checksum_pf
			"Cbx_fsys_checksum_pf"
			VALUE
			0x702D6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_clu_mfo
			"Cbx_fsys_clu_mfo"
			VALUE
			0x70769
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_clu_pf
			"Cbx_fsys_clu_pf"
			VALUE
			0x702D7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_clu_vf
			"Cbx_fsys_clu_vf"
			VALUE
			0x70551
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_cp_mfo
			"Cbx_fsys_cp_mfo"
			VALUE
			0x70665
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_cp_pf
			"Cbx_fsys_cp_pf"
			VALUE
			0x702D8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_cp_vf
			"Cbx_fsys_cp_vf"
			VALUE
			0x70537
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_crk_mfo
			"Cbx_fsys_crk_mfo"
			VALUE
			0x7076A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_crk_nr_mfo
			"Cbx_fsys_crk_nr_mfo"
			VALUE
			0x7076B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_crk_nr_pf
			"Cbx_fsys_crk_nr_pf"
			VALUE
			0x702DA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_crk_nr_vf
			"Cbx_fsys_crk_nr_vf"
			VALUE
			0x70553
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_crk_pf
			"Cbx_fsys_crk_pf"
			VALUE
			0x702D9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_crk_vf
			"Cbx_fsys_crk_vf"
			VALUE
			0x70552
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_cru_pf
			"Cbx_fsys_cru_pf"
			VALUE
			0x702DB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_el_wind_rcpt_pf
			"Cbx_fsys_el_wind_rcpt_pf"
			VALUE
			0x702DC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_eng_temp_pf
			"Cbx_fsys_eng_temp_pf"
			VALUE
			0x702DD
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_eng_whl_mfo
			"Cbx_fsys_eng_whl_mfo"
			VALUE
			0x7076C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_eng_whl_pf
			"Cbx_fsys_eng_whl_pf"
			VALUE
			0x702DE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_eng_whl_vf
			"Cbx_fsys_eng_whl_vf"
			VALUE
			0x70554
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_fsys_lpg_mfo
			"Cbx_fsys_fsys_lpg_mfo"
			VALUE
			0x7076E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_fsys_lpg_pf
			"Cbx_fsys_fsys_lpg_pf"
			VALUE
			0x702E0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_fsys_lpg_vf
			"Cbx_fsys_fsys_lpg_vf"
			VALUE
			0x70556
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_fsys_mfo
			"Cbx_fsys_fsys_mfo"
			VALUE
			0x7076D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_fsys_pf
			"Cbx_fsys_fsys_pf"
			VALUE
			0x702DF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_fsys_vf
			"Cbx_fsys_fsys_vf"
			VALUE
			0x70555
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_gas_pump_mfo
			"Cbx_fsys_gas_pump_mfo"
			VALUE
			0x70666
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_gas_pump_pf
			"Cbx_fsys_gas_pump_pf"
			VALUE
			0x702E1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_gas_pump_vf
			"Cbx_fsys_gas_pump_vf"
			VALUE
			0x70538
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_igc_1_mfo
			"Cbx_fsys_igc_1_mfo"
			VALUE
			0x70667
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_igc_1_pf
			"Cbx_fsys_igc_1_pf"
			VALUE
			0x702E2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_igc_1_vf
			"Cbx_fsys_igc_1_vf"
			VALUE
			0x70539
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_igc_2_mfo
			"Cbx_fsys_igc_2_mfo"
			VALUE
			0x70668
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_igc_2_pf
			"Cbx_fsys_igc_2_pf"
			VALUE
			0x702E3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_igc_2_vf
			"Cbx_fsys_igc_2_vf"
			VALUE
			0x7053A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_igc_3_mfo
			"Cbx_fsys_igc_3_mfo"
			VALUE
			0x70669
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_igc_3_pf
			"Cbx_fsys_igc_3_pf"
			VALUE
			0x702E4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_igc_3_vf
			"Cbx_fsys_igc_3_vf"
			VALUE
			0x7053B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_igc_4_mfo
			"Cbx_fsys_igc_4_mfo"
			VALUE
			0x7066A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_igc_4_pf
			"Cbx_fsys_igc_4_pf"
			VALUE
			0x702E5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_igc_4_vf
			"Cbx_fsys_igc_4_vf"
			VALUE
			0x7053C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_inj1_mfo
			"Cbx_fsys_inj1_mfo"
			VALUE
			0x7066B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_inj1_pf
			"Cbx_fsys_inj1_pf"
			VALUE
			0x702E6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_inj1_vf
			"Cbx_fsys_inj1_vf"
			VALUE
			0x7053D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_inj2_mfo
			"Cbx_fsys_inj2_mfo"
			VALUE
			0x7066C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_inj2_pf
			"Cbx_fsys_inj2_pf"
			VALUE
			0x702E7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_inj2_vf
			"Cbx_fsys_inj2_vf"
			VALUE
			0x7053E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_inj3_mfo
			"Cbx_fsys_inj3_mfo"
			VALUE
			0x7066D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_inj3_pf
			"Cbx_fsys_inj3_pf"
			VALUE
			0x702E8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_inj3_vf
			"Cbx_fsys_inj3_vf"
			VALUE
			0x7053F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_inj4_mfo
			"Cbx_fsys_inj4_mfo"
			VALUE
			0x7066E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_inj4_pf
			"Cbx_fsys_inj4_pf"
			VALUE
			0x702E9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_inj4_vf
			"Cbx_fsys_inj4_vf"
			VALUE
			0x70540
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_inj_ecu_mfo
			"Cbx_fsys_inj_ecu_mfo"
			VALUE
			0x7076F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_inj_ecu_pf
			"Cbx_fsys_inj_ecu_pf"
			VALUE
			0x702EA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_inj_ecu_vf
			"Cbx_fsys_inj_ecu_vf"
			VALUE
			0x70557
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_ip_inj_cnt_pf
			"Cbx_fsys_ip_inj_cnt_pf"
			VALUE
			0x702EB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_knk_mfo
			"Cbx_fsys_knk_mfo"
			VALUE
			0x70770
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_knk_pf
			"Cbx_fsys_knk_pf"
			VALUE
			0x702EC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_knk_vf
			"Cbx_fsys_knk_vf"
			VALUE
			0x70558
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_lbdw_hot_mfo
			"Cbx_fsys_lbdw_hot_mfo"
			VALUE
			0x70670
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_lbdw_hot_pf
			"Cbx_fsys_lbdw_hot_pf"
			VALUE
			0x702EE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_lbdw_hot_vf
			"Cbx_fsys_lbdw_hot_vf"
			VALUE
			0x70542
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_lbdw_mfo
			"Cbx_fsys_lbdw_mfo"
			VALUE
			0x7066F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_lbdw_pf
			"Cbx_fsys_lbdw_pf"
			VALUE
			0x702ED
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_lbdw_pump_crt_pf
			"Cbx_fsys_lbdw_pump_crt_pf"
			VALUE
			0x702EF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_lbdw_vf
			"Cbx_fsys_lbdw_vf"
			VALUE
			0x70541
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_lbup_hot_mfo
			"Cbx_fsys_lbup_hot_mfo"
			VALUE
			0x70672
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_lbup_hot_pf
			"Cbx_fsys_lbup_hot_pf"
			VALUE
			0x702F1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_lbup_hot_vf
			"Cbx_fsys_lbup_hot_vf"
			VALUE
			0x70544
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_lbup_mfo
			"Cbx_fsys_lbup_mfo"
			VALUE
			0x70671
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_lbup_pf
			"Cbx_fsys_lbup_pf"
			VALUE
			0x702F0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_lbup_pump_crt_pf
			"Cbx_fsys_lbup_pump_crt_pf"
			VALUE
			0x702F2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_lbup_vf
			"Cbx_fsys_lbup_vf"
			VALUE
			0x70543
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_lpg_rcpt_mfo
			"Cbx_fsys_lpg_rcpt_mfo"
			VALUE
			0x70771
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_lpg_rcpt_pf
			"Cbx_fsys_lpg_rcpt_pf"
			VALUE
			0x702F3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_lpg_rcpt_vf
			"Cbx_fsys_lpg_rcpt_vf"
			VALUE
			0x70559
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_map_chr_pf
			"Cbx_fsys_map_chr_pf"
			VALUE
			0x702F5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_map_mfo
			"Cbx_fsys_map_mfo"
			VALUE
			0x70772
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_map_pf
			"Cbx_fsys_map_pf"
			VALUE
			0x702F4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_map_vf
			"Cbx_fsys_map_vf"
			VALUE
			0x7055A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mastervac_pf
			"Cbx_fsys_mastervac_pf"
			VALUE
			0x702F6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mcut_sens1_pf
			"Cbx_fsys_mcut_sens1_pf"
			VALUE
			0x702F7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mdf1_pf
			"Cbx_fsys_mdf1_pf"
			VALUE
			0x702F8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mdf2_pf
			"Cbx_fsys_mdf2_pf"
			VALUE
			0x702F9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_min_gas_lvl_mfo
			"Cbx_fsys_min_gas_lvl_mfo"
			VALUE
			0x70773
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_min_gas_lvl_pf
			"Cbx_fsys_min_gas_lvl_pf"
			VALUE
			0x702FA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_min_gas_lvl_vf
			"Cbx_fsys_min_gas_lvl_vf"
			VALUE
			0x7055B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_min_lpg_lvl_pf
			"Cbx_fsys_min_lpg_lvl_pf"
			VALUE
			0x702FB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_cata_1_lpg_mfo
			"Cbx_fsys_mis_cata_1_lpg_mfo"
			VALUE
			0x70776
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_cata_1_lpg_pf
			"Cbx_fsys_mis_cata_1_lpg_pf"
			VALUE
			0x702FE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_cata_1_lpg_vf
			"Cbx_fsys_mis_cata_1_lpg_vf"
			VALUE
			0x7055E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_cata_1_mfo
			"Cbx_fsys_mis_cata_1_mfo"
			VALUE
			0x70775
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_cata_1_pf
			"Cbx_fsys_mis_cata_1_pf"
			VALUE
			0x702FD
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_cata_1_vf
			"Cbx_fsys_mis_cata_1_vf"
			VALUE
			0x7055D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_cata_2_lpg_mfo
			"Cbx_fsys_mis_cata_2_lpg_mfo"
			VALUE
			0x70778
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_cata_2_lpg_pf
			"Cbx_fsys_mis_cata_2_lpg_pf"
			VALUE
			0x70300
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_cata_2_lpg_vf
			"Cbx_fsys_mis_cata_2_lpg_vf"
			VALUE
			0x70560
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_cata_2_mfo
			"Cbx_fsys_mis_cata_2_mfo"
			VALUE
			0x70777
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_cata_2_pf
			"Cbx_fsys_mis_cata_2_pf"
			VALUE
			0x702FF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_cata_2_vf
			"Cbx_fsys_mis_cata_2_vf"
			VALUE
			0x7055F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_cata_3_lpg_mfo
			"Cbx_fsys_mis_cata_3_lpg_mfo"
			VALUE
			0x7077A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_cata_3_lpg_pf
			"Cbx_fsys_mis_cata_3_lpg_pf"
			VALUE
			0x70302
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_cata_3_lpg_vf
			"Cbx_fsys_mis_cata_3_lpg_vf"
			VALUE
			0x70562
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_cata_3_mfo
			"Cbx_fsys_mis_cata_3_mfo"
			VALUE
			0x70779
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_cata_3_pf
			"Cbx_fsys_mis_cata_3_pf"
			VALUE
			0x70301
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_cata_3_vf
			"Cbx_fsys_mis_cata_3_vf"
			VALUE
			0x70561
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_cata_4_lpg_mfo
			"Cbx_fsys_mis_cata_4_lpg_mfo"
			VALUE
			0x7077C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_cata_4_lpg_pf
			"Cbx_fsys_mis_cata_4_lpg_pf"
			VALUE
			0x70304
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_cata_4_lpg_vf
			"Cbx_fsys_mis_cata_4_lpg_vf"
			VALUE
			0x70564
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_cata_4_mfo
			"Cbx_fsys_mis_cata_4_mfo"
			VALUE
			0x7077B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_cata_4_pf
			"Cbx_fsys_mis_cata_4_pf"
			VALUE
			0x70303
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_cata_4_vf
			"Cbx_fsys_mis_cata_4_vf"
			VALUE
			0x70563
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_cata_gas_mfo
			"Cbx_fsys_mis_cata_gas_mfo"
			VALUE
			0x7077D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_cata_gas_pf
			"Cbx_fsys_mis_cata_gas_pf"
			VALUE
			0x70305
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_cata_gas_vf
			"Cbx_fsys_mis_cata_gas_vf"
			VALUE
			0x70565
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_cata_lpg_mfo
			"Cbx_fsys_mis_cata_lpg_mfo"
			VALUE
			0x7077E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_cata_lpg_pf
			"Cbx_fsys_mis_cata_lpg_pf"
			VALUE
			0x70306
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_cata_lpg_vf
			"Cbx_fsys_mis_cata_lpg_vf"
			VALUE
			0x70566
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_cata_mfo
			"Cbx_fsys_mis_cata_mfo"
			VALUE
			0x70774
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_cata_pf
			"Cbx_fsys_mis_cata_pf"
			VALUE
			0x702FC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_cata_vf
			"Cbx_fsys_mis_cata_vf"
			VALUE
			0x7055C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_fast_pf
			"Cbx_fsys_mis_fast_pf"
			VALUE
			0x70307
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_lih_pf
			"Cbx_fsys_mis_lih_pf"
			VALUE
			0x70308
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_polu_1_lpg_mfo
			"Cbx_fsys_mis_polu_1_lpg_mfo"
			VALUE
			0x70781
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_polu_1_lpg_pf
			"Cbx_fsys_mis_polu_1_lpg_pf"
			VALUE
			0x7030B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_polu_1_lpg_vf
			"Cbx_fsys_mis_polu_1_lpg_vf"
			VALUE
			0x70569
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_polu_1_mfo
			"Cbx_fsys_mis_polu_1_mfo"
			VALUE
			0x70780
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_polu_1_pf
			"Cbx_fsys_mis_polu_1_pf"
			VALUE
			0x7030A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_polu_1_vf
			"Cbx_fsys_mis_polu_1_vf"
			VALUE
			0x70568
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_polu_2_lpg_mfo
			"Cbx_fsys_mis_polu_2_lpg_mfo"
			VALUE
			0x70783
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_polu_2_lpg_pf
			"Cbx_fsys_mis_polu_2_lpg_pf"
			VALUE
			0x7030D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_polu_2_lpg_vf
			"Cbx_fsys_mis_polu_2_lpg_vf"
			VALUE
			0x7056B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_polu_2_mfo
			"Cbx_fsys_mis_polu_2_mfo"
			VALUE
			0x70782
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_polu_2_pf
			"Cbx_fsys_mis_polu_2_pf"
			VALUE
			0x7030C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_polu_2_vf
			"Cbx_fsys_mis_polu_2_vf"
			VALUE
			0x7056A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_polu_3_lpg_mfo
			"Cbx_fsys_mis_polu_3_lpg_mfo"
			VALUE
			0x70785
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_polu_3_lpg_pf
			"Cbx_fsys_mis_polu_3_lpg_pf"
			VALUE
			0x7030F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_polu_3_lpg_vf
			"Cbx_fsys_mis_polu_3_lpg_vf"
			VALUE
			0x7056D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_polu_3_mfo
			"Cbx_fsys_mis_polu_3_mfo"
			VALUE
			0x70784
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_polu_3_pf
			"Cbx_fsys_mis_polu_3_pf"
			VALUE
			0x7030E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_polu_3_vf
			"Cbx_fsys_mis_polu_3_vf"
			VALUE
			0x7056C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_polu_4_lpg_mfo
			"Cbx_fsys_mis_polu_4_lpg_mfo"
			VALUE
			0x70787
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_polu_4_lpg_pf
			"Cbx_fsys_mis_polu_4_lpg_pf"
			VALUE
			0x70311
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_polu_4_lpg_vf
			"Cbx_fsys_mis_polu_4_lpg_vf"
			VALUE
			0x7056F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_polu_4_mfo
			"Cbx_fsys_mis_polu_4_mfo"
			VALUE
			0x70786
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_polu_4_pf
			"Cbx_fsys_mis_polu_4_pf"
			VALUE
			0x70310
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_polu_4_vf
			"Cbx_fsys_mis_polu_4_vf"
			VALUE
			0x7056E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_polu_gas_mfo
			"Cbx_fsys_mis_polu_gas_mfo"
			VALUE
			0x70788
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_polu_gas_pf
			"Cbx_fsys_mis_polu_gas_pf"
			VALUE
			0x70312
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_polu_gas_vf
			"Cbx_fsys_mis_polu_gas_vf"
			VALUE
			0x70570
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_polu_lpg_mfo
			"Cbx_fsys_mis_polu_lpg_mfo"
			VALUE
			0x70789
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_polu_lpg_pf
			"Cbx_fsys_mis_polu_lpg_pf"
			VALUE
			0x70313
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_polu_lpg_vf
			"Cbx_fsys_mis_polu_lpg_vf"
			VALUE
			0x70571
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_polu_mfo
			"Cbx_fsys_mis_polu_mfo"
			VALUE
			0x7077F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_polu_pf
			"Cbx_fsys_mis_polu_pf"
			VALUE
			0x70309
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mis_polu_vf
			"Cbx_fsys_mis_polu_vf"
			VALUE
			0x70567
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mvac_pump_pf
			"Cbx_fsys_mvac_pump_pf"
			VALUE
			0x70314
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_mvac_sys_pf
			"Cbx_fsys_mvac_sys_pf"
			VALUE
			0x70315
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_obd_cata_mfo
			"Cbx_fsys_obd_cata_mfo"
			VALUE
			0x7078A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_obd_cata_pf
			"Cbx_fsys_obd_cata_pf"
			VALUE
			0x70316
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_obd_cata_vf
			"Cbx_fsys_obd_cata_vf"
			VALUE
			0x70572
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_obd_lamb_mfo
			"Cbx_fsys_obd_lamb_mfo"
			VALUE
			0x7078B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_obd_lamb_pf
			"Cbx_fsys_obd_lamb_pf"
			VALUE
			0x70317
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_obd_lamb_vf
			"Cbx_fsys_obd_lamb_vf"
			VALUE
			0x70573
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_obd_sa_mfo
			"Cbx_fsys_obd_sa_mfo"
			VALUE
			0x7078C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_obd_sa_pf
			"Cbx_fsys_obd_sa_pf"
			VALUE
			0x70318
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_obd_sa_vf
			"Cbx_fsys_obd_sa_vf"
			VALUE
			0x70574
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_oil_pf
			"Cbx_fsys_oil_pf"
			VALUE
			0x70319
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_pdl_pf
			"Cbx_fsys_pdl_pf"
			VALUE
			0x7031A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_pmh_pf
			"Cbx_fsys_pmh_pf"
			VALUE
			0x7031B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_pow_lbdw_mfo
			"Cbx_fsys_pow_lbdw_mfo"
			VALUE
			0x7078D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_pow_lbdw_pf
			"Cbx_fsys_pow_lbdw_pf"
			VALUE
			0x7031C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_pow_lbdw_vf
			"Cbx_fsys_pow_lbdw_vf"
			VALUE
			0x70575
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_pow_lbup_mfo
			"Cbx_fsys_pow_lbup_mfo"
			VALUE
			0x7078E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_pow_lbup_pf
			"Cbx_fsys_pow_lbup_pf"
			VALUE
			0x7031D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_pow_lbup_vf
			"Cbx_fsys_pow_lbup_vf"
			VALUE
			0x70576
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_ptc_pf
			"Cbx_fsys_ptc_pf"
			VALUE
			0x7031E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_ptc_rov_pf
			"Cbx_fsys_ptc_rov_pf"
			VALUE
			0x7031F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_pws_pf
			"Cbx_fsys_pws_pf"
			VALUE
			0x70320
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_rams_pdl_mfo
			"Cbx_fsys_rams_pdl_mfo"
			VALUE
			0x7078F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_rams_pdl_pf
			"Cbx_fsys_rams_pdl_pf"
			VALUE
			0x70322
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_rams_pdl_vf
			"Cbx_fsys_rams_pdl_vf"
			VALUE
			0x70577
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_rams_pf
			"Cbx_fsys_rams_pf"
			VALUE
			0x70321
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_reserve_3_pf
			"Cbx_fsys_reserve_3_pf"
			VALUE
			0x70323
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_rmc_pf
			"Cbx_fsys_rmc_pf"
			VALUE
			0x70324
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_sa_ev_mfo
			"Cbx_fsys_sa_ev_mfo"
			VALUE
			0x70674
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_sa_ev_pf
			"Cbx_fsys_sa_ev_pf"
			VALUE
			0x70326
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_sa_ev_vf
			"Cbx_fsys_sa_ev_vf"
			VALUE
			0x70546
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_sa_mfo
			"Cbx_fsys_sa_mfo"
			VALUE
			0x70673
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_sa_pf
			"Cbx_fsys_sa_pf"
			VALUE
			0x70325
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_sa_vf
			"Cbx_fsys_sa_vf"
			VALUE
			0x70545
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_spg_mfo
			"Cbx_fsys_spg_mfo"
			VALUE
			0x70790
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_spg_pf
			"Cbx_fsys_spg_pf"
			VALUE
			0x70327
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_spg_sys_mfo
			"Cbx_fsys_spg_sys_mfo"
			VALUE
			0x70791
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_spg_sys_pf
			"Cbx_fsys_spg_sys_pf"
			VALUE
			0x70328
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_spg_sys_vf
			"Cbx_fsys_spg_sys_vf"
			VALUE
			0x70579
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_spg_vf
			"Cbx_fsys_spg_vf"
			VALUE
			0x70578
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_spi_cc_pf
			"Cbx_fsys_spi_cc_pf"
			VALUE
			0x70329
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_svkl_pf
			"Cbx_fsys_svkl_pf"
			VALUE
			0x7032A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_swlk_pf
			"Cbx_fsys_swlk_pf"
			VALUE
			0x7032B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_tco_mfo
			"Cbx_fsys_tco_mfo"
			VALUE
			0x70675
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_tco_pf
			"Cbx_fsys_tco_pf"
			VALUE
			0x7032C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_tco_vf
			"Cbx_fsys_tco_vf"
			VALUE
			0x70547
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_thpl_pf
			"Cbx_fsys_thpl_pf"
			VALUE
			0x7032D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_thr_cmd_pf
			"Cbx_fsys_thr_cmd_pf"
			VALUE
			0x7032F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_thr_pf
			"Cbx_fsys_thr_pf"
			VALUE
			0x7032E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_tia_mfo
			"Cbx_fsys_tia_mfo"
			VALUE
			0x70676
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_tia_pf
			"Cbx_fsys_tia_pf"
			VALUE
			0x70330
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_tia_vf
			"Cbx_fsys_tia_vf"
			VALUE
			0x70548
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_tjy_ctl_pf
			"Cbx_fsys_tjy_ctl_pf"
			VALUE
			0x70331
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_tlz_ad_b_mfo
			"Cbx_fsys_tlz_ad_b_mfo"
			VALUE
			0x70792
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_tlz_ad_b_pf
			"Cbx_fsys_tlz_ad_b_pf"
			VALUE
			0x70332
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_tlz_ad_b_vf
			"Cbx_fsys_tlz_ad_b_vf"
			VALUE
			0x7057A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_vb_pf
			"Cbx_fsys_vb_pf"
			VALUE
			0x70333
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_vs_mfo
			"Cbx_fsys_vs_mfo"
			VALUE
			0x70677
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_vs_pf
			"Cbx_fsys_vs_pf"
			VALUE
			0x70334
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_vs_vf
			"Cbx_fsys_vs_vf"
			VALUE
			0x70549
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_vta_intake_mfo
			"Cbx_fsys_vta_intake_mfo"
			VALUE
			0x70678
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_vta_intake_pf
			"Cbx_fsys_vta_intake_pf"
			VALUE
			0x70335
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_vta_intake_vf
			"Cbx_fsys_vta_intake_vf"
			VALUE
			0x7054A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_vvt_int_ev_mfo
			"Cbx_fsys_vvt_int_ev_mfo"
			VALUE
			0x70679
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_vvt_int_ev_pf
			"Cbx_fsys_vvt_int_ev_pf"
			VALUE
			0x70337
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_vvt_int_ev_vf
			"Cbx_fsys_vvt_int_ev_vf"
			VALUE
			0x7054B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_vvt_int_old_off_mfo
			"Cbx_fsys_vvt_int_old_off_mfo"
			VALUE
			0x70793
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_vvt_int_old_off_vf
			"Cbx_fsys_vvt_int_old_off_vf"
			VALUE
			0x7057B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_vvt_int_pf
			"Cbx_fsys_vvt_int_pf"
			VALUE
			0x70336
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_vvt_intake_mfo
			"Cbx_fsys_vvt_intake_mfo"
			VALUE
			0x7067A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_vvt_intake_pf
			"Cbx_fsys_vvt_intake_pf"
			VALUE
			0x70338
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_vvt_intake_vf
			"Cbx_fsys_vvt_intake_vf"
			VALUE
			0x7054C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_vvtc_toth_3_mfo
			"Cbx_fsys_vvtc_toth_3_mfo"
			VALUE
			0x70794
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_vvtc_toth_3_pf
			"Cbx_fsys_vvtc_toth_3_pf"
			VALUE
			0x70339
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_vvtc_toth_3_vf
			"Cbx_fsys_vvtc_toth_3_vf"
			VALUE
			0x7057C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_wat_temp_pf
			"Cbx_fsys_wat_temp_pf"
			VALUE
			0x7033A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_wgc_mfo
			"Cbx_fsys_wgc_mfo"
			VALUE
			0x7067B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_wgc_pf
			"Cbx_fsys_wgc_pf"
			VALUE
			0x7033B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_wgc_vf
			"Cbx_fsys_wgc_vf"
			VALUE
			0x7054D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fsys_wpmp_pf
			"Cbx_fsys_wpmp_pf"
			VALUE
			0x7033C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_fuel_conf
			"Cbx_fuel_conf"
			VALUE
			0x71E98
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_h_thr_conf
			"Cbx_h_thr_conf"
			VALUE
			0x790F3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_iga_bch_mod
			"Cbx_iga_bch_mod"
			VALUE
			0x73C1C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_iga_ofs_dsb
			"Cbx_iga_ofs_dsb"
			VALUE
			0x73C1D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_igc_1_4_diag_dsb
			"Cbx_igc_1_4_diag_dsb"
			VALUE
			0x71DF1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_igc_2_3_diag_dsb
			"Cbx_igc_2_3_diag_dsb"
			VALUE
			0x71DF2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_inj_clos_angl_bch
			"Cbx_inj_clos_angl_bch"
			VALUE
			0x74873
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_inj_srs1_dsb_0
			"Cbx_inj_srs1_dsb_0"
			VALUE
			0x736B8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_inj_srs1_dsb_1
			"Cbx_inj_srs1_dsb_1"
			VALUE
			0x736B9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_inj_srs1_dsb_2
			"Cbx_inj_srs1_dsb_2"
			VALUE
			0x736BA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_inj_srs1_dsb_3
			"Cbx_inj_srs1_dsb_3"
			VALUE
			0x736BB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_inj_srs1_dsb_4
			"Cbx_inj_srs1_dsb_4"
			VALUE
			0x736BC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_inj_srs1_dsb_5
			"Cbx_inj_srs1_dsb_5"
			VALUE
			0x736BD
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_inj_srs1_dsb_vvtc_0
			"Cbx_inj_srs1_dsb_vvtc_0"
			VALUE
			0x736BE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_inj_srs1_dsb_vvtc_1
			"Cbx_inj_srs1_dsb_vvtc_1"
			VALUE
			0x736BF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_inj_srs2_dsb_0
			"Cbx_inj_srs2_dsb_0"
			VALUE
			0x736C0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_inj_srs2_dsb_1
			"Cbx_inj_srs2_dsb_1"
			VALUE
			0x736C1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_inj_srs2_dsb_2
			"Cbx_inj_srs2_dsb_2"
			VALUE
			0x736C2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_inj_srs2_dsb_3
			"Cbx_inj_srs2_dsb_3"
			VALUE
			0x736C3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_inj_srs2_dsb_4
			"Cbx_inj_srs2_dsb_4"
			VALUE
			0x736C4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_inj_srs2_dsb_5
			"Cbx_inj_srs2_dsb_5"
			VALUE
			0x736C5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_inj_srs2_dsb_vvtc_0
			"Cbx_inj_srs2_dsb_vvtc_0"
			VALUE
			0x736C6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_inj_srs2_dsb_vvtc_1
			"Cbx_inj_srs2_dsb_vvtc_1"
			VALUE
			0x736C7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_inv_dyn_cor_vvt_dsb
			"Cbx_inv_dyn_cor_vvt_dsb"
			VALUE
			0x790F4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ip_can_oil_cge_intv
			"Cbx_ip_can_oil_cge_intv"
			VALUE
			0x71E99
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_is_ad_mdf_conf
			"Cbx_is_ad_mdf_conf"
			VALUE
			0x7386B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_is_alt_conf
			"Cbx_is_alt_conf"
			VALUE
			0x7386C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_is_dft_ini_req
			"Cbx_is_dft_ini_req"
			VALUE
			0x73199
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_is_ini_req
			"Cbx_is_ini_req"
			VALUE
			0x7319A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_is_min_ad_pwm_req
			"Cbx_is_min_ad_pwm_req"
			VALUE
			0x7319B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_is_min_ad_pwm_set
			"Cbx_is_min_ad_pwm_set"
			VALUE
			0x7386D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_kd_rich_cor_prs_conf
			"Cbx_kd_rich_cor_prs_conf"
			VALUE
			0x74874
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_knk_ad_dsb
			"Cbx_knk_ad_dsb"
			VALUE
			0x721A9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_knk_dft_ini_req
			"Cbx_knk_dft_ini_req"
			VALUE
			0x7319C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_knk_out_tq_cor
			"Cbx_knk_out_tq_cor"
			VALUE
			0x790F5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_l_pwl_conf
			"Cbx_l_pwl_conf"
			VALUE
			0x78D54
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_ac_prs_pf
			"Cbx_lamb_ac_prs_pf"
			VALUE
			0x70108
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_ac_rcpt_pf
			"Cbx_lamb_ac_rcpt_pf"
			VALUE
			0x70109
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_acr_pf
			"Cbx_lamb_acr_pf"
			VALUE
			0x7010A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_actr_rly_cut_pf
			"Cbx_lamb_actr_rly_cut_pf"
			VALUE
			0x7010C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_actr_rly_pf
			"Cbx_lamb_actr_rly_pf"
			VALUE
			0x7010B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_agb_pf
			"Cbx_lamb_agb_pf"
			VALUE
			0x7010D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_agb_rcpt_mfo
			"Cbx_lamb_agb_rcpt_mfo"
			VALUE
			0x706AA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_agb_rcpt_vf
			"Cbx_lamb_agb_rcpt_vf"
			VALUE
			0x70436
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_air_mfo
			"Cbx_lamb_air_mfo"
			VALUE
			0x706AB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_air_pf
			"Cbx_lamb_air_pf"
			VALUE
			0x7010E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_air_vf
			"Cbx_lamb_air_vf"
			VALUE
			0x70437
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_alt_load_in_pf
			"Cbx_lamb_alt_load_in_pf"
			VALUE
			0x70110
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_alt_pf
			"Cbx_lamb_alt_pf"
			VALUE
			0x7010F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_bkup_mem_mfo
			"Cbx_lamb_bkup_mem_mfo"
			VALUE
			0x706AC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_bkup_mem_pf
			"Cbx_lamb_bkup_mem_pf"
			VALUE
			0x70111
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_bkup_mem_vf
			"Cbx_lamb_bkup_mem_vf"
			VALUE
			0x70438
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_checksum_pf
			"Cbx_lamb_checksum_pf"
			VALUE
			0x70112
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_clu_mfo
			"Cbx_lamb_clu_mfo"
			VALUE
			0x706AD
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_clu_pf
			"Cbx_lamb_clu_pf"
			VALUE
			0x70113
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_clu_vf
			"Cbx_lamb_clu_vf"
			VALUE
			0x70439
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_cp_mfo
			"Cbx_lamb_cp_mfo"
			VALUE
			0x70609
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_cp_pf
			"Cbx_lamb_cp_pf"
			VALUE
			0x70114
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_cp_vf
			"Cbx_lamb_cp_vf"
			VALUE
			0x7041F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_crk_mfo
			"Cbx_lamb_crk_mfo"
			VALUE
			0x706AE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_crk_nr_mfo
			"Cbx_lamb_crk_nr_mfo"
			VALUE
			0x706AF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_crk_nr_pf
			"Cbx_lamb_crk_nr_pf"
			VALUE
			0x70116
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_crk_nr_vf
			"Cbx_lamb_crk_nr_vf"
			VALUE
			0x7043B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_crk_pf
			"Cbx_lamb_crk_pf"
			VALUE
			0x70115
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_crk_vf
			"Cbx_lamb_crk_vf"
			VALUE
			0x7043A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_cru_pf
			"Cbx_lamb_cru_pf"
			VALUE
			0x70117
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_el_wind_rcpt_pf
			"Cbx_lamb_el_wind_rcpt_pf"
			VALUE
			0x70118
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_eng_temp_pf
			"Cbx_lamb_eng_temp_pf"
			VALUE
			0x70119
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_eng_whl_mfo
			"Cbx_lamb_eng_whl_mfo"
			VALUE
			0x706B0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_eng_whl_pf
			"Cbx_lamb_eng_whl_pf"
			VALUE
			0x7011A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_eng_whl_vf
			"Cbx_lamb_eng_whl_vf"
			VALUE
			0x7043C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_fsys_lpg_mfo
			"Cbx_lamb_fsys_lpg_mfo"
			VALUE
			0x706B2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_fsys_lpg_pf
			"Cbx_lamb_fsys_lpg_pf"
			VALUE
			0x7011C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_fsys_lpg_vf
			"Cbx_lamb_fsys_lpg_vf"
			VALUE
			0x7043E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_fsys_mfo
			"Cbx_lamb_fsys_mfo"
			VALUE
			0x706B1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_fsys_pf
			"Cbx_lamb_fsys_pf"
			VALUE
			0x7011B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_fsys_vf
			"Cbx_lamb_fsys_vf"
			VALUE
			0x7043D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_gas_pump_mfo
			"Cbx_lamb_gas_pump_mfo"
			VALUE
			0x7060A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_gas_pump_pf
			"Cbx_lamb_gas_pump_pf"
			VALUE
			0x7011D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_gas_pump_vf
			"Cbx_lamb_gas_pump_vf"
			VALUE
			0x70420
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_igc_1_mfo
			"Cbx_lamb_igc_1_mfo"
			VALUE
			0x7060B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_igc_1_pf
			"Cbx_lamb_igc_1_pf"
			VALUE
			0x7011E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_igc_1_vf
			"Cbx_lamb_igc_1_vf"
			VALUE
			0x70421
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_igc_2_mfo
			"Cbx_lamb_igc_2_mfo"
			VALUE
			0x7060C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_igc_2_pf
			"Cbx_lamb_igc_2_pf"
			VALUE
			0x7011F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_igc_2_vf
			"Cbx_lamb_igc_2_vf"
			VALUE
			0x70422
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_igc_3_mfo
			"Cbx_lamb_igc_3_mfo"
			VALUE
			0x7060D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_igc_3_pf
			"Cbx_lamb_igc_3_pf"
			VALUE
			0x70120
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_igc_3_vf
			"Cbx_lamb_igc_3_vf"
			VALUE
			0x70423
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_igc_4_mfo
			"Cbx_lamb_igc_4_mfo"
			VALUE
			0x7060E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_igc_4_pf
			"Cbx_lamb_igc_4_pf"
			VALUE
			0x70121
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_igc_4_vf
			"Cbx_lamb_igc_4_vf"
			VALUE
			0x70424
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_inj1_mfo
			"Cbx_lamb_inj1_mfo"
			VALUE
			0x7060F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_inj1_pf
			"Cbx_lamb_inj1_pf"
			VALUE
			0x70122
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_inj1_vf
			"Cbx_lamb_inj1_vf"
			VALUE
			0x70425
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_inj2_mfo
			"Cbx_lamb_inj2_mfo"
			VALUE
			0x70610
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_inj2_pf
			"Cbx_lamb_inj2_pf"
			VALUE
			0x70123
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_inj2_vf
			"Cbx_lamb_inj2_vf"
			VALUE
			0x70426
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_inj3_mfo
			"Cbx_lamb_inj3_mfo"
			VALUE
			0x70611
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_inj3_pf
			"Cbx_lamb_inj3_pf"
			VALUE
			0x70124
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_inj3_vf
			"Cbx_lamb_inj3_vf"
			VALUE
			0x70427
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_inj4_mfo
			"Cbx_lamb_inj4_mfo"
			VALUE
			0x70612
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_inj4_pf
			"Cbx_lamb_inj4_pf"
			VALUE
			0x70125
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_inj4_vf
			"Cbx_lamb_inj4_vf"
			VALUE
			0x70428
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_inj_ecu_mfo
			"Cbx_lamb_inj_ecu_mfo"
			VALUE
			0x706B3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_inj_ecu_pf
			"Cbx_lamb_inj_ecu_pf"
			VALUE
			0x70126
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_inj_ecu_vf
			"Cbx_lamb_inj_ecu_vf"
			VALUE
			0x7043F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_ip_inj_cnt_pf
			"Cbx_lamb_ip_inj_cnt_pf"
			VALUE
			0x70127
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_knk_mfo
			"Cbx_lamb_knk_mfo"
			VALUE
			0x706B4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_knk_pf
			"Cbx_lamb_knk_pf"
			VALUE
			0x70128
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_knk_vf
			"Cbx_lamb_knk_vf"
			VALUE
			0x70440
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_lbdw_hot_mfo
			"Cbx_lamb_lbdw_hot_mfo"
			VALUE
			0x70614
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_lbdw_hot_pf
			"Cbx_lamb_lbdw_hot_pf"
			VALUE
			0x7012A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_lbdw_hot_vf
			"Cbx_lamb_lbdw_hot_vf"
			VALUE
			0x7042A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_lbdw_mfo
			"Cbx_lamb_lbdw_mfo"
			VALUE
			0x70613
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_lbdw_pf
			"Cbx_lamb_lbdw_pf"
			VALUE
			0x70129
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_lbdw_pump_crt_pf
			"Cbx_lamb_lbdw_pump_crt_pf"
			VALUE
			0x7012B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_lbdw_vf
			"Cbx_lamb_lbdw_vf"
			VALUE
			0x70429
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_lbup_hot_mfo
			"Cbx_lamb_lbup_hot_mfo"
			VALUE
			0x70616
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_lbup_hot_pf
			"Cbx_lamb_lbup_hot_pf"
			VALUE
			0x7012D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_lbup_hot_vf
			"Cbx_lamb_lbup_hot_vf"
			VALUE
			0x7042C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_lbup_mfo
			"Cbx_lamb_lbup_mfo"
			VALUE
			0x70615
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_lbup_pf
			"Cbx_lamb_lbup_pf"
			VALUE
			0x7012C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_lbup_pump_crt_pf
			"Cbx_lamb_lbup_pump_crt_pf"
			VALUE
			0x7012E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_lbup_vf
			"Cbx_lamb_lbup_vf"
			VALUE
			0x7042B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_lpg_rcpt_mfo
			"Cbx_lamb_lpg_rcpt_mfo"
			VALUE
			0x706B5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_lpg_rcpt_pf
			"Cbx_lamb_lpg_rcpt_pf"
			VALUE
			0x7012F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_lpg_rcpt_vf
			"Cbx_lamb_lpg_rcpt_vf"
			VALUE
			0x70441
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_map_chr_pf
			"Cbx_lamb_map_chr_pf"
			VALUE
			0x70131
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_map_mfo
			"Cbx_lamb_map_mfo"
			VALUE
			0x706B6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_map_pf
			"Cbx_lamb_map_pf"
			VALUE
			0x70130
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_map_vf
			"Cbx_lamb_map_vf"
			VALUE
			0x70442
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mastervac_pf
			"Cbx_lamb_mastervac_pf"
			VALUE
			0x70132
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mcut_sens1_pf
			"Cbx_lamb_mcut_sens1_pf"
			VALUE
			0x70133
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mdf1_pf
			"Cbx_lamb_mdf1_pf"
			VALUE
			0x70134
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mdf2_pf
			"Cbx_lamb_mdf2_pf"
			VALUE
			0x70135
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_min_gas_lvl_mfo
			"Cbx_lamb_min_gas_lvl_mfo"
			VALUE
			0x706B7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_min_gas_lvl_pf
			"Cbx_lamb_min_gas_lvl_pf"
			VALUE
			0x70136
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_min_gas_lvl_vf
			"Cbx_lamb_min_gas_lvl_vf"
			VALUE
			0x70443
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_min_lpg_lvl_pf
			"Cbx_lamb_min_lpg_lvl_pf"
			VALUE
			0x70137
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_cata_1_lpg_mfo
			"Cbx_lamb_mis_cata_1_lpg_mfo"
			VALUE
			0x706BA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_cata_1_lpg_pf
			"Cbx_lamb_mis_cata_1_lpg_pf"
			VALUE
			0x7013A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_cata_1_lpg_vf
			"Cbx_lamb_mis_cata_1_lpg_vf"
			VALUE
			0x70446
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_cata_1_mfo
			"Cbx_lamb_mis_cata_1_mfo"
			VALUE
			0x706B9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_cata_1_pf
			"Cbx_lamb_mis_cata_1_pf"
			VALUE
			0x70139
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_cata_1_vf
			"Cbx_lamb_mis_cata_1_vf"
			VALUE
			0x70445
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_cata_2_lpg_mfo
			"Cbx_lamb_mis_cata_2_lpg_mfo"
			VALUE
			0x706BC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_cata_2_lpg_pf
			"Cbx_lamb_mis_cata_2_lpg_pf"
			VALUE
			0x7013C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_cata_2_lpg_vf
			"Cbx_lamb_mis_cata_2_lpg_vf"
			VALUE
			0x70448
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_cata_2_mfo
			"Cbx_lamb_mis_cata_2_mfo"
			VALUE
			0x706BB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_cata_2_pf
			"Cbx_lamb_mis_cata_2_pf"
			VALUE
			0x7013B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_cata_2_vf
			"Cbx_lamb_mis_cata_2_vf"
			VALUE
			0x70447
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_cata_3_lpg_mfo
			"Cbx_lamb_mis_cata_3_lpg_mfo"
			VALUE
			0x706BE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_cata_3_lpg_pf
			"Cbx_lamb_mis_cata_3_lpg_pf"
			VALUE
			0x7013E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_cata_3_lpg_vf
			"Cbx_lamb_mis_cata_3_lpg_vf"
			VALUE
			0x7044A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_cata_3_mfo
			"Cbx_lamb_mis_cata_3_mfo"
			VALUE
			0x706BD
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_cata_3_pf
			"Cbx_lamb_mis_cata_3_pf"
			VALUE
			0x7013D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_cata_3_vf
			"Cbx_lamb_mis_cata_3_vf"
			VALUE
			0x70449
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_cata_4_lpg_mfo
			"Cbx_lamb_mis_cata_4_lpg_mfo"
			VALUE
			0x706C0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_cata_4_lpg_pf
			"Cbx_lamb_mis_cata_4_lpg_pf"
			VALUE
			0x70140
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_cata_4_lpg_vf
			"Cbx_lamb_mis_cata_4_lpg_vf"
			VALUE
			0x7044C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_cata_4_mfo
			"Cbx_lamb_mis_cata_4_mfo"
			VALUE
			0x706BF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_cata_4_pf
			"Cbx_lamb_mis_cata_4_pf"
			VALUE
			0x7013F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_cata_4_vf
			"Cbx_lamb_mis_cata_4_vf"
			VALUE
			0x7044B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_cata_gas_mfo
			"Cbx_lamb_mis_cata_gas_mfo"
			VALUE
			0x706C1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_cata_gas_pf
			"Cbx_lamb_mis_cata_gas_pf"
			VALUE
			0x70141
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_cata_gas_vf
			"Cbx_lamb_mis_cata_gas_vf"
			VALUE
			0x7044D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_cata_lpg_mfo
			"Cbx_lamb_mis_cata_lpg_mfo"
			VALUE
			0x706C2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_cata_lpg_pf
			"Cbx_lamb_mis_cata_lpg_pf"
			VALUE
			0x70142
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_cata_lpg_vf
			"Cbx_lamb_mis_cata_lpg_vf"
			VALUE
			0x7044E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_cata_mfo
			"Cbx_lamb_mis_cata_mfo"
			VALUE
			0x706B8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_cata_pf
			"Cbx_lamb_mis_cata_pf"
			VALUE
			0x70138
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_cata_vf
			"Cbx_lamb_mis_cata_vf"
			VALUE
			0x70444
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_fast_pf
			"Cbx_lamb_mis_fast_pf"
			VALUE
			0x70143
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_lih_pf
			"Cbx_lamb_mis_lih_pf"
			VALUE
			0x70144
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_polu_1_lpg_mfo
			"Cbx_lamb_mis_polu_1_lpg_mfo"
			VALUE
			0x706C5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_polu_1_lpg_pf
			"Cbx_lamb_mis_polu_1_lpg_pf"
			VALUE
			0x70147
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_polu_1_lpg_vf
			"Cbx_lamb_mis_polu_1_lpg_vf"
			VALUE
			0x70451
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_polu_1_mfo
			"Cbx_lamb_mis_polu_1_mfo"
			VALUE
			0x706C4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_polu_1_pf
			"Cbx_lamb_mis_polu_1_pf"
			VALUE
			0x70146
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_polu_1_vf
			"Cbx_lamb_mis_polu_1_vf"
			VALUE
			0x70450
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_polu_2_lpg_mfo
			"Cbx_lamb_mis_polu_2_lpg_mfo"
			VALUE
			0x706C7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_polu_2_lpg_pf
			"Cbx_lamb_mis_polu_2_lpg_pf"
			VALUE
			0x70149
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_polu_2_lpg_vf
			"Cbx_lamb_mis_polu_2_lpg_vf"
			VALUE
			0x70453
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_polu_2_mfo
			"Cbx_lamb_mis_polu_2_mfo"
			VALUE
			0x706C6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_polu_2_pf
			"Cbx_lamb_mis_polu_2_pf"
			VALUE
			0x70148
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_polu_2_vf
			"Cbx_lamb_mis_polu_2_vf"
			VALUE
			0x70452
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_polu_3_lpg_mfo
			"Cbx_lamb_mis_polu_3_lpg_mfo"
			VALUE
			0x706C9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_polu_3_lpg_pf
			"Cbx_lamb_mis_polu_3_lpg_pf"
			VALUE
			0x7014B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_polu_3_lpg_vf
			"Cbx_lamb_mis_polu_3_lpg_vf"
			VALUE
			0x70455
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_polu_3_mfo
			"Cbx_lamb_mis_polu_3_mfo"
			VALUE
			0x706C8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_polu_3_pf
			"Cbx_lamb_mis_polu_3_pf"
			VALUE
			0x7014A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_polu_3_vf
			"Cbx_lamb_mis_polu_3_vf"
			VALUE
			0x70454
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_polu_4_lpg_mfo
			"Cbx_lamb_mis_polu_4_lpg_mfo"
			VALUE
			0x706CB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_polu_4_lpg_pf
			"Cbx_lamb_mis_polu_4_lpg_pf"
			VALUE
			0x7014D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_polu_4_lpg_vf
			"Cbx_lamb_mis_polu_4_lpg_vf"
			VALUE
			0x70457
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_polu_4_mfo
			"Cbx_lamb_mis_polu_4_mfo"
			VALUE
			0x706CA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_polu_4_pf
			"Cbx_lamb_mis_polu_4_pf"
			VALUE
			0x7014C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_polu_4_vf
			"Cbx_lamb_mis_polu_4_vf"
			VALUE
			0x70456
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_polu_gas_mfo
			"Cbx_lamb_mis_polu_gas_mfo"
			VALUE
			0x706CC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_polu_gas_pf
			"Cbx_lamb_mis_polu_gas_pf"
			VALUE
			0x7014E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_polu_gas_vf
			"Cbx_lamb_mis_polu_gas_vf"
			VALUE
			0x70458
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_polu_lpg_mfo
			"Cbx_lamb_mis_polu_lpg_mfo"
			VALUE
			0x706CD
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_polu_lpg_pf
			"Cbx_lamb_mis_polu_lpg_pf"
			VALUE
			0x7014F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_polu_lpg_vf
			"Cbx_lamb_mis_polu_lpg_vf"
			VALUE
			0x70459
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_polu_mfo
			"Cbx_lamb_mis_polu_mfo"
			VALUE
			0x706C3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_polu_pf
			"Cbx_lamb_mis_polu_pf"
			VALUE
			0x70145
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mis_polu_vf
			"Cbx_lamb_mis_polu_vf"
			VALUE
			0x7044F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mvac_pump_pf
			"Cbx_lamb_mvac_pump_pf"
			VALUE
			0x70150
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_mvac_sys_pf
			"Cbx_lamb_mvac_sys_pf"
			VALUE
			0x70151
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_obd_cata_mfo
			"Cbx_lamb_obd_cata_mfo"
			VALUE
			0x706CE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_obd_cata_pf
			"Cbx_lamb_obd_cata_pf"
			VALUE
			0x70152
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_obd_cata_vf
			"Cbx_lamb_obd_cata_vf"
			VALUE
			0x7045A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_obd_lamb_mfo
			"Cbx_lamb_obd_lamb_mfo"
			VALUE
			0x706CF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_obd_lamb_pf
			"Cbx_lamb_obd_lamb_pf"
			VALUE
			0x70153
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_obd_lamb_vf
			"Cbx_lamb_obd_lamb_vf"
			VALUE
			0x7045B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_obd_sa_mfo
			"Cbx_lamb_obd_sa_mfo"
			VALUE
			0x706D0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_obd_sa_pf
			"Cbx_lamb_obd_sa_pf"
			VALUE
			0x70154
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_obd_sa_vf
			"Cbx_lamb_obd_sa_vf"
			VALUE
			0x7045C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_oil_pf
			"Cbx_lamb_oil_pf"
			VALUE
			0x70155
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_pdl_pf
			"Cbx_lamb_pdl_pf"
			VALUE
			0x70156
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_pmh_pf
			"Cbx_lamb_pmh_pf"
			VALUE
			0x70157
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_pow_lbdw_mfo
			"Cbx_lamb_pow_lbdw_mfo"
			VALUE
			0x706D1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_pow_lbdw_pf
			"Cbx_lamb_pow_lbdw_pf"
			VALUE
			0x70158
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_pow_lbdw_vf
			"Cbx_lamb_pow_lbdw_vf"
			VALUE
			0x7045D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_pow_lbup_mfo
			"Cbx_lamb_pow_lbup_mfo"
			VALUE
			0x706D2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_pow_lbup_pf
			"Cbx_lamb_pow_lbup_pf"
			VALUE
			0x70159
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_pow_lbup_vf
			"Cbx_lamb_pow_lbup_vf"
			VALUE
			0x7045E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_ptc_pf
			"Cbx_lamb_ptc_pf"
			VALUE
			0x7015A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_ptc_rov_pf
			"Cbx_lamb_ptc_rov_pf"
			VALUE
			0x7015B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_pws_pf
			"Cbx_lamb_pws_pf"
			VALUE
			0x7015C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_rams_pdl_mfo
			"Cbx_lamb_rams_pdl_mfo"
			VALUE
			0x706D3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_rams_pdl_pf
			"Cbx_lamb_rams_pdl_pf"
			VALUE
			0x7015E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_rams_pdl_vf
			"Cbx_lamb_rams_pdl_vf"
			VALUE
			0x7045F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_rams_pf
			"Cbx_lamb_rams_pf"
			VALUE
			0x7015D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_reserve_3_pf
			"Cbx_lamb_reserve_3_pf"
			VALUE
			0x7015F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_rmc_pf
			"Cbx_lamb_rmc_pf"
			VALUE
			0x70160
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_sa_ev_mfo
			"Cbx_lamb_sa_ev_mfo"
			VALUE
			0x70618
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_sa_ev_pf
			"Cbx_lamb_sa_ev_pf"
			VALUE
			0x70162
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_sa_ev_vf
			"Cbx_lamb_sa_ev_vf"
			VALUE
			0x7042E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_sa_mfo
			"Cbx_lamb_sa_mfo"
			VALUE
			0x70617
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_sa_pf
			"Cbx_lamb_sa_pf"
			VALUE
			0x70161
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_sa_vf
			"Cbx_lamb_sa_vf"
			VALUE
			0x7042D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_spg_mfo
			"Cbx_lamb_spg_mfo"
			VALUE
			0x706D4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_spg_pf
			"Cbx_lamb_spg_pf"
			VALUE
			0x70163
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_spg_sys_mfo
			"Cbx_lamb_spg_sys_mfo"
			VALUE
			0x706D5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_spg_sys_pf
			"Cbx_lamb_spg_sys_pf"
			VALUE
			0x70164
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_spg_sys_vf
			"Cbx_lamb_spg_sys_vf"
			VALUE
			0x70461
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_spg_vf
			"Cbx_lamb_spg_vf"
			VALUE
			0x70460
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_spi_cc_pf
			"Cbx_lamb_spi_cc_pf"
			VALUE
			0x70165
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_svkl_pf
			"Cbx_lamb_svkl_pf"
			VALUE
			0x70166
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_swlk_pf
			"Cbx_lamb_swlk_pf"
			VALUE
			0x70167
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_tco_mfo
			"Cbx_lamb_tco_mfo"
			VALUE
			0x70619
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_tco_pf
			"Cbx_lamb_tco_pf"
			VALUE
			0x70168
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_tco_vf
			"Cbx_lamb_tco_vf"
			VALUE
			0x7042F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_thpl_pf
			"Cbx_lamb_thpl_pf"
			VALUE
			0x70169
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_thr_cmd_pf
			"Cbx_lamb_thr_cmd_pf"
			VALUE
			0x7016B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_thr_pf
			"Cbx_lamb_thr_pf"
			VALUE
			0x7016A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_tia_mfo
			"Cbx_lamb_tia_mfo"
			VALUE
			0x7061A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_tia_pf
			"Cbx_lamb_tia_pf"
			VALUE
			0x7016C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_tia_vf
			"Cbx_lamb_tia_vf"
			VALUE
			0x70430
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_tjy_ctl_pf
			"Cbx_lamb_tjy_ctl_pf"
			VALUE
			0x7016D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_tlz_ad_b_mfo
			"Cbx_lamb_tlz_ad_b_mfo"
			VALUE
			0x706D6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_tlz_ad_b_pf
			"Cbx_lamb_tlz_ad_b_pf"
			VALUE
			0x7016E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_tlz_ad_b_vf
			"Cbx_lamb_tlz_ad_b_vf"
			VALUE
			0x70462
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_vb_pf
			"Cbx_lamb_vb_pf"
			VALUE
			0x7016F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_vs_mfo
			"Cbx_lamb_vs_mfo"
			VALUE
			0x7061B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_vs_pf
			"Cbx_lamb_vs_pf"
			VALUE
			0x70170
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_vs_vf
			"Cbx_lamb_vs_vf"
			VALUE
			0x70431
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_vta_intake_mfo
			"Cbx_lamb_vta_intake_mfo"
			VALUE
			0x7061C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_vta_intake_pf
			"Cbx_lamb_vta_intake_pf"
			VALUE
			0x70171
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_vta_intake_vf
			"Cbx_lamb_vta_intake_vf"
			VALUE
			0x70432
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_vvt_int_ev_mfo
			"Cbx_lamb_vvt_int_ev_mfo"
			VALUE
			0x7061D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_vvt_int_ev_pf
			"Cbx_lamb_vvt_int_ev_pf"
			VALUE
			0x70173
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_vvt_int_ev_vf
			"Cbx_lamb_vvt_int_ev_vf"
			VALUE
			0x70433
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_vvt_int_old_off_mfo
			"Cbx_lamb_vvt_int_old_off_mfo"
			VALUE
			0x706D7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_vvt_int_old_off_vf
			"Cbx_lamb_vvt_int_old_off_vf"
			VALUE
			0x70463
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_vvt_int_pf
			"Cbx_lamb_vvt_int_pf"
			VALUE
			0x70172
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_vvt_intake_mfo
			"Cbx_lamb_vvt_intake_mfo"
			VALUE
			0x7061E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_vvt_intake_pf
			"Cbx_lamb_vvt_intake_pf"
			VALUE
			0x70174
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_vvt_intake_vf
			"Cbx_lamb_vvt_intake_vf"
			VALUE
			0x70434
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_vvtc_toth_3_mfo
			"Cbx_lamb_vvtc_toth_3_mfo"
			VALUE
			0x706D8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_vvtc_toth_3_pf
			"Cbx_lamb_vvtc_toth_3_pf"
			VALUE
			0x70175
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_vvtc_toth_3_vf
			"Cbx_lamb_vvtc_toth_3_vf"
			VALUE
			0x70464
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_wat_temp_pf
			"Cbx_lamb_wat_temp_pf"
			VALUE
			0x70176
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_wgc_mfo
			"Cbx_lamb_wgc_mfo"
			VALUE
			0x7061F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_wgc_pf
			"Cbx_lamb_wgc_pf"
			VALUE
			0x70177
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_wgc_vf
			"Cbx_lamb_wgc_vf"
			VALUE
			0x70435
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lamb_wpmp_pf
			"Cbx_lamb_wpmp_pf"
			VALUE
			0x70178
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lbdw
			"Cbx_lbdw"
			VALUE
			0x7837C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lbdw_osp_typ
			"Cbx_lbdw_osp_typ"
			VALUE
			0x7837D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lbdw_typ
			"Cbx_lbdw_typ"
			VALUE
			0x7837E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lbup_conf
			"Cbx_lbup_conf"
			VALUE
			0x78790
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lbup_dwpt_per_ena
			"Cbx_lbup_dwpt_per_ena"
			VALUE
			0x7837F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lbup_hot_cho
			"Cbx_lbup_hot_cho"
			VALUE
			0x78380
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lbup_osp_typ
			"Cbx_lbup_osp_typ"
			VALUE
			0x78381
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lbup_typ
			"Cbx_lbup_typ"
			VALUE
			0x78382
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lpg_aper_pump_run_ena
			"Cbx_lpg_aper_pump_run_ena"
			VALUE
			0x73740
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lpg_gas_pump_cut_ena
			"Cbx_lpg_gas_pump_cut_ena"
			VALUE
			0x73741
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lpg_min_lvl_diag_ena
			"Cbx_lpg_min_lvl_diag_ena"
			VALUE
			0x73742
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lpg_min_lvl_lih_ena
			"Cbx_lpg_min_lvl_lih_ena"
			VALUE
			0x73743
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lpg_prs_diag_ena
			"Cbx_lpg_prs_diag_ena"
			VALUE
			0x73744
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lpg_sta_ena
			"Cbx_lpg_sta_ena"
			VALUE
			0x73745
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lsb_ini_req
			"Cbx_lsb_ini_req"
			VALUE
			0x7319D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lsm_ctr_ini_req
			"Cbx_lsm_ctr_ini_req"
			VALUE
			0x7319E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_lsm_dft_ini_req
			"Cbx_lsm_dft_ini_req"
			VALUE
			0x7319F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_max_iga_conf
			"Cbx_max_iga_conf"
			VALUE
			0x73C1E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_max_ti_b0_ini_req
			"Cbx_max_ti_b0_ini_req"
			VALUE
			0x731A0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_max_ti_b1_ini_req
			"Cbx_max_ti_b1_ini_req"
			VALUE
			0x731A1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_max_ti_b2_ini_req
			"Cbx_max_ti_b2_ini_req"
			VALUE
			0x731A2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_max_ti_b3_ini_req
			"Cbx_max_ti_b3_ini_req"
			VALUE
			0x731A3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_max_ti_b4_ini_req
			"Cbx_max_ti_b4_ini_req"
			VALUE
			0x731A4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mdl_cp_load_dsb
			"Cbx_mdl_cp_load_dsb"
			VALUE
			0x76FA3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mdl_thr_conf
			"Cbx_mdl_thr_conf"
			VALUE
			0x73C1F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_agb
			"Cbx_mena_agb"
			VALUE
			0x736C8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_agb_rcpt
			"Cbx_mena_agb_rcpt"
			VALUE
			0x708EC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_air
			"Cbx_mena_air"
			VALUE
			0x708ED
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_bkup_mem
			"Cbx_mena_bkup_mem"
			VALUE
			0x708EE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_clu
			"Cbx_mena_clu"
			VALUE
			0x708EF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_cp
			"Cbx_mena_cp"
			VALUE
			0x708D5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_crk
			"Cbx_mena_crk"
			VALUE
			0x708F0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_crk_nr
			"Cbx_mena_crk_nr"
			VALUE
			0x708F1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_eng_whl
			"Cbx_mena_eng_whl"
			VALUE
			0x708F2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_flsh_mis_cata
			"Cbx_mena_flsh_mis_cata"
			VALUE
			0x736C9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_flsh_mis_cata_lpg
			"Cbx_mena_flsh_mis_cata_lpg"
			VALUE
			0x736CA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_fsys
			"Cbx_mena_fsys"
			VALUE
			0x708F3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_fsys_lpg
			"Cbx_mena_fsys_lpg"
			VALUE
			0x708F4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_gas_pump
			"Cbx_mena_gas_pump"
			VALUE
			0x708D6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_igc_1
			"Cbx_mena_igc_1"
			VALUE
			0x708D7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_igc_2
			"Cbx_mena_igc_2"
			VALUE
			0x708D8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_igc_3
			"Cbx_mena_igc_3"
			VALUE
			0x708D9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_igc_4
			"Cbx_mena_igc_4"
			VALUE
			0x708DA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_inj1
			"Cbx_mena_inj1"
			VALUE
			0x708DB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_inj2
			"Cbx_mena_inj2"
			VALUE
			0x708DC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_inj3
			"Cbx_mena_inj3"
			VALUE
			0x708DD
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_inj4
			"Cbx_mena_inj4"
			VALUE
			0x708DE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_inj_ecu
			"Cbx_mena_inj_ecu"
			VALUE
			0x708F5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_knk
			"Cbx_mena_knk"
			VALUE
			0x708F6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_lbdw
			"Cbx_mena_lbdw"
			VALUE
			0x708DF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_lbdw_hot
			"Cbx_mena_lbdw_hot"
			VALUE
			0x708E0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_lbup
			"Cbx_mena_lbup"
			VALUE
			0x708E1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_lbup_hot
			"Cbx_mena_lbup_hot"
			VALUE
			0x708E2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_lpg
			"Cbx_mena_lpg"
			VALUE
			0x736CB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_lpg_rcpt
			"Cbx_mena_lpg_rcpt"
			VALUE
			0x708F7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_map
			"Cbx_mena_map"
			VALUE
			0x708F8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_min_gas_lvl
			"Cbx_mena_min_gas_lvl"
			VALUE
			0x708F9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_mis_cata
			"Cbx_mena_mis_cata"
			VALUE
			0x708FA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_mis_cata_1
			"Cbx_mena_mis_cata_1"
			VALUE
			0x708FB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_mis_cata_1_lpg
			"Cbx_mena_mis_cata_1_lpg"
			VALUE
			0x708FC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_mis_cata_2
			"Cbx_mena_mis_cata_2"
			VALUE
			0x708FD
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_mis_cata_2_lpg
			"Cbx_mena_mis_cata_2_lpg"
			VALUE
			0x708FE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_mis_cata_3
			"Cbx_mena_mis_cata_3"
			VALUE
			0x708FF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_mis_cata_3_lpg
			"Cbx_mena_mis_cata_3_lpg"
			VALUE
			0x70900
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_mis_cata_4
			"Cbx_mena_mis_cata_4"
			VALUE
			0x70901
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_mis_cata_4_lpg
			"Cbx_mena_mis_cata_4_lpg"
			VALUE
			0x70902
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_mis_cata_gas
			"Cbx_mena_mis_cata_gas"
			VALUE
			0x70903
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_mis_cata_lpg
			"Cbx_mena_mis_cata_lpg"
			VALUE
			0x70904
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_mis_polu
			"Cbx_mena_mis_polu"
			VALUE
			0x70905
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_mis_polu_1
			"Cbx_mena_mis_polu_1"
			VALUE
			0x70906
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_mis_polu_1_lpg
			"Cbx_mena_mis_polu_1_lpg"
			VALUE
			0x70907
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_mis_polu_2
			"Cbx_mena_mis_polu_2"
			VALUE
			0x70908
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_mis_polu_2_lpg
			"Cbx_mena_mis_polu_2_lpg"
			VALUE
			0x70909
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_mis_polu_3
			"Cbx_mena_mis_polu_3"
			VALUE
			0x7090A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_mis_polu_3_lpg
			"Cbx_mena_mis_polu_3_lpg"
			VALUE
			0x7090B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_mis_polu_4
			"Cbx_mena_mis_polu_4"
			VALUE
			0x7090C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_mis_polu_4_lpg
			"Cbx_mena_mis_polu_4_lpg"
			VALUE
			0x7090D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_mis_polu_gas
			"Cbx_mena_mis_polu_gas"
			VALUE
			0x7090E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_mis_polu_lpg
			"Cbx_mena_mis_polu_lpg"
			VALUE
			0x7090F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_obd_cata
			"Cbx_mena_obd_cata"
			VALUE
			0x70910
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_obd_lamb
			"Cbx_mena_obd_lamb"
			VALUE
			0x70911
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_obd_sa
			"Cbx_mena_obd_sa"
			VALUE
			0x70912
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_pow_lbdw
			"Cbx_mena_pow_lbdw"
			VALUE
			0x70913
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_pow_lbup
			"Cbx_mena_pow_lbup"
			VALUE
			0x70914
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_rams_pdl
			"Cbx_mena_rams_pdl"
			VALUE
			0x70915
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_sa
			"Cbx_mena_sa"
			VALUE
			0x708E3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_sa_ev
			"Cbx_mena_sa_ev"
			VALUE
			0x708E4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_spg
			"Cbx_mena_spg"
			VALUE
			0x70916
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_spg_sys
			"Cbx_mena_spg_sys"
			VALUE
			0x70917
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_tco
			"Cbx_mena_tco"
			VALUE
			0x708E5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_tia
			"Cbx_mena_tia"
			VALUE
			0x708E6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_tlz_ad_b
			"Cbx_mena_tlz_ad_b"
			VALUE
			0x70918
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_vs
			"Cbx_mena_vs"
			VALUE
			0x708E7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_vta_intake
			"Cbx_mena_vta_intake"
			VALUE
			0x708E8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_vvt_int_ev
			"Cbx_mena_vvt_int_ev"
			VALUE
			0x708E9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_vvt_int_old_off
			"Cbx_mena_vvt_int_old_off"
			VALUE
			0x70919
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_vvt_intake
			"Cbx_mena_vvt_intake"
			VALUE
			0x708EA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_vvtc_toth_3
			"Cbx_mena_vvtc_toth_3"
			VALUE
			0x7091A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mena_wgc
			"Cbx_mena_wgc"
			VALUE
			0x708EB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_min_lvl_pump_cut_ena
			"Cbx_min_lvl_pump_cut_ena"
			VALUE
			0x73746
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_min_ti
			"Cbx_min_ti"
			VALUE
			0x74875
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_min_ti_b0_ini_req
			"Cbx_min_ti_b0_ini_req"
			VALUE
			0x731A5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_min_ti_b1_ini_req
			"Cbx_min_ti_b1_ini_req"
			VALUE
			0x731A6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_min_ti_b2_ini_req
			"Cbx_min_ti_b2_ini_req"
			VALUE
			0x731A7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_min_ti_b3_ini_req
			"Cbx_min_ti_b3_ini_req"
			VALUE
			0x731A8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_min_ti_b4_ini_req
			"Cbx_min_ti_b4_ini_req"
			VALUE
			0x731A9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_ac_prs_pf
			"Cbx_mis_cata_ac_prs_pf"
			VALUE
			0x7025B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_ac_rcpt_pf
			"Cbx_mis_cata_ac_rcpt_pf"
			VALUE
			0x7025C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_acr_pf
			"Cbx_mis_cata_acr_pf"
			VALUE
			0x7025D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_actr_rly_cut_pf
			"Cbx_mis_cata_actr_rly_cut_pf"
			VALUE
			0x7025F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_actr_rly_pf
			"Cbx_mis_cata_actr_rly_pf"
			VALUE
			0x7025E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_agb_pf
			"Cbx_mis_cata_agb_pf"
			VALUE
			0x70260
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_agb_rcpt_mfo
			"Cbx_mis_cata_agb_rcpt_mfo"
			VALUE
			0x70737
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_agb_rcpt_vf
			"Cbx_mis_cata_agb_rcpt_vf"
			VALUE
			0x70508
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_air_mfo
			"Cbx_mis_cata_air_mfo"
			VALUE
			0x70738
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_air_pf
			"Cbx_mis_cata_air_pf"
			VALUE
			0x70261
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_air_vf
			"Cbx_mis_cata_air_vf"
			VALUE
			0x70509
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_alt_load_in_pf
			"Cbx_mis_cata_alt_load_in_pf"
			VALUE
			0x70263
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_alt_pf
			"Cbx_mis_cata_alt_pf"
			VALUE
			0x70262
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_bkup_mem_mfo
			"Cbx_mis_cata_bkup_mem_mfo"
			VALUE
			0x70739
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_bkup_mem_pf
			"Cbx_mis_cata_bkup_mem_pf"
			VALUE
			0x70264
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_bkup_mem_vf
			"Cbx_mis_cata_bkup_mem_vf"
			VALUE
			0x7050A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_checksum_pf
			"Cbx_mis_cata_checksum_pf"
			VALUE
			0x70265
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_clu_mfo
			"Cbx_mis_cata_clu_mfo"
			VALUE
			0x7073A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_clu_pf
			"Cbx_mis_cata_clu_pf"
			VALUE
			0x70266
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_clu_vf
			"Cbx_mis_cata_clu_vf"
			VALUE
			0x7050B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_cp_mfo
			"Cbx_mis_cata_cp_mfo"
			VALUE
			0x7064E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_cp_pf
			"Cbx_mis_cata_cp_pf"
			VALUE
			0x70267
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_cp_vf
			"Cbx_mis_cata_cp_vf"
			VALUE
			0x704F1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_crk_mfo
			"Cbx_mis_cata_crk_mfo"
			VALUE
			0x7073B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_crk_nr_mfo
			"Cbx_mis_cata_crk_nr_mfo"
			VALUE
			0x7073C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_crk_nr_pf
			"Cbx_mis_cata_crk_nr_pf"
			VALUE
			0x70269
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_crk_nr_vf
			"Cbx_mis_cata_crk_nr_vf"
			VALUE
			0x7050D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_crk_pf
			"Cbx_mis_cata_crk_pf"
			VALUE
			0x70268
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_crk_vf
			"Cbx_mis_cata_crk_vf"
			VALUE
			0x7050C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_cru_pf
			"Cbx_mis_cata_cru_pf"
			VALUE
			0x7026A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_el_wind_rcpt_pf
			"Cbx_mis_cata_el_wind_rcpt_pf"
			VALUE
			0x7026B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_eng_temp_pf
			"Cbx_mis_cata_eng_temp_pf"
			VALUE
			0x7026C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_eng_whl_mfo
			"Cbx_mis_cata_eng_whl_mfo"
			VALUE
			0x7073D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_eng_whl_pf
			"Cbx_mis_cata_eng_whl_pf"
			VALUE
			0x7026D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_eng_whl_vf
			"Cbx_mis_cata_eng_whl_vf"
			VALUE
			0x7050E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_fsys_lpg_mfo
			"Cbx_mis_cata_fsys_lpg_mfo"
			VALUE
			0x7073F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_fsys_lpg_pf
			"Cbx_mis_cata_fsys_lpg_pf"
			VALUE
			0x7026F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_fsys_lpg_vf
			"Cbx_mis_cata_fsys_lpg_vf"
			VALUE
			0x70510
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_fsys_mfo
			"Cbx_mis_cata_fsys_mfo"
			VALUE
			0x7073E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_fsys_pf
			"Cbx_mis_cata_fsys_pf"
			VALUE
			0x7026E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_fsys_vf
			"Cbx_mis_cata_fsys_vf"
			VALUE
			0x7050F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_gas_pump_mfo
			"Cbx_mis_cata_gas_pump_mfo"
			VALUE
			0x7064F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_gas_pump_pf
			"Cbx_mis_cata_gas_pump_pf"
			VALUE
			0x70270
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_gas_pump_vf
			"Cbx_mis_cata_gas_pump_vf"
			VALUE
			0x704F2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_igc_1_mfo
			"Cbx_mis_cata_igc_1_mfo"
			VALUE
			0x70650
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_igc_1_pf
			"Cbx_mis_cata_igc_1_pf"
			VALUE
			0x70271
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_igc_1_vf
			"Cbx_mis_cata_igc_1_vf"
			VALUE
			0x704F3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_igc_2_mfo
			"Cbx_mis_cata_igc_2_mfo"
			VALUE
			0x70651
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_igc_2_pf
			"Cbx_mis_cata_igc_2_pf"
			VALUE
			0x70272
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_igc_2_vf
			"Cbx_mis_cata_igc_2_vf"
			VALUE
			0x704F4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_igc_3_mfo
			"Cbx_mis_cata_igc_3_mfo"
			VALUE
			0x70652
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_igc_3_pf
			"Cbx_mis_cata_igc_3_pf"
			VALUE
			0x70273
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_igc_3_vf
			"Cbx_mis_cata_igc_3_vf"
			VALUE
			0x704F5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_igc_4_mfo
			"Cbx_mis_cata_igc_4_mfo"
			VALUE
			0x70653
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_igc_4_pf
			"Cbx_mis_cata_igc_4_pf"
			VALUE
			0x70274
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_igc_4_vf
			"Cbx_mis_cata_igc_4_vf"
			VALUE
			0x704F6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_inj1_mfo
			"Cbx_mis_cata_inj1_mfo"
			VALUE
			0x70654
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_inj1_pf
			"Cbx_mis_cata_inj1_pf"
			VALUE
			0x70275
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_inj1_vf
			"Cbx_mis_cata_inj1_vf"
			VALUE
			0x704F7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_inj2_mfo
			"Cbx_mis_cata_inj2_mfo"
			VALUE
			0x70655
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_inj2_pf
			"Cbx_mis_cata_inj2_pf"
			VALUE
			0x70276
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_inj2_vf
			"Cbx_mis_cata_inj2_vf"
			VALUE
			0x704F8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_inj3_mfo
			"Cbx_mis_cata_inj3_mfo"
			VALUE
			0x70656
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_inj3_pf
			"Cbx_mis_cata_inj3_pf"
			VALUE
			0x70277
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_inj3_vf
			"Cbx_mis_cata_inj3_vf"
			VALUE
			0x704F9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_inj4_mfo
			"Cbx_mis_cata_inj4_mfo"
			VALUE
			0x70657
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_inj4_pf
			"Cbx_mis_cata_inj4_pf"
			VALUE
			0x70278
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_inj4_vf
			"Cbx_mis_cata_inj4_vf"
			VALUE
			0x704FA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_inj_ecu_mfo
			"Cbx_mis_cata_inj_ecu_mfo"
			VALUE
			0x70740
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_inj_ecu_pf
			"Cbx_mis_cata_inj_ecu_pf"
			VALUE
			0x70279
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_inj_ecu_vf
			"Cbx_mis_cata_inj_ecu_vf"
			VALUE
			0x70511
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_ip_inj_cnt_pf
			"Cbx_mis_cata_ip_inj_cnt_pf"
			VALUE
			0x7027A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_knk_mfo
			"Cbx_mis_cata_knk_mfo"
			VALUE
			0x70741
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_knk_pf
			"Cbx_mis_cata_knk_pf"
			VALUE
			0x7027B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_knk_vf
			"Cbx_mis_cata_knk_vf"
			VALUE
			0x70512
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_lbdw_hot_mfo
			"Cbx_mis_cata_lbdw_hot_mfo"
			VALUE
			0x70659
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_lbdw_hot_pf
			"Cbx_mis_cata_lbdw_hot_pf"
			VALUE
			0x7027D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_lbdw_hot_vf
			"Cbx_mis_cata_lbdw_hot_vf"
			VALUE
			0x704FC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_lbdw_mfo
			"Cbx_mis_cata_lbdw_mfo"
			VALUE
			0x70658
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_lbdw_pf
			"Cbx_mis_cata_lbdw_pf"
			VALUE
			0x7027C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_lbdw_pump_crt_pf
			"Cbx_mis_cata_lbdw_pump_crt_pf"
			VALUE
			0x7027E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_lbdw_vf
			"Cbx_mis_cata_lbdw_vf"
			VALUE
			0x704FB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_lbup_hot_mfo
			"Cbx_mis_cata_lbup_hot_mfo"
			VALUE
			0x7065B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_lbup_hot_pf
			"Cbx_mis_cata_lbup_hot_pf"
			VALUE
			0x70280
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_lbup_hot_vf
			"Cbx_mis_cata_lbup_hot_vf"
			VALUE
			0x704FE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_lbup_mfo
			"Cbx_mis_cata_lbup_mfo"
			VALUE
			0x7065A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_lbup_pf
			"Cbx_mis_cata_lbup_pf"
			VALUE
			0x7027F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_lbup_pump_crt_pf
			"Cbx_mis_cata_lbup_pump_crt_pf"
			VALUE
			0x70281
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_lbup_vf
			"Cbx_mis_cata_lbup_vf"
			VALUE
			0x704FD
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_lpg_rcpt_mfo
			"Cbx_mis_cata_lpg_rcpt_mfo"
			VALUE
			0x70742
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_lpg_rcpt_pf
			"Cbx_mis_cata_lpg_rcpt_pf"
			VALUE
			0x70282
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_lpg_rcpt_vf
			"Cbx_mis_cata_lpg_rcpt_vf"
			VALUE
			0x70513
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_map_chr_pf
			"Cbx_mis_cata_map_chr_pf"
			VALUE
			0x70284
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_map_mfo
			"Cbx_mis_cata_map_mfo"
			VALUE
			0x70743
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_map_pf
			"Cbx_mis_cata_map_pf"
			VALUE
			0x70283
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_map_vf
			"Cbx_mis_cata_map_vf"
			VALUE
			0x70514
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mastervac_pf
			"Cbx_mis_cata_mastervac_pf"
			VALUE
			0x70285
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mcut_sens1_pf
			"Cbx_mis_cata_mcut_sens1_pf"
			VALUE
			0x70286
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mdf1_pf
			"Cbx_mis_cata_mdf1_pf"
			VALUE
			0x70287
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mdf2_pf
			"Cbx_mis_cata_mdf2_pf"
			VALUE
			0x70288
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_min_gas_lvl_mfo
			"Cbx_mis_cata_min_gas_lvl_mfo"
			VALUE
			0x70744
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_min_gas_lvl_pf
			"Cbx_mis_cata_min_gas_lvl_pf"
			VALUE
			0x70289
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_min_gas_lvl_vf
			"Cbx_mis_cata_min_gas_lvl_vf"
			VALUE
			0x70515
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_min_lpg_lvl_pf
			"Cbx_mis_cata_min_lpg_lvl_pf"
			VALUE
			0x7028A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_cata_1_lpg_mfo
			"Cbx_mis_cata_mis_cata_1_lpg_mfo"
			VALUE
			0x70747
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_cata_1_lpg_pf
			"Cbx_mis_cata_mis_cata_1_lpg_pf"
			VALUE
			0x7028D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_cata_1_lpg_vf
			"Cbx_mis_cata_mis_cata_1_lpg_vf"
			VALUE
			0x70518
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_cata_1_mfo
			"Cbx_mis_cata_mis_cata_1_mfo"
			VALUE
			0x70746
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_cata_1_pf
			"Cbx_mis_cata_mis_cata_1_pf"
			VALUE
			0x7028C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_cata_1_vf
			"Cbx_mis_cata_mis_cata_1_vf"
			VALUE
			0x70517
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_cata_2_lpg_mfo
			"Cbx_mis_cata_mis_cata_2_lpg_mfo"
			VALUE
			0x70749
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_cata_2_lpg_pf
			"Cbx_mis_cata_mis_cata_2_lpg_pf"
			VALUE
			0x7028F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_cata_2_lpg_vf
			"Cbx_mis_cata_mis_cata_2_lpg_vf"
			VALUE
			0x7051A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_cata_2_mfo
			"Cbx_mis_cata_mis_cata_2_mfo"
			VALUE
			0x70748
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_cata_2_pf
			"Cbx_mis_cata_mis_cata_2_pf"
			VALUE
			0x7028E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_cata_2_vf
			"Cbx_mis_cata_mis_cata_2_vf"
			VALUE
			0x70519
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_cata_3_lpg_mfo
			"Cbx_mis_cata_mis_cata_3_lpg_mfo"
			VALUE
			0x7074B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_cata_3_lpg_pf
			"Cbx_mis_cata_mis_cata_3_lpg_pf"
			VALUE
			0x70291
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_cata_3_lpg_vf
			"Cbx_mis_cata_mis_cata_3_lpg_vf"
			VALUE
			0x7051C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_cata_3_mfo
			"Cbx_mis_cata_mis_cata_3_mfo"
			VALUE
			0x7074A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_cata_3_pf
			"Cbx_mis_cata_mis_cata_3_pf"
			VALUE
			0x70290
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_cata_3_vf
			"Cbx_mis_cata_mis_cata_3_vf"
			VALUE
			0x7051B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_cata_4_lpg_mfo
			"Cbx_mis_cata_mis_cata_4_lpg_mfo"
			VALUE
			0x7074D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_cata_4_lpg_pf
			"Cbx_mis_cata_mis_cata_4_lpg_pf"
			VALUE
			0x70293
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_cata_4_lpg_vf
			"Cbx_mis_cata_mis_cata_4_lpg_vf"
			VALUE
			0x7051E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_cata_4_mfo
			"Cbx_mis_cata_mis_cata_4_mfo"
			VALUE
			0x7074C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_cata_4_pf
			"Cbx_mis_cata_mis_cata_4_pf"
			VALUE
			0x70292
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_cata_4_vf
			"Cbx_mis_cata_mis_cata_4_vf"
			VALUE
			0x7051D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_cata_gas_mfo
			"Cbx_mis_cata_mis_cata_gas_mfo"
			VALUE
			0x7074E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_cata_gas_pf
			"Cbx_mis_cata_mis_cata_gas_pf"
			VALUE
			0x70294
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_cata_gas_vf
			"Cbx_mis_cata_mis_cata_gas_vf"
			VALUE
			0x7051F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_cata_lpg_mfo
			"Cbx_mis_cata_mis_cata_lpg_mfo"
			VALUE
			0x7074F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_cata_lpg_pf
			"Cbx_mis_cata_mis_cata_lpg_pf"
			VALUE
			0x70295
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_cata_lpg_vf
			"Cbx_mis_cata_mis_cata_lpg_vf"
			VALUE
			0x70520
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_cata_mfo
			"Cbx_mis_cata_mis_cata_mfo"
			VALUE
			0x70745
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_cata_pf
			"Cbx_mis_cata_mis_cata_pf"
			VALUE
			0x7028B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_cata_vf
			"Cbx_mis_cata_mis_cata_vf"
			VALUE
			0x70516
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_fast_pf
			"Cbx_mis_cata_mis_fast_pf"
			VALUE
			0x70296
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_lih_pf
			"Cbx_mis_cata_mis_lih_pf"
			VALUE
			0x70297
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_polu_1_lpg_mfo
			"Cbx_mis_cata_mis_polu_1_lpg_mfo"
			VALUE
			0x70752
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_polu_1_lpg_pf
			"Cbx_mis_cata_mis_polu_1_lpg_pf"
			VALUE
			0x7029A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_polu_1_lpg_vf
			"Cbx_mis_cata_mis_polu_1_lpg_vf"
			VALUE
			0x70523
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_polu_1_mfo
			"Cbx_mis_cata_mis_polu_1_mfo"
			VALUE
			0x70751
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_polu_1_pf
			"Cbx_mis_cata_mis_polu_1_pf"
			VALUE
			0x70299
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_polu_1_vf
			"Cbx_mis_cata_mis_polu_1_vf"
			VALUE
			0x70522
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_polu_2_lpg_mfo
			"Cbx_mis_cata_mis_polu_2_lpg_mfo"
			VALUE
			0x70754
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_polu_2_lpg_pf
			"Cbx_mis_cata_mis_polu_2_lpg_pf"
			VALUE
			0x7029C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_polu_2_lpg_vf
			"Cbx_mis_cata_mis_polu_2_lpg_vf"
			VALUE
			0x70525
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_polu_2_mfo
			"Cbx_mis_cata_mis_polu_2_mfo"
			VALUE
			0x70753
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_polu_2_pf
			"Cbx_mis_cata_mis_polu_2_pf"
			VALUE
			0x7029B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_polu_2_vf
			"Cbx_mis_cata_mis_polu_2_vf"
			VALUE
			0x70524
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_polu_3_lpg_mfo
			"Cbx_mis_cata_mis_polu_3_lpg_mfo"
			VALUE
			0x70756
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_polu_3_lpg_pf
			"Cbx_mis_cata_mis_polu_3_lpg_pf"
			VALUE
			0x7029E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_polu_3_lpg_vf
			"Cbx_mis_cata_mis_polu_3_lpg_vf"
			VALUE
			0x70527
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_polu_3_mfo
			"Cbx_mis_cata_mis_polu_3_mfo"
			VALUE
			0x70755
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_polu_3_pf
			"Cbx_mis_cata_mis_polu_3_pf"
			VALUE
			0x7029D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_polu_3_vf
			"Cbx_mis_cata_mis_polu_3_vf"
			VALUE
			0x70526
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_polu_4_lpg_mfo
			"Cbx_mis_cata_mis_polu_4_lpg_mfo"
			VALUE
			0x70758
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_polu_4_lpg_pf
			"Cbx_mis_cata_mis_polu_4_lpg_pf"
			VALUE
			0x702A0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_polu_4_lpg_vf
			"Cbx_mis_cata_mis_polu_4_lpg_vf"
			VALUE
			0x70529
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_polu_4_mfo
			"Cbx_mis_cata_mis_polu_4_mfo"
			VALUE
			0x70757
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_polu_4_pf
			"Cbx_mis_cata_mis_polu_4_pf"
			VALUE
			0x7029F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_polu_4_vf
			"Cbx_mis_cata_mis_polu_4_vf"
			VALUE
			0x70528
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_polu_gas_mfo
			"Cbx_mis_cata_mis_polu_gas_mfo"
			VALUE
			0x70759
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_polu_gas_pf
			"Cbx_mis_cata_mis_polu_gas_pf"
			VALUE
			0x702A1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_polu_gas_vf
			"Cbx_mis_cata_mis_polu_gas_vf"
			VALUE
			0x7052A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_polu_lpg_mfo
			"Cbx_mis_cata_mis_polu_lpg_mfo"
			VALUE
			0x7075A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_polu_lpg_pf
			"Cbx_mis_cata_mis_polu_lpg_pf"
			VALUE
			0x702A2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_polu_lpg_vf
			"Cbx_mis_cata_mis_polu_lpg_vf"
			VALUE
			0x7052B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_polu_mfo
			"Cbx_mis_cata_mis_polu_mfo"
			VALUE
			0x70750
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_polu_pf
			"Cbx_mis_cata_mis_polu_pf"
			VALUE
			0x70298
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mis_polu_vf
			"Cbx_mis_cata_mis_polu_vf"
			VALUE
			0x70521
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mvac_pump_pf
			"Cbx_mis_cata_mvac_pump_pf"
			VALUE
			0x702A3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_mvac_sys_pf
			"Cbx_mis_cata_mvac_sys_pf"
			VALUE
			0x702A4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_obd_cata_mfo
			"Cbx_mis_cata_obd_cata_mfo"
			VALUE
			0x7075B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_obd_cata_pf
			"Cbx_mis_cata_obd_cata_pf"
			VALUE
			0x702A5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_obd_cata_vf
			"Cbx_mis_cata_obd_cata_vf"
			VALUE
			0x7052C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_obd_lamb_mfo
			"Cbx_mis_cata_obd_lamb_mfo"
			VALUE
			0x7075C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_obd_lamb_pf
			"Cbx_mis_cata_obd_lamb_pf"
			VALUE
			0x702A6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_obd_lamb_vf
			"Cbx_mis_cata_obd_lamb_vf"
			VALUE
			0x7052D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_obd_sa_mfo
			"Cbx_mis_cata_obd_sa_mfo"
			VALUE
			0x7075D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_obd_sa_pf
			"Cbx_mis_cata_obd_sa_pf"
			VALUE
			0x702A7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_obd_sa_vf
			"Cbx_mis_cata_obd_sa_vf"
			VALUE
			0x7052E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_oil_pf
			"Cbx_mis_cata_oil_pf"
			VALUE
			0x702A8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_pdl_pf
			"Cbx_mis_cata_pdl_pf"
			VALUE
			0x702A9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_pmh_pf
			"Cbx_mis_cata_pmh_pf"
			VALUE
			0x702AA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_pow_lbdw_mfo
			"Cbx_mis_cata_pow_lbdw_mfo"
			VALUE
			0x7075E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_pow_lbdw_pf
			"Cbx_mis_cata_pow_lbdw_pf"
			VALUE
			0x702AB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_pow_lbdw_vf
			"Cbx_mis_cata_pow_lbdw_vf"
			VALUE
			0x7052F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_pow_lbup_mfo
			"Cbx_mis_cata_pow_lbup_mfo"
			VALUE
			0x7075F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_pow_lbup_pf
			"Cbx_mis_cata_pow_lbup_pf"
			VALUE
			0x702AC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_pow_lbup_vf
			"Cbx_mis_cata_pow_lbup_vf"
			VALUE
			0x70530
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_ptc_pf
			"Cbx_mis_cata_ptc_pf"
			VALUE
			0x702AD
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_ptc_rov_pf
			"Cbx_mis_cata_ptc_rov_pf"
			VALUE
			0x702AE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_pws_pf
			"Cbx_mis_cata_pws_pf"
			VALUE
			0x702AF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_rams_pdl_mfo
			"Cbx_mis_cata_rams_pdl_mfo"
			VALUE
			0x70760
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_rams_pdl_pf
			"Cbx_mis_cata_rams_pdl_pf"
			VALUE
			0x702B1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_rams_pdl_vf
			"Cbx_mis_cata_rams_pdl_vf"
			VALUE
			0x70531
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_rams_pf
			"Cbx_mis_cata_rams_pf"
			VALUE
			0x702B0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_reserve_3_pf
			"Cbx_mis_cata_reserve_3_pf"
			VALUE
			0x702B2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_rmc_pf
			"Cbx_mis_cata_rmc_pf"
			VALUE
			0x702B3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_sa_ev_mfo
			"Cbx_mis_cata_sa_ev_mfo"
			VALUE
			0x7065D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_sa_ev_pf
			"Cbx_mis_cata_sa_ev_pf"
			VALUE
			0x702B5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_sa_ev_vf
			"Cbx_mis_cata_sa_ev_vf"
			VALUE
			0x70500
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_sa_mfo
			"Cbx_mis_cata_sa_mfo"
			VALUE
			0x7065C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_sa_pf
			"Cbx_mis_cata_sa_pf"
			VALUE
			0x702B4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_sa_vf
			"Cbx_mis_cata_sa_vf"
			VALUE
			0x704FF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_spg_mfo
			"Cbx_mis_cata_spg_mfo"
			VALUE
			0x70761
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_spg_pf
			"Cbx_mis_cata_spg_pf"
			VALUE
			0x702B6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_spg_sys_mfo
			"Cbx_mis_cata_spg_sys_mfo"
			VALUE
			0x70762
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_spg_sys_pf
			"Cbx_mis_cata_spg_sys_pf"
			VALUE
			0x702B7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_spg_sys_vf
			"Cbx_mis_cata_spg_sys_vf"
			VALUE
			0x70533
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_spg_vf
			"Cbx_mis_cata_spg_vf"
			VALUE
			0x70532
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_spi_cc_pf
			"Cbx_mis_cata_spi_cc_pf"
			VALUE
			0x702B8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_svkl_pf
			"Cbx_mis_cata_svkl_pf"
			VALUE
			0x702B9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_swlk_pf
			"Cbx_mis_cata_swlk_pf"
			VALUE
			0x702BA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_tco_mfo
			"Cbx_mis_cata_tco_mfo"
			VALUE
			0x7065E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_tco_pf
			"Cbx_mis_cata_tco_pf"
			VALUE
			0x702BB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_tco_vf
			"Cbx_mis_cata_tco_vf"
			VALUE
			0x70501
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_thpl_pf
			"Cbx_mis_cata_thpl_pf"
			VALUE
			0x702BC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_thr_cmd_pf
			"Cbx_mis_cata_thr_cmd_pf"
			VALUE
			0x702BE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_thr_pf
			"Cbx_mis_cata_thr_pf"
			VALUE
			0x702BD
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_tia_mfo
			"Cbx_mis_cata_tia_mfo"
			VALUE
			0x7065F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_tia_pf
			"Cbx_mis_cata_tia_pf"
			VALUE
			0x702BF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_tia_vf
			"Cbx_mis_cata_tia_vf"
			VALUE
			0x70502
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_tjy_ctl_pf
			"Cbx_mis_cata_tjy_ctl_pf"
			VALUE
			0x702C0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_tlz_ad_b_mfo
			"Cbx_mis_cata_tlz_ad_b_mfo"
			VALUE
			0x70763
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_tlz_ad_b_pf
			"Cbx_mis_cata_tlz_ad_b_pf"
			VALUE
			0x702C1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_tlz_ad_b_vf
			"Cbx_mis_cata_tlz_ad_b_vf"
			VALUE
			0x70534
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_vb_pf
			"Cbx_mis_cata_vb_pf"
			VALUE
			0x702C2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_vs_mfo
			"Cbx_mis_cata_vs_mfo"
			VALUE
			0x70660
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_vs_pf
			"Cbx_mis_cata_vs_pf"
			VALUE
			0x702C3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_vs_vf
			"Cbx_mis_cata_vs_vf"
			VALUE
			0x70503
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_vta_intake_mfo
			"Cbx_mis_cata_vta_intake_mfo"
			VALUE
			0x70661
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_vta_intake_pf
			"Cbx_mis_cata_vta_intake_pf"
			VALUE
			0x702C4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_vta_intake_vf
			"Cbx_mis_cata_vta_intake_vf"
			VALUE
			0x70504
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_vvt_int_ev_mfo
			"Cbx_mis_cata_vvt_int_ev_mfo"
			VALUE
			0x70662
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_vvt_int_ev_pf
			"Cbx_mis_cata_vvt_int_ev_pf"
			VALUE
			0x702C6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_vvt_int_ev_vf
			"Cbx_mis_cata_vvt_int_ev_vf"
			VALUE
			0x70505
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_vvt_int_old_off_mfo
			"Cbx_mis_cata_vvt_int_old_off_mfo"
			VALUE
			0x70764
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_vvt_int_old_off_vf
			"Cbx_mis_cata_vvt_int_old_off_vf"
			VALUE
			0x70535
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_vvt_int_pf
			"Cbx_mis_cata_vvt_int_pf"
			VALUE
			0x702C5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_vvt_intake_mfo
			"Cbx_mis_cata_vvt_intake_mfo"
			VALUE
			0x70663
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_vvt_intake_pf
			"Cbx_mis_cata_vvt_intake_pf"
			VALUE
			0x702C7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_vvt_intake_vf
			"Cbx_mis_cata_vvt_intake_vf"
			VALUE
			0x70506
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_vvtc_toth_3_mfo
			"Cbx_mis_cata_vvtc_toth_3_mfo"
			VALUE
			0x70765
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_vvtc_toth_3_pf
			"Cbx_mis_cata_vvtc_toth_3_pf"
			VALUE
			0x702C8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_vvtc_toth_3_vf
			"Cbx_mis_cata_vvtc_toth_3_vf"
			VALUE
			0x70536
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_wat_temp_pf
			"Cbx_mis_cata_wat_temp_pf"
			VALUE
			0x702C9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_wgc_mfo
			"Cbx_mis_cata_wgc_mfo"
			VALUE
			0x70664
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_wgc_pf
			"Cbx_mis_cata_wgc_pf"
			VALUE
			0x702CA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_wgc_vf
			"Cbx_mis_cata_wgc_vf"
			VALUE
			0x70507
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_cata_wpmp_pf
			"Cbx_mis_cata_wpmp_pf"
			VALUE
			0x702CB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_lih_conf
			"Cbx_mis_lih_conf"
			VALUE
			0x77025
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_ac_prs_pf
			"Cbx_mis_polu_ac_prs_pf"
			VALUE
			0x701EA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_ac_rcpt_pf
			"Cbx_mis_polu_ac_rcpt_pf"
			VALUE
			0x701EB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_acr_pf
			"Cbx_mis_polu_acr_pf"
			VALUE
			0x701EC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_actr_rly_cut_pf
			"Cbx_mis_polu_actr_rly_cut_pf"
			VALUE
			0x701EE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_actr_rly_pf
			"Cbx_mis_polu_actr_rly_pf"
			VALUE
			0x701ED
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_agb_pf
			"Cbx_mis_polu_agb_pf"
			VALUE
			0x701EF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_agb_rcpt_mfo
			"Cbx_mis_polu_agb_rcpt_mfo"
			VALUE
			0x70708
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_agb_rcpt_vf
			"Cbx_mis_polu_agb_rcpt_vf"
			VALUE
			0x704C2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_air_mfo
			"Cbx_mis_polu_air_mfo"
			VALUE
			0x70709
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_air_pf
			"Cbx_mis_polu_air_pf"
			VALUE
			0x701F0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_air_vf
			"Cbx_mis_polu_air_vf"
			VALUE
			0x704C3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_alt_load_in_pf
			"Cbx_mis_polu_alt_load_in_pf"
			VALUE
			0x701F2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_alt_pf
			"Cbx_mis_polu_alt_pf"
			VALUE
			0x701F1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_bkup_mem_mfo
			"Cbx_mis_polu_bkup_mem_mfo"
			VALUE
			0x7070A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_bkup_mem_pf
			"Cbx_mis_polu_bkup_mem_pf"
			VALUE
			0x701F3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_bkup_mem_vf
			"Cbx_mis_polu_bkup_mem_vf"
			VALUE
			0x704C4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_checksum_pf
			"Cbx_mis_polu_checksum_pf"
			VALUE
			0x701F4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_clu_mfo
			"Cbx_mis_polu_clu_mfo"
			VALUE
			0x7070B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_clu_pf
			"Cbx_mis_polu_clu_pf"
			VALUE
			0x701F5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_clu_vf
			"Cbx_mis_polu_clu_vf"
			VALUE
			0x704C5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_cp_mfo
			"Cbx_mis_polu_cp_mfo"
			VALUE
			0x70637
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_cp_pf
			"Cbx_mis_polu_cp_pf"
			VALUE
			0x701F6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_cp_vf
			"Cbx_mis_polu_cp_vf"
			VALUE
			0x704AB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_crk_mfo
			"Cbx_mis_polu_crk_mfo"
			VALUE
			0x7070C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_crk_nr_mfo
			"Cbx_mis_polu_crk_nr_mfo"
			VALUE
			0x7070D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_crk_nr_pf
			"Cbx_mis_polu_crk_nr_pf"
			VALUE
			0x701F8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_crk_nr_vf
			"Cbx_mis_polu_crk_nr_vf"
			VALUE
			0x704C7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_crk_pf
			"Cbx_mis_polu_crk_pf"
			VALUE
			0x701F7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_crk_vf
			"Cbx_mis_polu_crk_vf"
			VALUE
			0x704C6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_cru_pf
			"Cbx_mis_polu_cru_pf"
			VALUE
			0x701F9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_el_wind_rcpt_pf
			"Cbx_mis_polu_el_wind_rcpt_pf"
			VALUE
			0x701FA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_eng_temp_pf
			"Cbx_mis_polu_eng_temp_pf"
			VALUE
			0x701FB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_eng_whl_mfo
			"Cbx_mis_polu_eng_whl_mfo"
			VALUE
			0x7070E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_eng_whl_pf
			"Cbx_mis_polu_eng_whl_pf"
			VALUE
			0x701FC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_eng_whl_vf
			"Cbx_mis_polu_eng_whl_vf"
			VALUE
			0x704C8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_fsys_lpg_mfo
			"Cbx_mis_polu_fsys_lpg_mfo"
			VALUE
			0x70710
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_fsys_lpg_pf
			"Cbx_mis_polu_fsys_lpg_pf"
			VALUE
			0x701FE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_fsys_lpg_vf
			"Cbx_mis_polu_fsys_lpg_vf"
			VALUE
			0x704CA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_fsys_mfo
			"Cbx_mis_polu_fsys_mfo"
			VALUE
			0x7070F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_fsys_pf
			"Cbx_mis_polu_fsys_pf"
			VALUE
			0x701FD
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_fsys_vf
			"Cbx_mis_polu_fsys_vf"
			VALUE
			0x704C9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_gas_pump_mfo
			"Cbx_mis_polu_gas_pump_mfo"
			VALUE
			0x70638
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_gas_pump_pf
			"Cbx_mis_polu_gas_pump_pf"
			VALUE
			0x701FF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_gas_pump_vf
			"Cbx_mis_polu_gas_pump_vf"
			VALUE
			0x704AC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_igc_1_mfo
			"Cbx_mis_polu_igc_1_mfo"
			VALUE
			0x70639
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_igc_1_pf
			"Cbx_mis_polu_igc_1_pf"
			VALUE
			0x70200
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_igc_1_vf
			"Cbx_mis_polu_igc_1_vf"
			VALUE
			0x704AD
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_igc_2_mfo
			"Cbx_mis_polu_igc_2_mfo"
			VALUE
			0x7063A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_igc_2_pf
			"Cbx_mis_polu_igc_2_pf"
			VALUE
			0x70201
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_igc_2_vf
			"Cbx_mis_polu_igc_2_vf"
			VALUE
			0x704AE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_igc_3_mfo
			"Cbx_mis_polu_igc_3_mfo"
			VALUE
			0x7063B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_igc_3_pf
			"Cbx_mis_polu_igc_3_pf"
			VALUE
			0x70202
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_igc_3_vf
			"Cbx_mis_polu_igc_3_vf"
			VALUE
			0x704AF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_igc_4_mfo
			"Cbx_mis_polu_igc_4_mfo"
			VALUE
			0x7063C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_igc_4_pf
			"Cbx_mis_polu_igc_4_pf"
			VALUE
			0x70203
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_igc_4_vf
			"Cbx_mis_polu_igc_4_vf"
			VALUE
			0x704B0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_inj1_mfo
			"Cbx_mis_polu_inj1_mfo"
			VALUE
			0x7063D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_inj1_pf
			"Cbx_mis_polu_inj1_pf"
			VALUE
			0x70204
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_inj1_vf
			"Cbx_mis_polu_inj1_vf"
			VALUE
			0x704B1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_inj2_mfo
			"Cbx_mis_polu_inj2_mfo"
			VALUE
			0x7063E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_inj2_pf
			"Cbx_mis_polu_inj2_pf"
			VALUE
			0x70205
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_inj2_vf
			"Cbx_mis_polu_inj2_vf"
			VALUE
			0x704B2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_inj3_mfo
			"Cbx_mis_polu_inj3_mfo"
			VALUE
			0x7063F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_inj3_pf
			"Cbx_mis_polu_inj3_pf"
			VALUE
			0x70206
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_inj3_vf
			"Cbx_mis_polu_inj3_vf"
			VALUE
			0x704B3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_inj4_mfo
			"Cbx_mis_polu_inj4_mfo"
			VALUE
			0x70640
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_inj4_pf
			"Cbx_mis_polu_inj4_pf"
			VALUE
			0x70207
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_inj4_vf
			"Cbx_mis_polu_inj4_vf"
			VALUE
			0x704B4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_inj_ecu_mfo
			"Cbx_mis_polu_inj_ecu_mfo"
			VALUE
			0x70711
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_inj_ecu_pf
			"Cbx_mis_polu_inj_ecu_pf"
			VALUE
			0x70208
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_inj_ecu_vf
			"Cbx_mis_polu_inj_ecu_vf"
			VALUE
			0x704CB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_ip_inj_cnt_pf
			"Cbx_mis_polu_ip_inj_cnt_pf"
			VALUE
			0x70209
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_knk_mfo
			"Cbx_mis_polu_knk_mfo"
			VALUE
			0x70712
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_knk_pf
			"Cbx_mis_polu_knk_pf"
			VALUE
			0x7020A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_knk_vf
			"Cbx_mis_polu_knk_vf"
			VALUE
			0x704CC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_lbdw_hot_mfo
			"Cbx_mis_polu_lbdw_hot_mfo"
			VALUE
			0x70642
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_lbdw_hot_pf
			"Cbx_mis_polu_lbdw_hot_pf"
			VALUE
			0x7020C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_lbdw_hot_vf
			"Cbx_mis_polu_lbdw_hot_vf"
			VALUE
			0x704B6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_lbdw_mfo
			"Cbx_mis_polu_lbdw_mfo"
			VALUE
			0x70641
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_lbdw_pf
			"Cbx_mis_polu_lbdw_pf"
			VALUE
			0x7020B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_lbdw_pump_crt_pf
			"Cbx_mis_polu_lbdw_pump_crt_pf"
			VALUE
			0x7020D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_lbdw_vf
			"Cbx_mis_polu_lbdw_vf"
			VALUE
			0x704B5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_lbup_hot_mfo
			"Cbx_mis_polu_lbup_hot_mfo"
			VALUE
			0x70644
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_lbup_hot_pf
			"Cbx_mis_polu_lbup_hot_pf"
			VALUE
			0x7020F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_lbup_hot_vf
			"Cbx_mis_polu_lbup_hot_vf"
			VALUE
			0x704B8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_lbup_mfo
			"Cbx_mis_polu_lbup_mfo"
			VALUE
			0x70643
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_lbup_pf
			"Cbx_mis_polu_lbup_pf"
			VALUE
			0x7020E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_lbup_pump_crt_pf
			"Cbx_mis_polu_lbup_pump_crt_pf"
			VALUE
			0x70210
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_lbup_vf
			"Cbx_mis_polu_lbup_vf"
			VALUE
			0x704B7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_lpg_rcpt_mfo
			"Cbx_mis_polu_lpg_rcpt_mfo"
			VALUE
			0x70713
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_lpg_rcpt_pf
			"Cbx_mis_polu_lpg_rcpt_pf"
			VALUE
			0x70211
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_lpg_rcpt_vf
			"Cbx_mis_polu_lpg_rcpt_vf"
			VALUE
			0x704CD
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_map_chr_pf
			"Cbx_mis_polu_map_chr_pf"
			VALUE
			0x70213
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_map_mfo
			"Cbx_mis_polu_map_mfo"
			VALUE
			0x70714
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_map_pf
			"Cbx_mis_polu_map_pf"
			VALUE
			0x70212
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_map_vf
			"Cbx_mis_polu_map_vf"
			VALUE
			0x704CE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mastervac_pf
			"Cbx_mis_polu_mastervac_pf"
			VALUE
			0x70214
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mcut_sens1_pf
			"Cbx_mis_polu_mcut_sens1_pf"
			VALUE
			0x70215
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mdf1_pf
			"Cbx_mis_polu_mdf1_pf"
			VALUE
			0x70216
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mdf2_pf
			"Cbx_mis_polu_mdf2_pf"
			VALUE
			0x70217
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_min_gas_lvl_mfo
			"Cbx_mis_polu_min_gas_lvl_mfo"
			VALUE
			0x70715
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_min_gas_lvl_pf
			"Cbx_mis_polu_min_gas_lvl_pf"
			VALUE
			0x70218
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_min_gas_lvl_vf
			"Cbx_mis_polu_min_gas_lvl_vf"
			VALUE
			0x704CF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_min_lpg_lvl_pf
			"Cbx_mis_polu_min_lpg_lvl_pf"
			VALUE
			0x70219
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_cata_1_lpg_mfo
			"Cbx_mis_polu_mis_cata_1_lpg_mfo"
			VALUE
			0x70718
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_cata_1_lpg_pf
			"Cbx_mis_polu_mis_cata_1_lpg_pf"
			VALUE
			0x7021C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_cata_1_lpg_vf
			"Cbx_mis_polu_mis_cata_1_lpg_vf"
			VALUE
			0x704D2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_cata_1_mfo
			"Cbx_mis_polu_mis_cata_1_mfo"
			VALUE
			0x70717
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_cata_1_pf
			"Cbx_mis_polu_mis_cata_1_pf"
			VALUE
			0x7021B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_cata_1_vf
			"Cbx_mis_polu_mis_cata_1_vf"
			VALUE
			0x704D1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_cata_2_lpg_mfo
			"Cbx_mis_polu_mis_cata_2_lpg_mfo"
			VALUE
			0x7071A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_cata_2_lpg_pf
			"Cbx_mis_polu_mis_cata_2_lpg_pf"
			VALUE
			0x7021E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_cata_2_lpg_vf
			"Cbx_mis_polu_mis_cata_2_lpg_vf"
			VALUE
			0x704D4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_cata_2_mfo
			"Cbx_mis_polu_mis_cata_2_mfo"
			VALUE
			0x70719
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_cata_2_pf
			"Cbx_mis_polu_mis_cata_2_pf"
			VALUE
			0x7021D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_cata_2_vf
			"Cbx_mis_polu_mis_cata_2_vf"
			VALUE
			0x704D3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_cata_3_lpg_mfo
			"Cbx_mis_polu_mis_cata_3_lpg_mfo"
			VALUE
			0x7071C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_cata_3_lpg_pf
			"Cbx_mis_polu_mis_cata_3_lpg_pf"
			VALUE
			0x70220
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_cata_3_lpg_vf
			"Cbx_mis_polu_mis_cata_3_lpg_vf"
			VALUE
			0x704D6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_cata_3_mfo
			"Cbx_mis_polu_mis_cata_3_mfo"
			VALUE
			0x7071B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_cata_3_pf
			"Cbx_mis_polu_mis_cata_3_pf"
			VALUE
			0x7021F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_cata_3_vf
			"Cbx_mis_polu_mis_cata_3_vf"
			VALUE
			0x704D5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_cata_4_lpg_mfo
			"Cbx_mis_polu_mis_cata_4_lpg_mfo"
			VALUE
			0x7071E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_cata_4_lpg_pf
			"Cbx_mis_polu_mis_cata_4_lpg_pf"
			VALUE
			0x70222
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_cata_4_lpg_vf
			"Cbx_mis_polu_mis_cata_4_lpg_vf"
			VALUE
			0x704D8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_cata_4_mfo
			"Cbx_mis_polu_mis_cata_4_mfo"
			VALUE
			0x7071D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_cata_4_pf
			"Cbx_mis_polu_mis_cata_4_pf"
			VALUE
			0x70221
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_cata_4_vf
			"Cbx_mis_polu_mis_cata_4_vf"
			VALUE
			0x704D7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_cata_gas_mfo
			"Cbx_mis_polu_mis_cata_gas_mfo"
			VALUE
			0x7071F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_cata_gas_pf
			"Cbx_mis_polu_mis_cata_gas_pf"
			VALUE
			0x70223
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_cata_gas_vf
			"Cbx_mis_polu_mis_cata_gas_vf"
			VALUE
			0x704D9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_cata_lpg_mfo
			"Cbx_mis_polu_mis_cata_lpg_mfo"
			VALUE
			0x70720
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_cata_lpg_pf
			"Cbx_mis_polu_mis_cata_lpg_pf"
			VALUE
			0x70224
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_cata_lpg_vf
			"Cbx_mis_polu_mis_cata_lpg_vf"
			VALUE
			0x704DA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_cata_mfo
			"Cbx_mis_polu_mis_cata_mfo"
			VALUE
			0x70716
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_cata_pf
			"Cbx_mis_polu_mis_cata_pf"
			VALUE
			0x7021A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_cata_vf
			"Cbx_mis_polu_mis_cata_vf"
			VALUE
			0x704D0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_fast_pf
			"Cbx_mis_polu_mis_fast_pf"
			VALUE
			0x70225
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_lih_pf
			"Cbx_mis_polu_mis_lih_pf"
			VALUE
			0x70226
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_polu_1_lpg_mfo
			"Cbx_mis_polu_mis_polu_1_lpg_mfo"
			VALUE
			0x70723
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_polu_1_lpg_pf
			"Cbx_mis_polu_mis_polu_1_lpg_pf"
			VALUE
			0x70229
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_polu_1_lpg_vf
			"Cbx_mis_polu_mis_polu_1_lpg_vf"
			VALUE
			0x704DD
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_polu_1_mfo
			"Cbx_mis_polu_mis_polu_1_mfo"
			VALUE
			0x70722
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_polu_1_pf
			"Cbx_mis_polu_mis_polu_1_pf"
			VALUE
			0x70228
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_polu_1_vf
			"Cbx_mis_polu_mis_polu_1_vf"
			VALUE
			0x704DC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_polu_2_lpg_mfo
			"Cbx_mis_polu_mis_polu_2_lpg_mfo"
			VALUE
			0x70725
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_polu_2_lpg_pf
			"Cbx_mis_polu_mis_polu_2_lpg_pf"
			VALUE
			0x7022B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_polu_2_lpg_vf
			"Cbx_mis_polu_mis_polu_2_lpg_vf"
			VALUE
			0x704DF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_polu_2_mfo
			"Cbx_mis_polu_mis_polu_2_mfo"
			VALUE
			0x70724
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_polu_2_pf
			"Cbx_mis_polu_mis_polu_2_pf"
			VALUE
			0x7022A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_polu_2_vf
			"Cbx_mis_polu_mis_polu_2_vf"
			VALUE
			0x704DE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_polu_3_lpg_mfo
			"Cbx_mis_polu_mis_polu_3_lpg_mfo"
			VALUE
			0x70727
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_polu_3_lpg_pf
			"Cbx_mis_polu_mis_polu_3_lpg_pf"
			VALUE
			0x7022D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_polu_3_lpg_vf
			"Cbx_mis_polu_mis_polu_3_lpg_vf"
			VALUE
			0x704E1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_polu_3_mfo
			"Cbx_mis_polu_mis_polu_3_mfo"
			VALUE
			0x70726
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_polu_3_pf
			"Cbx_mis_polu_mis_polu_3_pf"
			VALUE
			0x7022C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_polu_3_vf
			"Cbx_mis_polu_mis_polu_3_vf"
			VALUE
			0x704E0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_polu_4_lpg_mfo
			"Cbx_mis_polu_mis_polu_4_lpg_mfo"
			VALUE
			0x70729
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_polu_4_lpg_pf
			"Cbx_mis_polu_mis_polu_4_lpg_pf"
			VALUE
			0x7022F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_polu_4_lpg_vf
			"Cbx_mis_polu_mis_polu_4_lpg_vf"
			VALUE
			0x704E3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_polu_4_mfo
			"Cbx_mis_polu_mis_polu_4_mfo"
			VALUE
			0x70728
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_polu_4_pf
			"Cbx_mis_polu_mis_polu_4_pf"
			VALUE
			0x7022E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_polu_4_vf
			"Cbx_mis_polu_mis_polu_4_vf"
			VALUE
			0x704E2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_polu_gas_mfo
			"Cbx_mis_polu_mis_polu_gas_mfo"
			VALUE
			0x7072A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_polu_gas_pf
			"Cbx_mis_polu_mis_polu_gas_pf"
			VALUE
			0x70230
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_polu_gas_vf
			"Cbx_mis_polu_mis_polu_gas_vf"
			VALUE
			0x704E4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_polu_lpg_mfo
			"Cbx_mis_polu_mis_polu_lpg_mfo"
			VALUE
			0x7072B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_polu_lpg_pf
			"Cbx_mis_polu_mis_polu_lpg_pf"
			VALUE
			0x70231
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_polu_lpg_vf
			"Cbx_mis_polu_mis_polu_lpg_vf"
			VALUE
			0x704E5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_polu_mfo
			"Cbx_mis_polu_mis_polu_mfo"
			VALUE
			0x70721
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_polu_pf
			"Cbx_mis_polu_mis_polu_pf"
			VALUE
			0x70227
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mis_polu_vf
			"Cbx_mis_polu_mis_polu_vf"
			VALUE
			0x704DB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mvac_pump_pf
			"Cbx_mis_polu_mvac_pump_pf"
			VALUE
			0x70232
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_mvac_sys_pf
			"Cbx_mis_polu_mvac_sys_pf"
			VALUE
			0x70233
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_obd_cata_mfo
			"Cbx_mis_polu_obd_cata_mfo"
			VALUE
			0x7072C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_obd_cata_pf
			"Cbx_mis_polu_obd_cata_pf"
			VALUE
			0x70234
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_obd_cata_vf
			"Cbx_mis_polu_obd_cata_vf"
			VALUE
			0x704E6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_obd_lamb_mfo
			"Cbx_mis_polu_obd_lamb_mfo"
			VALUE
			0x7072D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_obd_lamb_pf
			"Cbx_mis_polu_obd_lamb_pf"
			VALUE
			0x70235
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_obd_lamb_vf
			"Cbx_mis_polu_obd_lamb_vf"
			VALUE
			0x704E7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_obd_sa_mfo
			"Cbx_mis_polu_obd_sa_mfo"
			VALUE
			0x7072E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_obd_sa_pf
			"Cbx_mis_polu_obd_sa_pf"
			VALUE
			0x70236
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_obd_sa_vf
			"Cbx_mis_polu_obd_sa_vf"
			VALUE
			0x704E8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_oil_pf
			"Cbx_mis_polu_oil_pf"
			VALUE
			0x70237
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_pdl_pf
			"Cbx_mis_polu_pdl_pf"
			VALUE
			0x70238
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_pmh_pf
			"Cbx_mis_polu_pmh_pf"
			VALUE
			0x70239
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_pow_lbdw_mfo
			"Cbx_mis_polu_pow_lbdw_mfo"
			VALUE
			0x7072F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_pow_lbdw_pf
			"Cbx_mis_polu_pow_lbdw_pf"
			VALUE
			0x7023A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_pow_lbdw_vf
			"Cbx_mis_polu_pow_lbdw_vf"
			VALUE
			0x704E9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_pow_lbup_mfo
			"Cbx_mis_polu_pow_lbup_mfo"
			VALUE
			0x70730
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_pow_lbup_pf
			"Cbx_mis_polu_pow_lbup_pf"
			VALUE
			0x7023B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_pow_lbup_vf
			"Cbx_mis_polu_pow_lbup_vf"
			VALUE
			0x704EA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_ptc_pf
			"Cbx_mis_polu_ptc_pf"
			VALUE
			0x7023C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_ptc_rov_pf
			"Cbx_mis_polu_ptc_rov_pf"
			VALUE
			0x7023D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_pws_pf
			"Cbx_mis_polu_pws_pf"
			VALUE
			0x7023E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_rams_pdl_mfo
			"Cbx_mis_polu_rams_pdl_mfo"
			VALUE
			0x70731
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_rams_pdl_pf
			"Cbx_mis_polu_rams_pdl_pf"
			VALUE
			0x70240
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_rams_pdl_vf
			"Cbx_mis_polu_rams_pdl_vf"
			VALUE
			0x704EB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_rams_pf
			"Cbx_mis_polu_rams_pf"
			VALUE
			0x7023F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_reserve_3_pf
			"Cbx_mis_polu_reserve_3_pf"
			VALUE
			0x70241
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_rmc_pf
			"Cbx_mis_polu_rmc_pf"
			VALUE
			0x70242
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_sa_ev_mfo
			"Cbx_mis_polu_sa_ev_mfo"
			VALUE
			0x70646
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_sa_ev_pf
			"Cbx_mis_polu_sa_ev_pf"
			VALUE
			0x70244
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_sa_ev_vf
			"Cbx_mis_polu_sa_ev_vf"
			VALUE
			0x704BA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_sa_mfo
			"Cbx_mis_polu_sa_mfo"
			VALUE
			0x70645
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_sa_pf
			"Cbx_mis_polu_sa_pf"
			VALUE
			0x70243
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_sa_vf
			"Cbx_mis_polu_sa_vf"
			VALUE
			0x704B9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_spg_mfo
			"Cbx_mis_polu_spg_mfo"
			VALUE
			0x70732
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_spg_pf
			"Cbx_mis_polu_spg_pf"
			VALUE
			0x70245
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_spg_sys_mfo
			"Cbx_mis_polu_spg_sys_mfo"
			VALUE
			0x70733
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_spg_sys_pf
			"Cbx_mis_polu_spg_sys_pf"
			VALUE
			0x70246
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_spg_sys_vf
			"Cbx_mis_polu_spg_sys_vf"
			VALUE
			0x704ED
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_spg_vf
			"Cbx_mis_polu_spg_vf"
			VALUE
			0x704EC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_spi_cc_pf
			"Cbx_mis_polu_spi_cc_pf"
			VALUE
			0x70247
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_svkl_pf
			"Cbx_mis_polu_svkl_pf"
			VALUE
			0x70248
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_swlk_pf
			"Cbx_mis_polu_swlk_pf"
			VALUE
			0x70249
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_tco_mfo
			"Cbx_mis_polu_tco_mfo"
			VALUE
			0x70647
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_tco_pf
			"Cbx_mis_polu_tco_pf"
			VALUE
			0x7024A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_tco_vf
			"Cbx_mis_polu_tco_vf"
			VALUE
			0x704BB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_thpl_pf
			"Cbx_mis_polu_thpl_pf"
			VALUE
			0x7024B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_thr_cmd_pf
			"Cbx_mis_polu_thr_cmd_pf"
			VALUE
			0x7024D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_thr_pf
			"Cbx_mis_polu_thr_pf"
			VALUE
			0x7024C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_tia_mfo
			"Cbx_mis_polu_tia_mfo"
			VALUE
			0x70648
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_tia_pf
			"Cbx_mis_polu_tia_pf"
			VALUE
			0x7024E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_tia_vf
			"Cbx_mis_polu_tia_vf"
			VALUE
			0x704BC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_tjy_ctl_pf
			"Cbx_mis_polu_tjy_ctl_pf"
			VALUE
			0x7024F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_tlz_ad_b_mfo
			"Cbx_mis_polu_tlz_ad_b_mfo"
			VALUE
			0x70734
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_tlz_ad_b_pf
			"Cbx_mis_polu_tlz_ad_b_pf"
			VALUE
			0x70250
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_tlz_ad_b_vf
			"Cbx_mis_polu_tlz_ad_b_vf"
			VALUE
			0x704EE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_vb_pf
			"Cbx_mis_polu_vb_pf"
			VALUE
			0x70251
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_vs_mfo
			"Cbx_mis_polu_vs_mfo"
			VALUE
			0x70649
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_vs_pf
			"Cbx_mis_polu_vs_pf"
			VALUE
			0x70252
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_vs_vf
			"Cbx_mis_polu_vs_vf"
			VALUE
			0x704BD
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_vta_intake_mfo
			"Cbx_mis_polu_vta_intake_mfo"
			VALUE
			0x7064A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_vta_intake_pf
			"Cbx_mis_polu_vta_intake_pf"
			VALUE
			0x70253
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_vta_intake_vf
			"Cbx_mis_polu_vta_intake_vf"
			VALUE
			0x704BE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_vvt_int_ev_mfo
			"Cbx_mis_polu_vvt_int_ev_mfo"
			VALUE
			0x7064B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_vvt_int_ev_pf
			"Cbx_mis_polu_vvt_int_ev_pf"
			VALUE
			0x70255
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_vvt_int_ev_vf
			"Cbx_mis_polu_vvt_int_ev_vf"
			VALUE
			0x704BF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_vvt_int_old_off_mfo
			"Cbx_mis_polu_vvt_int_old_off_mfo"
			VALUE
			0x70735
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_vvt_int_old_off_vf
			"Cbx_mis_polu_vvt_int_old_off_vf"
			VALUE
			0x704EF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_vvt_int_pf
			"Cbx_mis_polu_vvt_int_pf"
			VALUE
			0x70254
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_vvt_intake_mfo
			"Cbx_mis_polu_vvt_intake_mfo"
			VALUE
			0x7064C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_vvt_intake_pf
			"Cbx_mis_polu_vvt_intake_pf"
			VALUE
			0x70256
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_vvt_intake_vf
			"Cbx_mis_polu_vvt_intake_vf"
			VALUE
			0x704C0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_vvtc_toth_3_mfo
			"Cbx_mis_polu_vvtc_toth_3_mfo"
			VALUE
			0x70736
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_vvtc_toth_3_pf
			"Cbx_mis_polu_vvtc_toth_3_pf"
			VALUE
			0x70257
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_vvtc_toth_3_vf
			"Cbx_mis_polu_vvtc_toth_3_vf"
			VALUE
			0x704F0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_wat_temp_pf
			"Cbx_mis_polu_wat_temp_pf"
			VALUE
			0x70258
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_wgc_mfo
			"Cbx_mis_polu_wgc_mfo"
			VALUE
			0x7064D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_wgc_pf
			"Cbx_mis_polu_wgc_pf"
			VALUE
			0x70259
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_wgc_vf
			"Cbx_mis_polu_wgc_vf"
			VALUE
			0x704C1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mis_polu_wpmp_pf
			"Cbx_mis_polu_wpmp_pf"
			VALUE
			0x7025A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mod_bch_diag_cata
			"Cbx_mod_bch_diag_cata"
			VALUE
			0x77026
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mod_bch_diag_lamb
			"Cbx_mod_bch_diag_lamb"
			VALUE
			0x77027
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mod_bch_diag_sa
			"Cbx_mod_bch_diag_sa"
			VALUE
			0x77028
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mux_conf_mil
			"Cbx_mux_conf_mil"
			VALUE
			0x71E9A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mux_ct_conf
			"Cbx_mux_ct_conf"
			VALUE
			0x790F6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mux_pwst_prs_dsb
			"Cbx_mux_pwst_prs_dsb"
			VALUE
			0x7360C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mv_fac_ini_req
			"Cbx_mv_fac_ini_req"
			VALUE
			0x731AA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mv_ofs_ini_req
			"Cbx_mv_ofs_ini_req"
			VALUE
			0x731AB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_mvac_pump_conf
			"Cbx_mvac_pump_conf"
			VALUE
			0x73706
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_obd_fail_dft_ini_req
			"Cbx_obd_fail_dft_ini_req"
			VALUE
			0x731AC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ol_cl_sp_conf
			"Cbx_ol_cl_sp_conf"
			VALUE
			0x74876
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_on_ac_cor_dsb
			"Cbx_on_ac_cor_dsb"
			VALUE
			0x7386E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_on_mdf_cor_dsb
			"Cbx_on_mdf_cor_dsb"
			VALUE
			0x7386F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_on_ptc_cor_dsb
			"Cbx_on_ptc_cor_dsb"
			VALUE
			0x73870
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_on_pwst_cor_dsb
			"Cbx_on_pwst_cor_dsb"
			VALUE
			0x73871
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_on_tia_fail_cor_dsb
			"Cbx_on_tia_fail_cor_dsb"
			VALUE
			0x73872
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ovn_tq_cor_dsb
			"Cbx_ovn_tq_cor_dsb"
			VALUE
			0x76FA4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_prs_sp_dsb
			"Cbx_prs_sp_dsb"
			VALUE
			0x76FA5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_prs_trs_iga_cor_dsb
			"Cbx_prs_trs_iga_cor_dsb"
			VALUE
			0x76FA6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ptc_max_cut_ena_lim
			"Cbx_ptc_max_cut_ena_lim"
			VALUE
			0x7874C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ptc_max_pow_ena_lim
			"Cbx_ptc_max_pow_ena_lim"
			VALUE
			0x7874D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_rams_ena_diag_ma
			"Cbx_rams_ena_diag_ma"
			VALUE
			0x790F7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_rams_lpg_lpg_mod_ena
			"Cbx_rams_lpg_lpg_mod_ena"
			VALUE
			0x790F8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_rams_ovt_act
			"Cbx_rams_ovt_act"
			VALUE
			0x790F9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_rams_tq_loss_ad_dsb
			"Cbx_rams_tq_loss_ad_dsb"
			VALUE
			0x790FA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_raw_whl_angl_dsb
			"Cbx_raw_whl_angl_dsb"
			VALUE
			0x7360D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_rgb_conf
			"Cbx_rgb_conf"
			VALUE
			0x78A81
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_rgb_dyn_iga_cor_dsb
			"Cbx_rgb_dyn_iga_cor_dsb"
			VALUE
			0x76FA7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_rich_dstb_iga_cor
			"Cbx_rich_dstb_iga_cor"
			VALUE
			0x70FD8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_ac_prs_pf
			"Cbx_sa_ac_prs_pf"
			VALUE
			0x7033D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_ac_rcpt_pf
			"Cbx_sa_ac_rcpt_pf"
			VALUE
			0x7033E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_acr_pf
			"Cbx_sa_acr_pf"
			VALUE
			0x7033F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_actr_rly_cut_pf
			"Cbx_sa_actr_rly_cut_pf"
			VALUE
			0x70341
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_actr_rly_pf
			"Cbx_sa_actr_rly_pf"
			VALUE
			0x70340
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_agb_pf
			"Cbx_sa_agb_pf"
			VALUE
			0x70342
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_agb_rcpt_mfo
			"Cbx_sa_agb_rcpt_mfo"
			VALUE
			0x70795
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_agb_rcpt_vf
			"Cbx_sa_agb_rcpt_vf"
			VALUE
			0x70594
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_air_mfo
			"Cbx_sa_air_mfo"
			VALUE
			0x70796
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_air_pf
			"Cbx_sa_air_pf"
			VALUE
			0x70343
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_air_vf
			"Cbx_sa_air_vf"
			VALUE
			0x70595
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_alt_load_in_pf
			"Cbx_sa_alt_load_in_pf"
			VALUE
			0x70345
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_alt_pf
			"Cbx_sa_alt_pf"
			VALUE
			0x70344
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_bkup_mem_mfo
			"Cbx_sa_bkup_mem_mfo"
			VALUE
			0x70797
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_bkup_mem_pf
			"Cbx_sa_bkup_mem_pf"
			VALUE
			0x70346
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_bkup_mem_vf
			"Cbx_sa_bkup_mem_vf"
			VALUE
			0x70596
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_checksum_pf
			"Cbx_sa_checksum_pf"
			VALUE
			0x70347
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_clu_mfo
			"Cbx_sa_clu_mfo"
			VALUE
			0x70798
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_clu_pf
			"Cbx_sa_clu_pf"
			VALUE
			0x70348
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_clu_vf
			"Cbx_sa_clu_vf"
			VALUE
			0x70597
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_cp_mfo
			"Cbx_sa_cp_mfo"
			VALUE
			0x7067C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_cp_pf
			"Cbx_sa_cp_pf"
			VALUE
			0x70349
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_cp_vf
			"Cbx_sa_cp_vf"
			VALUE
			0x7057D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_crk_mfo
			"Cbx_sa_crk_mfo"
			VALUE
			0x70799
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_crk_nr_mfo
			"Cbx_sa_crk_nr_mfo"
			VALUE
			0x7079A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_crk_nr_pf
			"Cbx_sa_crk_nr_pf"
			VALUE
			0x7034B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_crk_nr_vf
			"Cbx_sa_crk_nr_vf"
			VALUE
			0x70599
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_crk_pf
			"Cbx_sa_crk_pf"
			VALUE
			0x7034A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_crk_vf
			"Cbx_sa_crk_vf"
			VALUE
			0x70598
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_cru_pf
			"Cbx_sa_cru_pf"
			VALUE
			0x7034C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_el_wind_rcpt_pf
			"Cbx_sa_el_wind_rcpt_pf"
			VALUE
			0x7034D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_eng_temp_pf
			"Cbx_sa_eng_temp_pf"
			VALUE
			0x7034E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_eng_whl_mfo
			"Cbx_sa_eng_whl_mfo"
			VALUE
			0x7079B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_eng_whl_pf
			"Cbx_sa_eng_whl_pf"
			VALUE
			0x7034F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_eng_whl_vf
			"Cbx_sa_eng_whl_vf"
			VALUE
			0x7059A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_fsys_lpg_mfo
			"Cbx_sa_fsys_lpg_mfo"
			VALUE
			0x7079D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_fsys_lpg_pf
			"Cbx_sa_fsys_lpg_pf"
			VALUE
			0x70351
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_fsys_lpg_vf
			"Cbx_sa_fsys_lpg_vf"
			VALUE
			0x7059C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_fsys_mfo
			"Cbx_sa_fsys_mfo"
			VALUE
			0x7079C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_fsys_pf
			"Cbx_sa_fsys_pf"
			VALUE
			0x70350
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_fsys_vf
			"Cbx_sa_fsys_vf"
			VALUE
			0x7059B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_gas_pump_mfo
			"Cbx_sa_gas_pump_mfo"
			VALUE
			0x7067D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_gas_pump_pf
			"Cbx_sa_gas_pump_pf"
			VALUE
			0x70352
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_gas_pump_vf
			"Cbx_sa_gas_pump_vf"
			VALUE
			0x7057E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_igc_1_mfo
			"Cbx_sa_igc_1_mfo"
			VALUE
			0x7067E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_igc_1_pf
			"Cbx_sa_igc_1_pf"
			VALUE
			0x70353
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_igc_1_vf
			"Cbx_sa_igc_1_vf"
			VALUE
			0x7057F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_igc_2_mfo
			"Cbx_sa_igc_2_mfo"
			VALUE
			0x7067F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_igc_2_pf
			"Cbx_sa_igc_2_pf"
			VALUE
			0x70354
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_igc_2_vf
			"Cbx_sa_igc_2_vf"
			VALUE
			0x70580
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_igc_3_mfo
			"Cbx_sa_igc_3_mfo"
			VALUE
			0x70680
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_igc_3_pf
			"Cbx_sa_igc_3_pf"
			VALUE
			0x70355
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_igc_3_vf
			"Cbx_sa_igc_3_vf"
			VALUE
			0x70581
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_igc_4_mfo
			"Cbx_sa_igc_4_mfo"
			VALUE
			0x70681
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_igc_4_pf
			"Cbx_sa_igc_4_pf"
			VALUE
			0x70356
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_igc_4_vf
			"Cbx_sa_igc_4_vf"
			VALUE
			0x70582
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_inj1_mfo
			"Cbx_sa_inj1_mfo"
			VALUE
			0x70682
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_inj1_pf
			"Cbx_sa_inj1_pf"
			VALUE
			0x70357
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_inj1_vf
			"Cbx_sa_inj1_vf"
			VALUE
			0x70583
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_inj2_mfo
			"Cbx_sa_inj2_mfo"
			VALUE
			0x70683
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_inj2_pf
			"Cbx_sa_inj2_pf"
			VALUE
			0x70358
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_inj2_vf
			"Cbx_sa_inj2_vf"
			VALUE
			0x70584
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_inj3_mfo
			"Cbx_sa_inj3_mfo"
			VALUE
			0x70684
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_inj3_pf
			"Cbx_sa_inj3_pf"
			VALUE
			0x70359
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_inj3_vf
			"Cbx_sa_inj3_vf"
			VALUE
			0x70585
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_inj4_mfo
			"Cbx_sa_inj4_mfo"
			VALUE
			0x70685
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_inj4_pf
			"Cbx_sa_inj4_pf"
			VALUE
			0x7035A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_inj4_vf
			"Cbx_sa_inj4_vf"
			VALUE
			0x70586
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_inj_ecu_mfo
			"Cbx_sa_inj_ecu_mfo"
			VALUE
			0x7079E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_inj_ecu_pf
			"Cbx_sa_inj_ecu_pf"
			VALUE
			0x7035B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_inj_ecu_vf
			"Cbx_sa_inj_ecu_vf"
			VALUE
			0x7059D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_ip_inj_cnt_pf
			"Cbx_sa_ip_inj_cnt_pf"
			VALUE
			0x7035C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_knk_mfo
			"Cbx_sa_knk_mfo"
			VALUE
			0x7079F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_knk_pf
			"Cbx_sa_knk_pf"
			VALUE
			0x7035D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_knk_vf
			"Cbx_sa_knk_vf"
			VALUE
			0x7059E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_lbdw_hot_mfo
			"Cbx_sa_lbdw_hot_mfo"
			VALUE
			0x70687
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_lbdw_hot_pf
			"Cbx_sa_lbdw_hot_pf"
			VALUE
			0x7035F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_lbdw_hot_vf
			"Cbx_sa_lbdw_hot_vf"
			VALUE
			0x70588
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_lbdw_mfo
			"Cbx_sa_lbdw_mfo"
			VALUE
			0x70686
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_lbdw_pf
			"Cbx_sa_lbdw_pf"
			VALUE
			0x7035E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_lbdw_pump_crt_pf
			"Cbx_sa_lbdw_pump_crt_pf"
			VALUE
			0x70360
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_lbdw_vf
			"Cbx_sa_lbdw_vf"
			VALUE
			0x70587
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_lbup_hot_mfo
			"Cbx_sa_lbup_hot_mfo"
			VALUE
			0x70689
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_lbup_hot_pf
			"Cbx_sa_lbup_hot_pf"
			VALUE
			0x70362
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_lbup_hot_vf
			"Cbx_sa_lbup_hot_vf"
			VALUE
			0x7058A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_lbup_mfo
			"Cbx_sa_lbup_mfo"
			VALUE
			0x70688
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_lbup_pf
			"Cbx_sa_lbup_pf"
			VALUE
			0x70361
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_lbup_pump_crt_pf
			"Cbx_sa_lbup_pump_crt_pf"
			VALUE
			0x70363
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_lbup_vf
			"Cbx_sa_lbup_vf"
			VALUE
			0x70589
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_lpg_rcpt_mfo
			"Cbx_sa_lpg_rcpt_mfo"
			VALUE
			0x707A0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_lpg_rcpt_pf
			"Cbx_sa_lpg_rcpt_pf"
			VALUE
			0x70364
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_lpg_rcpt_vf
			"Cbx_sa_lpg_rcpt_vf"
			VALUE
			0x7059F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_map_chr_pf
			"Cbx_sa_map_chr_pf"
			VALUE
			0x70366
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_map_mfo
			"Cbx_sa_map_mfo"
			VALUE
			0x707A1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_map_pf
			"Cbx_sa_map_pf"
			VALUE
			0x70365
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_map_vf
			"Cbx_sa_map_vf"
			VALUE
			0x705A0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mastervac_pf
			"Cbx_sa_mastervac_pf"
			VALUE
			0x70367
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mcut_sens1_pf
			"Cbx_sa_mcut_sens1_pf"
			VALUE
			0x70368
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mdf1_pf
			"Cbx_sa_mdf1_pf"
			VALUE
			0x70369
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mdf2_pf
			"Cbx_sa_mdf2_pf"
			VALUE
			0x7036A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_min_gas_lvl_mfo
			"Cbx_sa_min_gas_lvl_mfo"
			VALUE
			0x707A2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_min_gas_lvl_pf
			"Cbx_sa_min_gas_lvl_pf"
			VALUE
			0x7036B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_min_gas_lvl_vf
			"Cbx_sa_min_gas_lvl_vf"
			VALUE
			0x705A1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_min_lpg_lvl_pf
			"Cbx_sa_min_lpg_lvl_pf"
			VALUE
			0x7036C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_cata_1_lpg_mfo
			"Cbx_sa_mis_cata_1_lpg_mfo"
			VALUE
			0x707A5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_cata_1_lpg_pf
			"Cbx_sa_mis_cata_1_lpg_pf"
			VALUE
			0x7036F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_cata_1_lpg_vf
			"Cbx_sa_mis_cata_1_lpg_vf"
			VALUE
			0x705A4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_cata_1_mfo
			"Cbx_sa_mis_cata_1_mfo"
			VALUE
			0x707A4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_cata_1_pf
			"Cbx_sa_mis_cata_1_pf"
			VALUE
			0x7036E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_cata_1_vf
			"Cbx_sa_mis_cata_1_vf"
			VALUE
			0x705A3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_cata_2_lpg_mfo
			"Cbx_sa_mis_cata_2_lpg_mfo"
			VALUE
			0x707A7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_cata_2_lpg_pf
			"Cbx_sa_mis_cata_2_lpg_pf"
			VALUE
			0x70371
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_cata_2_lpg_vf
			"Cbx_sa_mis_cata_2_lpg_vf"
			VALUE
			0x705A6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_cata_2_mfo
			"Cbx_sa_mis_cata_2_mfo"
			VALUE
			0x707A6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_cata_2_pf
			"Cbx_sa_mis_cata_2_pf"
			VALUE
			0x70370
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_cata_2_vf
			"Cbx_sa_mis_cata_2_vf"
			VALUE
			0x705A5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_cata_3_lpg_mfo
			"Cbx_sa_mis_cata_3_lpg_mfo"
			VALUE
			0x707A9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_cata_3_lpg_pf
			"Cbx_sa_mis_cata_3_lpg_pf"
			VALUE
			0x70373
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_cata_3_lpg_vf
			"Cbx_sa_mis_cata_3_lpg_vf"
			VALUE
			0x705A8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_cata_3_mfo
			"Cbx_sa_mis_cata_3_mfo"
			VALUE
			0x707A8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_cata_3_pf
			"Cbx_sa_mis_cata_3_pf"
			VALUE
			0x70372
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_cata_3_vf
			"Cbx_sa_mis_cata_3_vf"
			VALUE
			0x705A7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_cata_4_lpg_mfo
			"Cbx_sa_mis_cata_4_lpg_mfo"
			VALUE
			0x707AB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_cata_4_lpg_pf
			"Cbx_sa_mis_cata_4_lpg_pf"
			VALUE
			0x70375
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_cata_4_lpg_vf
			"Cbx_sa_mis_cata_4_lpg_vf"
			VALUE
			0x705AA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_cata_4_mfo
			"Cbx_sa_mis_cata_4_mfo"
			VALUE
			0x707AA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_cata_4_pf
			"Cbx_sa_mis_cata_4_pf"
			VALUE
			0x70374
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_cata_4_vf
			"Cbx_sa_mis_cata_4_vf"
			VALUE
			0x705A9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_cata_gas_mfo
			"Cbx_sa_mis_cata_gas_mfo"
			VALUE
			0x707AC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_cata_gas_pf
			"Cbx_sa_mis_cata_gas_pf"
			VALUE
			0x70376
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_cata_gas_vf
			"Cbx_sa_mis_cata_gas_vf"
			VALUE
			0x705AB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_cata_lpg_mfo
			"Cbx_sa_mis_cata_lpg_mfo"
			VALUE
			0x707AD
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_cata_lpg_pf
			"Cbx_sa_mis_cata_lpg_pf"
			VALUE
			0x70377
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_cata_lpg_vf
			"Cbx_sa_mis_cata_lpg_vf"
			VALUE
			0x705AC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_cata_mfo
			"Cbx_sa_mis_cata_mfo"
			VALUE
			0x707A3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_cata_pf
			"Cbx_sa_mis_cata_pf"
			VALUE
			0x7036D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_cata_vf
			"Cbx_sa_mis_cata_vf"
			VALUE
			0x705A2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_fast_pf
			"Cbx_sa_mis_fast_pf"
			VALUE
			0x70378
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_lih_pf
			"Cbx_sa_mis_lih_pf"
			VALUE
			0x70379
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_polu_1_lpg_mfo
			"Cbx_sa_mis_polu_1_lpg_mfo"
			VALUE
			0x707B0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_polu_1_lpg_pf
			"Cbx_sa_mis_polu_1_lpg_pf"
			VALUE
			0x7037C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_polu_1_lpg_vf
			"Cbx_sa_mis_polu_1_lpg_vf"
			VALUE
			0x705AF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_polu_1_mfo
			"Cbx_sa_mis_polu_1_mfo"
			VALUE
			0x707AF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_polu_1_pf
			"Cbx_sa_mis_polu_1_pf"
			VALUE
			0x7037B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_polu_1_vf
			"Cbx_sa_mis_polu_1_vf"
			VALUE
			0x705AE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_polu_2_lpg_mfo
			"Cbx_sa_mis_polu_2_lpg_mfo"
			VALUE
			0x707B2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_polu_2_lpg_pf
			"Cbx_sa_mis_polu_2_lpg_pf"
			VALUE
			0x7037E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_polu_2_lpg_vf
			"Cbx_sa_mis_polu_2_lpg_vf"
			VALUE
			0x705B1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_polu_2_mfo
			"Cbx_sa_mis_polu_2_mfo"
			VALUE
			0x707B1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_polu_2_pf
			"Cbx_sa_mis_polu_2_pf"
			VALUE
			0x7037D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_polu_2_vf
			"Cbx_sa_mis_polu_2_vf"
			VALUE
			0x705B0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_polu_3_lpg_mfo
			"Cbx_sa_mis_polu_3_lpg_mfo"
			VALUE
			0x707B4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_polu_3_lpg_pf
			"Cbx_sa_mis_polu_3_lpg_pf"
			VALUE
			0x70380
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_polu_3_lpg_vf
			"Cbx_sa_mis_polu_3_lpg_vf"
			VALUE
			0x705B3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_polu_3_mfo
			"Cbx_sa_mis_polu_3_mfo"
			VALUE
			0x707B3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_polu_3_pf
			"Cbx_sa_mis_polu_3_pf"
			VALUE
			0x7037F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_polu_3_vf
			"Cbx_sa_mis_polu_3_vf"
			VALUE
			0x705B2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_polu_4_lpg_mfo
			"Cbx_sa_mis_polu_4_lpg_mfo"
			VALUE
			0x707B6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_polu_4_lpg_pf
			"Cbx_sa_mis_polu_4_lpg_pf"
			VALUE
			0x70382
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_polu_4_lpg_vf
			"Cbx_sa_mis_polu_4_lpg_vf"
			VALUE
			0x705B5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_polu_4_mfo
			"Cbx_sa_mis_polu_4_mfo"
			VALUE
			0x707B5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_polu_4_pf
			"Cbx_sa_mis_polu_4_pf"
			VALUE
			0x70381
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_polu_4_vf
			"Cbx_sa_mis_polu_4_vf"
			VALUE
			0x705B4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_polu_gas_mfo
			"Cbx_sa_mis_polu_gas_mfo"
			VALUE
			0x707B7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_polu_gas_pf
			"Cbx_sa_mis_polu_gas_pf"
			VALUE
			0x70383
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_polu_gas_vf
			"Cbx_sa_mis_polu_gas_vf"
			VALUE
			0x705B6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_polu_lpg_mfo
			"Cbx_sa_mis_polu_lpg_mfo"
			VALUE
			0x707B8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_polu_lpg_pf
			"Cbx_sa_mis_polu_lpg_pf"
			VALUE
			0x70384
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_polu_lpg_vf
			"Cbx_sa_mis_polu_lpg_vf"
			VALUE
			0x705B7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_polu_mfo
			"Cbx_sa_mis_polu_mfo"
			VALUE
			0x707AE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_polu_pf
			"Cbx_sa_mis_polu_pf"
			VALUE
			0x7037A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mis_polu_vf
			"Cbx_sa_mis_polu_vf"
			VALUE
			0x705AD
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mvac_pump_pf
			"Cbx_sa_mvac_pump_pf"
			VALUE
			0x70385
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_mvac_sys_pf
			"Cbx_sa_mvac_sys_pf"
			VALUE
			0x70386
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_obd_cata_mfo
			"Cbx_sa_obd_cata_mfo"
			VALUE
			0x707B9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_obd_cata_pf
			"Cbx_sa_obd_cata_pf"
			VALUE
			0x70387
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_obd_cata_vf
			"Cbx_sa_obd_cata_vf"
			VALUE
			0x705B8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_obd_lamb_mfo
			"Cbx_sa_obd_lamb_mfo"
			VALUE
			0x707BA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_obd_lamb_pf
			"Cbx_sa_obd_lamb_pf"
			VALUE
			0x70388
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_obd_lamb_vf
			"Cbx_sa_obd_lamb_vf"
			VALUE
			0x705B9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_obd_sa_mfo
			"Cbx_sa_obd_sa_mfo"
			VALUE
			0x707BB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_obd_sa_pf
			"Cbx_sa_obd_sa_pf"
			VALUE
			0x70389
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_obd_sa_vf
			"Cbx_sa_obd_sa_vf"
			VALUE
			0x705BA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_oil_pf
			"Cbx_sa_oil_pf"
			VALUE
			0x7038A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_pdl_pf
			"Cbx_sa_pdl_pf"
			VALUE
			0x7038B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_pmh_pf
			"Cbx_sa_pmh_pf"
			VALUE
			0x7038C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_pow_lbdw_mfo
			"Cbx_sa_pow_lbdw_mfo"
			VALUE
			0x707BC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_pow_lbdw_pf
			"Cbx_sa_pow_lbdw_pf"
			VALUE
			0x7038D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_pow_lbdw_vf
			"Cbx_sa_pow_lbdw_vf"
			VALUE
			0x705BB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_pow_lbup_mfo
			"Cbx_sa_pow_lbup_mfo"
			VALUE
			0x707BD
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_pow_lbup_pf
			"Cbx_sa_pow_lbup_pf"
			VALUE
			0x7038E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_pow_lbup_vf
			"Cbx_sa_pow_lbup_vf"
			VALUE
			0x705BC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_ptc_pf
			"Cbx_sa_ptc_pf"
			VALUE
			0x7038F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_ptc_rov_pf
			"Cbx_sa_ptc_rov_pf"
			VALUE
			0x70390
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_pws_pf
			"Cbx_sa_pws_pf"
			VALUE
			0x70391
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_rams_pdl_mfo
			"Cbx_sa_rams_pdl_mfo"
			VALUE
			0x707BE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_rams_pdl_pf
			"Cbx_sa_rams_pdl_pf"
			VALUE
			0x70393
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_rams_pdl_vf
			"Cbx_sa_rams_pdl_vf"
			VALUE
			0x705BD
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_rams_pf
			"Cbx_sa_rams_pf"
			VALUE
			0x70392
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_reserve_3_pf
			"Cbx_sa_reserve_3_pf"
			VALUE
			0x70394
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_rmc_pf
			"Cbx_sa_rmc_pf"
			VALUE
			0x70395
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_sa_ev_mfo
			"Cbx_sa_sa_ev_mfo"
			VALUE
			0x7068B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_sa_ev_pf
			"Cbx_sa_sa_ev_pf"
			VALUE
			0x70397
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_sa_ev_vf
			"Cbx_sa_sa_ev_vf"
			VALUE
			0x7058C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_sa_mfo
			"Cbx_sa_sa_mfo"
			VALUE
			0x7068A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_sa_pf
			"Cbx_sa_sa_pf"
			VALUE
			0x70396
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_sa_vf
			"Cbx_sa_sa_vf"
			VALUE
			0x7058B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_spg_mfo
			"Cbx_sa_spg_mfo"
			VALUE
			0x707BF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_spg_pf
			"Cbx_sa_spg_pf"
			VALUE
			0x70398
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_spg_sys_mfo
			"Cbx_sa_spg_sys_mfo"
			VALUE
			0x707C0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_spg_sys_pf
			"Cbx_sa_spg_sys_pf"
			VALUE
			0x70399
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_spg_sys_vf
			"Cbx_sa_spg_sys_vf"
			VALUE
			0x705BF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_spg_vf
			"Cbx_sa_spg_vf"
			VALUE
			0x705BE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_spi_cc_pf
			"Cbx_sa_spi_cc_pf"
			VALUE
			0x7039A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_svkl_pf
			"Cbx_sa_svkl_pf"
			VALUE
			0x7039B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_swlk_pf
			"Cbx_sa_swlk_pf"
			VALUE
			0x7039C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_tco_mfo
			"Cbx_sa_tco_mfo"
			VALUE
			0x7068C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_tco_pf
			"Cbx_sa_tco_pf"
			VALUE
			0x7039D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_tco_vf
			"Cbx_sa_tco_vf"
			VALUE
			0x7058D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_thpl_pf
			"Cbx_sa_thpl_pf"
			VALUE
			0x7039E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_thr_cmd_pf
			"Cbx_sa_thr_cmd_pf"
			VALUE
			0x703A0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_thr_pf
			"Cbx_sa_thr_pf"
			VALUE
			0x7039F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_tia_mfo
			"Cbx_sa_tia_mfo"
			VALUE
			0x7068D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_tia_pf
			"Cbx_sa_tia_pf"
			VALUE
			0x703A1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_tia_vf
			"Cbx_sa_tia_vf"
			VALUE
			0x7058E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_tjy_ctl_pf
			"Cbx_sa_tjy_ctl_pf"
			VALUE
			0x703A2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_tlz_ad_b_mfo
			"Cbx_sa_tlz_ad_b_mfo"
			VALUE
			0x707C1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_tlz_ad_b_pf
			"Cbx_sa_tlz_ad_b_pf"
			VALUE
			0x703A3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_tlz_ad_b_vf
			"Cbx_sa_tlz_ad_b_vf"
			VALUE
			0x705C0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_vb_pf
			"Cbx_sa_vb_pf"
			VALUE
			0x703A4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_vs_mfo
			"Cbx_sa_vs_mfo"
			VALUE
			0x7068E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_vs_pf
			"Cbx_sa_vs_pf"
			VALUE
			0x703A5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_vs_vf
			"Cbx_sa_vs_vf"
			VALUE
			0x7058F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_vta_intake_mfo
			"Cbx_sa_vta_intake_mfo"
			VALUE
			0x7068F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_vta_intake_pf
			"Cbx_sa_vta_intake_pf"
			VALUE
			0x703A6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_vta_intake_vf
			"Cbx_sa_vta_intake_vf"
			VALUE
			0x70590
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_vvt_int_ev_mfo
			"Cbx_sa_vvt_int_ev_mfo"
			VALUE
			0x70690
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_vvt_int_ev_pf
			"Cbx_sa_vvt_int_ev_pf"
			VALUE
			0x703A8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_vvt_int_ev_vf
			"Cbx_sa_vvt_int_ev_vf"
			VALUE
			0x70591
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_vvt_int_old_off_mfo
			"Cbx_sa_vvt_int_old_off_mfo"
			VALUE
			0x707C2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_vvt_int_old_off_vf
			"Cbx_sa_vvt_int_old_off_vf"
			VALUE
			0x705C1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_vvt_int_pf
			"Cbx_sa_vvt_int_pf"
			VALUE
			0x703A7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_vvt_intake_mfo
			"Cbx_sa_vvt_intake_mfo"
			VALUE
			0x70691
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_vvt_intake_pf
			"Cbx_sa_vvt_intake_pf"
			VALUE
			0x703A9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_vvt_intake_vf
			"Cbx_sa_vvt_intake_vf"
			VALUE
			0x70592
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_vvtc_toth_3_mfo
			"Cbx_sa_vvtc_toth_3_mfo"
			VALUE
			0x707C3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_vvtc_toth_3_pf
			"Cbx_sa_vvtc_toth_3_pf"
			VALUE
			0x703AA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_vvtc_toth_3_vf
			"Cbx_sa_vvtc_toth_3_vf"
			VALUE
			0x705C2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_wat_temp_pf
			"Cbx_sa_wat_temp_pf"
			VALUE
			0x703AB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_wgc_mfo
			"Cbx_sa_wgc_mfo"
			VALUE
			0x70692
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_wgc_pf
			"Cbx_sa_wgc_pf"
			VALUE
			0x703AC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_wgc_vf
			"Cbx_sa_wgc_vf"
			VALUE
			0x70593
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sa_wpmp_pf
			"Cbx_sa_wpmp_pf"
			VALUE
			0x703AD
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_ac_prs_pf
			"Cbx_schd_ac_prs_pf"
			VALUE
			0x703AE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_ac_rcpt_pf
			"Cbx_schd_ac_rcpt_pf"
			VALUE
			0x703AF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_acr_pf
			"Cbx_schd_acr_pf"
			VALUE
			0x703B0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_actr_rly_cut_pf
			"Cbx_schd_actr_rly_cut_pf"
			VALUE
			0x703B2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_actr_rly_pf
			"Cbx_schd_actr_rly_pf"
			VALUE
			0x703B1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_agb_pf
			"Cbx_schd_agb_pf"
			VALUE
			0x703B3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_agb_rcpt_mfo
			"Cbx_schd_agb_rcpt_mfo"
			VALUE
			0x707C4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_agb_rcpt_vf
			"Cbx_schd_agb_rcpt_vf"
			VALUE
			0x705DA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_air_mfo
			"Cbx_schd_air_mfo"
			VALUE
			0x707C5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_air_pf
			"Cbx_schd_air_pf"
			VALUE
			0x703B4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_air_vf
			"Cbx_schd_air_vf"
			VALUE
			0x705DB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_alt_load_in_pf
			"Cbx_schd_alt_load_in_pf"
			VALUE
			0x703B6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_alt_pf
			"Cbx_schd_alt_pf"
			VALUE
			0x703B5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_bkup_mem_mfo
			"Cbx_schd_bkup_mem_mfo"
			VALUE
			0x707C6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_bkup_mem_pf
			"Cbx_schd_bkup_mem_pf"
			VALUE
			0x703B7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_bkup_mem_vf
			"Cbx_schd_bkup_mem_vf"
			VALUE
			0x705DC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_checksum_pf
			"Cbx_schd_checksum_pf"
			VALUE
			0x703B8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_clu_mfo
			"Cbx_schd_clu_mfo"
			VALUE
			0x707C7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_clu_pf
			"Cbx_schd_clu_pf"
			VALUE
			0x703B9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_clu_vf
			"Cbx_schd_clu_vf"
			VALUE
			0x705DD
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_cp_mfo
			"Cbx_schd_cp_mfo"
			VALUE
			0x70693
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_cp_pf
			"Cbx_schd_cp_pf"
			VALUE
			0x703BA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_cp_vf
			"Cbx_schd_cp_vf"
			VALUE
			0x705C3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_crk_mfo
			"Cbx_schd_crk_mfo"
			VALUE
			0x707C8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_crk_nr_mfo
			"Cbx_schd_crk_nr_mfo"
			VALUE
			0x707C9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_crk_nr_pf
			"Cbx_schd_crk_nr_pf"
			VALUE
			0x703BC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_crk_nr_vf
			"Cbx_schd_crk_nr_vf"
			VALUE
			0x705DF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_crk_pf
			"Cbx_schd_crk_pf"
			VALUE
			0x703BB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_crk_vf
			"Cbx_schd_crk_vf"
			VALUE
			0x705DE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_cru_pf
			"Cbx_schd_cru_pf"
			VALUE
			0x703BD
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_el_wind_rcpt_pf
			"Cbx_schd_el_wind_rcpt_pf"
			VALUE
			0x703BE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_eng_temp_pf
			"Cbx_schd_eng_temp_pf"
			VALUE
			0x703BF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_eng_whl_mfo
			"Cbx_schd_eng_whl_mfo"
			VALUE
			0x707CA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_eng_whl_pf
			"Cbx_schd_eng_whl_pf"
			VALUE
			0x703C0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_eng_whl_vf
			"Cbx_schd_eng_whl_vf"
			VALUE
			0x705E0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_fsys_lpg_mfo
			"Cbx_schd_fsys_lpg_mfo"
			VALUE
			0x707CC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_fsys_lpg_pf
			"Cbx_schd_fsys_lpg_pf"
			VALUE
			0x703C2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_fsys_lpg_vf
			"Cbx_schd_fsys_lpg_vf"
			VALUE
			0x705E2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_fsys_mfo
			"Cbx_schd_fsys_mfo"
			VALUE
			0x707CB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_fsys_pf
			"Cbx_schd_fsys_pf"
			VALUE
			0x703C1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_fsys_vf
			"Cbx_schd_fsys_vf"
			VALUE
			0x705E1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_gas_pump_mfo
			"Cbx_schd_gas_pump_mfo"
			VALUE
			0x70694
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_gas_pump_pf
			"Cbx_schd_gas_pump_pf"
			VALUE
			0x703C3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_gas_pump_vf
			"Cbx_schd_gas_pump_vf"
			VALUE
			0x705C4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_igc_1_mfo
			"Cbx_schd_igc_1_mfo"
			VALUE
			0x70695
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_igc_1_pf
			"Cbx_schd_igc_1_pf"
			VALUE
			0x703C4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_igc_1_vf
			"Cbx_schd_igc_1_vf"
			VALUE
			0x705C5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_igc_2_mfo
			"Cbx_schd_igc_2_mfo"
			VALUE
			0x70696
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_igc_2_pf
			"Cbx_schd_igc_2_pf"
			VALUE
			0x703C5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_igc_2_vf
			"Cbx_schd_igc_2_vf"
			VALUE
			0x705C6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_igc_3_mfo
			"Cbx_schd_igc_3_mfo"
			VALUE
			0x70697
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_igc_3_pf
			"Cbx_schd_igc_3_pf"
			VALUE
			0x703C6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_igc_3_vf
			"Cbx_schd_igc_3_vf"
			VALUE
			0x705C7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_igc_4_mfo
			"Cbx_schd_igc_4_mfo"
			VALUE
			0x70698
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_igc_4_pf
			"Cbx_schd_igc_4_pf"
			VALUE
			0x703C7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_igc_4_vf
			"Cbx_schd_igc_4_vf"
			VALUE
			0x705C8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_inj1_mfo
			"Cbx_schd_inj1_mfo"
			VALUE
			0x70699
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_inj1_pf
			"Cbx_schd_inj1_pf"
			VALUE
			0x703C8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_inj1_vf
			"Cbx_schd_inj1_vf"
			VALUE
			0x705C9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_inj2_mfo
			"Cbx_schd_inj2_mfo"
			VALUE
			0x7069A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_inj2_pf
			"Cbx_schd_inj2_pf"
			VALUE
			0x703C9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_inj2_vf
			"Cbx_schd_inj2_vf"
			VALUE
			0x705CA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_inj3_mfo
			"Cbx_schd_inj3_mfo"
			VALUE
			0x7069B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_inj3_pf
			"Cbx_schd_inj3_pf"
			VALUE
			0x703CA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_inj3_vf
			"Cbx_schd_inj3_vf"
			VALUE
			0x705CB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_inj4_mfo
			"Cbx_schd_inj4_mfo"
			VALUE
			0x7069C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_inj4_pf
			"Cbx_schd_inj4_pf"
			VALUE
			0x703CB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_inj4_vf
			"Cbx_schd_inj4_vf"
			VALUE
			0x705CC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_inj_ecu_mfo
			"Cbx_schd_inj_ecu_mfo"
			VALUE
			0x707CD
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_inj_ecu_pf
			"Cbx_schd_inj_ecu_pf"
			VALUE
			0x703CC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_inj_ecu_vf
			"Cbx_schd_inj_ecu_vf"
			VALUE
			0x705E3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_ip_inj_cnt_pf
			"Cbx_schd_ip_inj_cnt_pf"
			VALUE
			0x703CD
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_knk_mfo
			"Cbx_schd_knk_mfo"
			VALUE
			0x707CE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_knk_pf
			"Cbx_schd_knk_pf"
			VALUE
			0x703CE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_knk_vf
			"Cbx_schd_knk_vf"
			VALUE
			0x705E4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_lbdw_hot_mfo
			"Cbx_schd_lbdw_hot_mfo"
			VALUE
			0x7069E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_lbdw_hot_pf
			"Cbx_schd_lbdw_hot_pf"
			VALUE
			0x703D0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_lbdw_hot_vf
			"Cbx_schd_lbdw_hot_vf"
			VALUE
			0x705CE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_lbdw_mfo
			"Cbx_schd_lbdw_mfo"
			VALUE
			0x7069D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_lbdw_pf
			"Cbx_schd_lbdw_pf"
			VALUE
			0x703CF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_lbdw_pump_crt_pf
			"Cbx_schd_lbdw_pump_crt_pf"
			VALUE
			0x703D1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_lbdw_vf
			"Cbx_schd_lbdw_vf"
			VALUE
			0x705CD
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_lbup_hot_mfo
			"Cbx_schd_lbup_hot_mfo"
			VALUE
			0x706A0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_lbup_hot_pf
			"Cbx_schd_lbup_hot_pf"
			VALUE
			0x703D3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_lbup_hot_vf
			"Cbx_schd_lbup_hot_vf"
			VALUE
			0x705D0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_lbup_mfo
			"Cbx_schd_lbup_mfo"
			VALUE
			0x7069F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_lbup_pf
			"Cbx_schd_lbup_pf"
			VALUE
			0x703D2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_lbup_pump_crt_pf
			"Cbx_schd_lbup_pump_crt_pf"
			VALUE
			0x703D4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_lbup_vf
			"Cbx_schd_lbup_vf"
			VALUE
			0x705CF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_lpg_rcpt_mfo
			"Cbx_schd_lpg_rcpt_mfo"
			VALUE
			0x707CF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_lpg_rcpt_pf
			"Cbx_schd_lpg_rcpt_pf"
			VALUE
			0x703D5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_lpg_rcpt_vf
			"Cbx_schd_lpg_rcpt_vf"
			VALUE
			0x705E5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_map_chr_pf
			"Cbx_schd_map_chr_pf"
			VALUE
			0x703D7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_map_mfo
			"Cbx_schd_map_mfo"
			VALUE
			0x707D0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_map_pf
			"Cbx_schd_map_pf"
			VALUE
			0x703D6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_map_vf
			"Cbx_schd_map_vf"
			VALUE
			0x705E6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mastervac_pf
			"Cbx_schd_mastervac_pf"
			VALUE
			0x703D8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mcut_sens1_pf
			"Cbx_schd_mcut_sens1_pf"
			VALUE
			0x703D9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mdf1_pf
			"Cbx_schd_mdf1_pf"
			VALUE
			0x703DA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mdf2_pf
			"Cbx_schd_mdf2_pf"
			VALUE
			0x703DB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_min_gas_lvl_mfo
			"Cbx_schd_min_gas_lvl_mfo"
			VALUE
			0x707D1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_min_gas_lvl_pf
			"Cbx_schd_min_gas_lvl_pf"
			VALUE
			0x703DC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_min_gas_lvl_vf
			"Cbx_schd_min_gas_lvl_vf"
			VALUE
			0x705E7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_min_lpg_lvl_pf
			"Cbx_schd_min_lpg_lvl_pf"
			VALUE
			0x703DD
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_cata_1_lpg_mfo
			"Cbx_schd_mis_cata_1_lpg_mfo"
			VALUE
			0x707D4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_cata_1_lpg_pf
			"Cbx_schd_mis_cata_1_lpg_pf"
			VALUE
			0x703E0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_cata_1_lpg_vf
			"Cbx_schd_mis_cata_1_lpg_vf"
			VALUE
			0x705EA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_cata_1_mfo
			"Cbx_schd_mis_cata_1_mfo"
			VALUE
			0x707D3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_cata_1_pf
			"Cbx_schd_mis_cata_1_pf"
			VALUE
			0x703DF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_cata_1_vf
			"Cbx_schd_mis_cata_1_vf"
			VALUE
			0x705E9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_cata_2_lpg_mfo
			"Cbx_schd_mis_cata_2_lpg_mfo"
			VALUE
			0x707D6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_cata_2_lpg_pf
			"Cbx_schd_mis_cata_2_lpg_pf"
			VALUE
			0x703E2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_cata_2_lpg_vf
			"Cbx_schd_mis_cata_2_lpg_vf"
			VALUE
			0x705EC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_cata_2_mfo
			"Cbx_schd_mis_cata_2_mfo"
			VALUE
			0x707D5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_cata_2_pf
			"Cbx_schd_mis_cata_2_pf"
			VALUE
			0x703E1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_cata_2_vf
			"Cbx_schd_mis_cata_2_vf"
			VALUE
			0x705EB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_cata_3_lpg_mfo
			"Cbx_schd_mis_cata_3_lpg_mfo"
			VALUE
			0x707D8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_cata_3_lpg_pf
			"Cbx_schd_mis_cata_3_lpg_pf"
			VALUE
			0x703E4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_cata_3_lpg_vf
			"Cbx_schd_mis_cata_3_lpg_vf"
			VALUE
			0x705EE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_cata_3_mfo
			"Cbx_schd_mis_cata_3_mfo"
			VALUE
			0x707D7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_cata_3_pf
			"Cbx_schd_mis_cata_3_pf"
			VALUE
			0x703E3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_cata_3_vf
			"Cbx_schd_mis_cata_3_vf"
			VALUE
			0x705ED
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_cata_4_lpg_mfo
			"Cbx_schd_mis_cata_4_lpg_mfo"
			VALUE
			0x707DA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_cata_4_lpg_pf
			"Cbx_schd_mis_cata_4_lpg_pf"
			VALUE
			0x703E6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_cata_4_lpg_vf
			"Cbx_schd_mis_cata_4_lpg_vf"
			VALUE
			0x705F0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_cata_4_mfo
			"Cbx_schd_mis_cata_4_mfo"
			VALUE
			0x707D9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_cata_4_pf
			"Cbx_schd_mis_cata_4_pf"
			VALUE
			0x703E5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_cata_4_vf
			"Cbx_schd_mis_cata_4_vf"
			VALUE
			0x705EF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_cata_gas_mfo
			"Cbx_schd_mis_cata_gas_mfo"
			VALUE
			0x707DB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_cata_gas_pf
			"Cbx_schd_mis_cata_gas_pf"
			VALUE
			0x703E7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_cata_gas_vf
			"Cbx_schd_mis_cata_gas_vf"
			VALUE
			0x705F1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_cata_lpg_mfo
			"Cbx_schd_mis_cata_lpg_mfo"
			VALUE
			0x707DC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_cata_lpg_pf
			"Cbx_schd_mis_cata_lpg_pf"
			VALUE
			0x703E8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_cata_lpg_vf
			"Cbx_schd_mis_cata_lpg_vf"
			VALUE
			0x705F2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_cata_mfo
			"Cbx_schd_mis_cata_mfo"
			VALUE
			0x707D2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_cata_pf
			"Cbx_schd_mis_cata_pf"
			VALUE
			0x703DE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_cata_vf
			"Cbx_schd_mis_cata_vf"
			VALUE
			0x705E8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_fast_pf
			"Cbx_schd_mis_fast_pf"
			VALUE
			0x703E9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_lih_pf
			"Cbx_schd_mis_lih_pf"
			VALUE
			0x703EA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_polu_1_lpg_mfo
			"Cbx_schd_mis_polu_1_lpg_mfo"
			VALUE
			0x707DF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_polu_1_lpg_pf
			"Cbx_schd_mis_polu_1_lpg_pf"
			VALUE
			0x703ED
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_polu_1_lpg_vf
			"Cbx_schd_mis_polu_1_lpg_vf"
			VALUE
			0x705F5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_polu_1_mfo
			"Cbx_schd_mis_polu_1_mfo"
			VALUE
			0x707DE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_polu_1_pf
			"Cbx_schd_mis_polu_1_pf"
			VALUE
			0x703EC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_polu_1_vf
			"Cbx_schd_mis_polu_1_vf"
			VALUE
			0x705F4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_polu_2_lpg_mfo
			"Cbx_schd_mis_polu_2_lpg_mfo"
			VALUE
			0x707E1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_polu_2_lpg_pf
			"Cbx_schd_mis_polu_2_lpg_pf"
			VALUE
			0x703EF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_polu_2_lpg_vf
			"Cbx_schd_mis_polu_2_lpg_vf"
			VALUE
			0x705F7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_polu_2_mfo
			"Cbx_schd_mis_polu_2_mfo"
			VALUE
			0x707E0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_polu_2_pf
			"Cbx_schd_mis_polu_2_pf"
			VALUE
			0x703EE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_polu_2_vf
			"Cbx_schd_mis_polu_2_vf"
			VALUE
			0x705F6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_polu_3_lpg_mfo
			"Cbx_schd_mis_polu_3_lpg_mfo"
			VALUE
			0x707E3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_polu_3_lpg_pf
			"Cbx_schd_mis_polu_3_lpg_pf"
			VALUE
			0x703F1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_polu_3_lpg_vf
			"Cbx_schd_mis_polu_3_lpg_vf"
			VALUE
			0x705F9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_polu_3_mfo
			"Cbx_schd_mis_polu_3_mfo"
			VALUE
			0x707E2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_polu_3_pf
			"Cbx_schd_mis_polu_3_pf"
			VALUE
			0x703F0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_polu_3_vf
			"Cbx_schd_mis_polu_3_vf"
			VALUE
			0x705F8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_polu_4_lpg_mfo
			"Cbx_schd_mis_polu_4_lpg_mfo"
			VALUE
			0x707E5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_polu_4_lpg_pf
			"Cbx_schd_mis_polu_4_lpg_pf"
			VALUE
			0x703F3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_polu_4_lpg_vf
			"Cbx_schd_mis_polu_4_lpg_vf"
			VALUE
			0x705FB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_polu_4_mfo
			"Cbx_schd_mis_polu_4_mfo"
			VALUE
			0x707E4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_polu_4_pf
			"Cbx_schd_mis_polu_4_pf"
			VALUE
			0x703F2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_polu_4_vf
			"Cbx_schd_mis_polu_4_vf"
			VALUE
			0x705FA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_polu_gas_mfo
			"Cbx_schd_mis_polu_gas_mfo"
			VALUE
			0x707E6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_polu_gas_pf
			"Cbx_schd_mis_polu_gas_pf"
			VALUE
			0x703F4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_polu_gas_vf
			"Cbx_schd_mis_polu_gas_vf"
			VALUE
			0x705FC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_polu_lpg_mfo
			"Cbx_schd_mis_polu_lpg_mfo"
			VALUE
			0x707E7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_polu_lpg_pf
			"Cbx_schd_mis_polu_lpg_pf"
			VALUE
			0x703F5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_polu_lpg_vf
			"Cbx_schd_mis_polu_lpg_vf"
			VALUE
			0x705FD
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_polu_mfo
			"Cbx_schd_mis_polu_mfo"
			VALUE
			0x707DD
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_polu_pf
			"Cbx_schd_mis_polu_pf"
			VALUE
			0x703EB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mis_polu_vf
			"Cbx_schd_mis_polu_vf"
			VALUE
			0x705F3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mod_bch
			"Cbx_schd_mod_bch"
			VALUE
			0x77029
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mvac_pump_pf
			"Cbx_schd_mvac_pump_pf"
			VALUE
			0x703F6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_mvac_sys_pf
			"Cbx_schd_mvac_sys_pf"
			VALUE
			0x703F7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_obd_cata_mfo
			"Cbx_schd_obd_cata_mfo"
			VALUE
			0x707E8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_obd_cata_pf
			"Cbx_schd_obd_cata_pf"
			VALUE
			0x703F8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_obd_cata_vf
			"Cbx_schd_obd_cata_vf"
			VALUE
			0x705FE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_obd_lamb_mfo
			"Cbx_schd_obd_lamb_mfo"
			VALUE
			0x707E9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_obd_lamb_pf
			"Cbx_schd_obd_lamb_pf"
			VALUE
			0x703F9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_obd_lamb_vf
			"Cbx_schd_obd_lamb_vf"
			VALUE
			0x705FF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_obd_sa_mfo
			"Cbx_schd_obd_sa_mfo"
			VALUE
			0x707EA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_obd_sa_pf
			"Cbx_schd_obd_sa_pf"
			VALUE
			0x703FA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_obd_sa_vf
			"Cbx_schd_obd_sa_vf"
			VALUE
			0x70600
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_oil_pf
			"Cbx_schd_oil_pf"
			VALUE
			0x703FB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_pdl_pf
			"Cbx_schd_pdl_pf"
			VALUE
			0x703FC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_pmh_pf
			"Cbx_schd_pmh_pf"
			VALUE
			0x703FD
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
