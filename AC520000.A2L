			F_512_p0_104
			0
			33553920
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lgl_dly_asd_diag_lbup
			"Cxx_lgl_dly_asd_diag_lbup"
			VALUE
			0x78344
			DATA_RECORD_UWORD
			33553920
			F_512_p0_104
			0
			33553920
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lgl_dly_diag_cata
			"Cxx_lgl_dly_diag_cata"
			VALUE
			0x78346
			DATA_RECORD_UWORD
			33553920
			F_512_p0_104
			0
			33553920
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lgl_dly_diag_lbup
			"Cxx_lgl_dly_diag_lbup"
			VALUE
			0x78348
			DATA_RECORD_UWORD
			33553920
			F_512_p0_104
			0
			33553920
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lih_dly
			"Cxx_lih_dly"
			VALUE
			0x78F1F
			DATA_RECORD_UBYTE
			8.16
			F_0v032_p0_99
			0
			8.16
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lih_efy_inj_2_3_thd
			"Cxx_lih_efy_inj_2_3_thd"
			VALUE
			0x7AC0A
			DATA_RECORD_UWORD
			99.993303
			F_0v0015258_p0_48
			0
			99.993303
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lih_efy_inj_3_2_thd
			"Cxx_lih_efy_inj_3_2_thd"
			VALUE
			0x7AC0C
			DATA_RECORD_UWORD
			99.993303
			F_0v0015258_p0_48
			0
			99.993303
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lih_efy_inj_3_4_thd
			"Cxx_lih_efy_inj_3_4_thd"
			VALUE
			0x7AC0E
			DATA_RECORD_UWORD
			99.993303
			F_0v0015258_p0_48
			0
			99.993303
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lih_efy_inj_4_3_thd
			"Cxx_lih_efy_inj_4_3_thd"
			VALUE
			0x7AC10
			DATA_RECORD_UWORD
			99.993303
			F_0v0015258_p0_48
			0
			99.993303
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lih_iga_cor_dec_t
			"Cxx_lih_iga_cor_dec_t"
			VALUE
			0x71CCA
			DATA_RECORD_UBYTE
			8160
			F_32_p0_122
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lih_iga_max_cor
			"Cxx_lih_iga_max_cor"
			VALUE
			0x71CCB
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lih_iga_max_cor_rtn_t
			"Cxx_lih_iga_max_cor_rtn_t"
			VALUE
			0x71CCC
			DATA_RECORD_UBYTE
			130.56
			F_0v512_p0_121
			0
			130.56
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lih_thd_trt1_ini
			"Cxx_lih_thd_trt1_ini"
			VALUE
			0x736D4
			DATA_RECORD_UWORD
			6399.902344
			F_0v09765625_p0_71
			0
			6399.902344
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lih_thd_trt2_ini
			"Cxx_lih_thd_trt2_ini"
			VALUE
			0x736D6
			DATA_RECORD_UWORD
			6399.902344
			F_0v09765625_p0_71
			0
			6399.902344
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lim_zon
			"Cxx_lim_zon"
			VALUE
			0x7363E
			DATA_RECORD_UWORD
			2867.8116
			F_0v04376_p0_180
			0
			2867.8116
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lim_zon_ref_dif_1
			"Cxx_lim_zon_ref_dif_1"
			VALUE
			0x73640
			DATA_RECORD_UWORD
			2867.8116
			F_0v04376_p0_180
			0
			2867.8116
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lim_zon_ref_dif_2
			"Cxx_lim_zon_ref_dif_2"
			VALUE
			0x73642
			DATA_RECORD_UWORD
			2867.8116
			F_0v04376_p0_180
			0
			2867.8116
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lim_zon_ref_dif_3
			"Cxx_lim_zon_ref_dif_3"
			VALUE
			0x73644
			DATA_RECORD_UWORD
			2867.8116
			F_0v04376_p0_180
			0
			2867.8116
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lpg_abst_nr_fail
			"Cxx_lpg_abst_nr_fail"
			VALUE
			0x71EDE
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lpg_ad_cl_ti_fac_thd
			"Cxx_lpg_ad_cl_ti_fac_thd"
			VALUE
			0x737E3
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lpg_ad_fac_fac
			"Cxx_lpg_ad_fac_fac"
			VALUE
			0x737E4
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lpg_ad_h_thd
			"Cxx_lpg_ad_h_thd"
			VALUE
			0x737E5
			DATA_RECORD_UBYTE
			49.8046875
			F_0v1953125_p0_208
			0
			49.8046875
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lpg_ad_l_thd
			"Cxx_lpg_ad_l_thd"
			VALUE
			0x737E6
			DATA_RECORD_UBYTE
			49.8046875
			F_0v1953125_p0_208
			0
			49.8046875
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lpg_ad_lpg_max_temp
			"Cxx_lpg_ad_lpg_max_temp"
			VALUE
			0x737E7
			DATA_RECORD_UBYTE
			255
			F_1_m40_40
			-40
			215
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lpg_ad_lpg_min_temp
			"Cxx_lpg_ad_lpg_min_temp"
			VALUE
			0x737E8
			DATA_RECORD_UBYTE
			255
			F_1_m40_40
			-40
			215
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lpg_ad_max_n
			"Cxx_lpg_ad_max_n"
			VALUE
			0x737E9
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lpg_ad_max_prs
			"Cxx_lpg_ad_max_prs"
			VALUE
			0x73838
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lpg_ad_min_n
			"Cxx_lpg_ad_min_n"
			VALUE
			0x737EA
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lpg_ad_min_prs
			"Cxx_lpg_ad_min_prs"
			VALUE
			0x7383A
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lpg_ad_min_tco
			"Cxx_lpg_ad_min_tco"
			VALUE
			0x737EB
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lpg_aper_dly
			"Cxx_lpg_aper_dly"
			VALUE
			0x7383C
			DATA_RECORD_UWORD
			67107.84
			F_1v024_p0_119
			0
			67107.84
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lpg_aper_n_thd
			"Cxx_lpg_aper_n_thd"
			VALUE
			0x737EC
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lpg_aper_pump_run_dly
			"Cxx_lpg_aper_pump_run_dly"
			VALUE
			0x7383E
			DATA_RECORD_UWORD
			67107.84
			F_1v024_p0_119
			0
			67107.84
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lpg_cl_lean_diag_dly
			"Cxx_lpg_cl_lean_diag_dly"
			VALUE
			0x737ED
			DATA_RECORD_UBYTE
			32.64
			F_0v128_p0_75
			0
			32.64
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lpg_diag_ti_fac_thd
			"Cxx_lpg_diag_ti_fac_thd"
			VALUE
			0x73840
			DATA_RECORD_UWORD
			100.00641
			F_0v001526_p0_42
			0
			100.00641
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lpg_ena_ad_prs_max_thd
			"Cxx_lpg_ena_ad_prs_max_thd"
			VALUE
			0x73842
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lpg_ena_ad_prs_min_thd
			"Cxx_lpg_ena_ad_prs_min_thd"
			VALUE
			0x73844
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lpg_fl_lean_diag_dly
			"Cxx_lpg_fl_lean_diag_dly"
			VALUE
			0x737EE
			DATA_RECORD_UBYTE
			32.64
			F_0v128_p0_75
			0
			32.64
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lpg_flow_fmt_fac
			"Cxx_lpg_flow_fmt_fac"
			VALUE
			0x73846
			DATA_RECORD_UWORD
			255.9960938
			F_0v00390625_p0_90
			0
			255.9960938
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lpg_gas_dly
			"Cxx_lpg_gas_dly"
			VALUE
			0x73848
			DATA_RECORD_UWORD
			2097.12
			F_0v032_p0_99
			0
			2097.12
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lpg_gas_lpg_dly
			"Cxx_lpg_gas_lpg_dly"
			VALUE
			0x7384A
			DATA_RECORD_UWORD
			2097.12
			F_0v032_p0_99
			0
			2097.12
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lpg_gas_lpg_max_n
			"Cxx_lpg_gas_lpg_max_n"
			VALUE
			0x737EF
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lpg_gas_lpg_max_prs
			"Cxx_lpg_gas_lpg_max_prs"
			VALUE
			0x7384C
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lpg_gas_lpg_min_n
			"Cxx_lpg_gas_lpg_min_n"
			VALUE
			0x737F0
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lpg_gas_lpg_min_prs
			"Cxx_lpg_gas_lpg_min_prs"
			VALUE
			0x7384E
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lpg_gas_max_n
			"Cxx_lpg_gas_max_n"
			VALUE
			0x737F1
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lpg_gas_max_prs
			"Cxx_lpg_gas_max_prs"
			VALUE
			0x73850
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lpg_gas_min_n
			"Cxx_lpg_gas_min_n"
			VALUE
			0x737F2
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lpg_gas_min_prs
			"Cxx_lpg_gas_min_prs"
			VALUE
			0x73852
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lpg_gas_pump_cut_dly
			"Cxx_lpg_gas_pump_cut_dly"
			VALUE
			0x73854
			DATA_RECORD_UWORD
			67107.84
			F_1v024_p0_119
			0
			67107.84
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lpg_gas_pump_wup_dly
			"Cxx_lpg_gas_pump_wup_dly"
			VALUE
			0x73856
			DATA_RECORD_UWORD
			2097.12
			F_0v032_p0_99
			0
			2097.12
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lpg_gas_trs_cyc_nr
			"Cxx_lpg_gas_trs_cyc_nr"
			VALUE
			0x737F3
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lpg_max_nr_lpg_stal
			"Cxx_lpg_max_nr_lpg_stal"
			VALUE
			0x737F4
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lpg_max_nr_lpg_stall
			"Cxx_lpg_max_nr_lpg_stall"
			VALUE
			0x737F5
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lpg_prs_diag_dly
			"Cxx_lpg_prs_diag_dly"
			VALUE
			0x737F6
			DATA_RECORD_UBYTE
			32640
			F_128_p0_125
			0
			32640
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lpg_prs_dif_stab_thd
			"Cxx_lpg_prs_dif_stab_thd"
			VALUE
			0x73858
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p0_21
			0
			242479.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lpg_prs_dif_trs_thd
			"Cxx_lpg_prs_dif_trs_thd"
			VALUE
			0x7385A
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p0_21
			0
			242479.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lpg_prs_fil_fac
			"Cxx_lpg_prs_fil_fac"
			VALUE
			0x737F7
			DATA_RECORD_UBYTE
			99.603
			F_0v3906_p0_133
			0
			99.603
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lpg_pump_run_cdn_dly
			"Cxx_lpg_pump_run_cdn_dly"
			VALUE
			0x7385C
			DATA_RECORD_UWORD
			67107.84
			F_1v024_p0_119
			0
			67107.84
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lpg_rich_cl_tco_thd
			"Cxx_lpg_rich_cl_tco_thd"
			VALUE
			0x737F8
			DATA_RECORD_UBYTE
			255
			F_1_m40_40
			-40
			215
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lpg_stall_dly
			"Cxx_lpg_stall_dly"
			VALUE
			0x737F9
			DATA_RECORD_UBYTE
			32.64
			F_0v128_p0_75
			0
			32.64
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lpg_tco_ti_cor_fac
			"Cxx_lpg_tco_ti_cor_fac"
			VALUE
			0x737FA
			DATA_RECORD_UBYTE
			255
			F_1_p0_9
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lpg_wup_cor_dec
			"Cxx_lpg_wup_cor_dec"
			VALUE
			0x737FB
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lpg_wup_cor_inc
			"Cxx_lpg_wup_cor_inc"
			VALUE
			0x737FC
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lpg_zon_2_ad_prs_min
			"Cxx_lpg_zon_2_ad_prs_min"
			VALUE
			0x7385E
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lpg_zon_3_ad_prs_min
			"Cxx_lpg_zon_3_ad_prs_min"
			VALUE
			0x73860
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lpg_zon_4_ad_prs_min
			"Cxx_lpg_zon_4_ad_prs_min"
			VALUE
			0x73862
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lpg_zon_5_ad_prs_min
			"Cxx_lpg_zon_5_ad_prs_min"
			VALUE
			0x73864
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lvl_diag_cata
			"Cxx_lvl_diag_cata"
			VALUE
			0x7773E
			DATA_RECORD_UBYTE
			255
			F_1_p0_9
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lvl_diag_lamb
			"Cxx_lvl_diag_lamb"
			VALUE
			0x7773D
			DATA_RECORD_UBYTE
			255
			F_1_p0_9
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lvl_diag_sa
			"Cxx_lvl_diag_sa"
			VALUE
			0x7773F
			DATA_RECORD_UBYTE
			255
			F_1_p0_9
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_maf_clc_fac
			"Cxx_maf_clc_fac"
			VALUE
			0x77717
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_maf_clc_fil_fac
			"Cxx_maf_clc_fil_fac"
			VALUE
			0x77718
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_maf_clc_off_n_max
			"Cxx_maf_clc_off_n_max"
			VALUE
			0x77719
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_map_cut_decl_dly
			"Cxx_map_cut_decl_dly"
			VALUE
			0x758F7
			DATA_RECORD_UBYTE
			8.16
			F_0v032_p0_99
			0
			8.16
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_map_cut_decl_dly_lpg
			"Cxx_map_cut_decl_dly_lpg"
			VALUE
			0x758F8
			DATA_RECORD_UBYTE
			8.16
			F_0v032_p0_99
			0
			8.16
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_map_fil_fac
			"Cxx_map_fil_fac"
			VALUE
			0x7771A
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_map_min_thr_adj
			"Cxx_map_min_thr_adj"
			VALUE
			0x70D7E
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_map_rat_max_thr_adj
			"Cxx_map_rat_max_thr_adj"
			VALUE
			0x70D80
			DATA_RECORD_UWORD
			9999.98565
			F_0v15259_p0_186
			0
			9999.98565
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_map_slop_inj_cut
			"Cxx_map_slop_inj_cut"
			VALUE
			0x7ADF0
			DATA_RECORD_SWORD
			242479.5
			F_3v7_p0_21
			-121241.6
			121237.9
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_map_thd_vs_test
			"Cxx_map_thd_vs_test"
			VALUE
			0x7903C
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_alt_pwm
			"Cxx_max_alt_pwm"
			VALUE
			0x70DFA
			DATA_RECORD_UBYTE
			99.9999993
			F_0v39215686_p0_209
			0
			99.9999993
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_amp
			"Cxx_max_amp"
			VALUE
			0x7B0B0
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_b0_ini
			"Cxx_max_b0_ini"
			VALUE
			0x731F2
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_b1_ini
			"Cxx_max_b1_ini"
			VALUE
			0x731F3
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_b2_ini
			"Cxx_max_b2_ini"
			VALUE
			0x731F4
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_b3_ini
			"Cxx_max_b3_ini"
			VALUE
			0x731F5
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_b4_ini
			"Cxx_max_b4_ini"
			VALUE
			0x731F6
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_cl_ti_fac
			"Cxx_max_cl_ti_fac"
			VALUE
			0x758F9
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_cld_fac_thd
			"Cxx_max_cld_fac_thd"
			VALUE
			0x758FA
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_cld_ofs_thd
			"Cxx_max_cld_ofs_thd"
			VALUE
			0x758FB
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_diag_ti_ofs1
			"Cxx_max_diag_ti_ofs1"
			VALUE
			0x75958
			DATA_RECORD_SWORD
			65535
			Id_0x00
			-32768
			32767
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_dif_mfld_mv_prs
			"Cxx_max_dif_mfld_mv_prs"
			VALUE
			0x7903E
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p0_21
			0
			242479.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_dif_whl_angl
			"Cxx_max_dif_whl_angl"
			VALUE
			0x73646
			DATA_RECORD_UWORD
			2867.8116
			F_0v04376_p0_180
			0
			2867.8116
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_dyn_iga_tq
			"Cxx_max_dyn_iga_tq"
			VALUE
			0x71D1C
			DATA_RECORD_SWORD
			8191.875
			F_0v125_p0_30
			-4096
			4095.875
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_eng_eal
			"Cxx_max_eng_eal"
			VALUE
			0x7322C
			DATA_RECORD_UWORD
			399.9938965
			F_0v0061035156_p0_23
			0
			399.9938965
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_fast_agb_tq
			"Cxx_max_fast_agb_tq"
			VALUE
			0x71EDF
			DATA_RECORD_UBYTE
			510
			F_2_p0_198
			0
			510
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_fast_slop_ctr
			"Cxx_max_fast_slop_ctr"
			VALUE
			0x76F6C
			DATA_RECORD_UWORD
			65535
			F_1_p0_53
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_gear_cge_dly
			"Cxx_max_gear_cge_dly"
			VALUE
			0x71EE0
			DATA_RECORD_UBYTE
			32640
			F_128_p0_125
			0
			32640
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_h_alt_pwm_per
			"Cxx_max_h_alt_pwm_per"
			VALUE
			0x70E0E
			DATA_RECORD_UWORD
			209.712
			F_0v0032_p0_8
			0
			209.712
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_imd_ti_ad_fac
			"Cxx_max_imd_ti_ad_fac"
			VALUE
			0x758FC
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_imd_ti_ad_ofs
			"Cxx_max_imd_ti_ad_ofs"
			VALUE
			0x758FD
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_is_i_ofs
			"Cxx_max_is_i_ofs"
			VALUE
			0x73C08
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_is_min_ad_pwm
			"Cxx_max_is_min_ad_pwm"
			VALUE
			0x73AE0
			DATA_RECORD_SWORD
			65535
			Id_0x00
			-32768
			32767
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_is_ocl_t
			"Cxx_max_is_ocl_t"
			VALUE
			0x758FE
			DATA_RECORD_UBYTE
			1044.48
			F_4v096_p0_12
			0
			1044.48
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_is_ti_ofs2
			"Cxx_max_is_ti_ofs2"
			VALUE
			0x7595A
			DATA_RECORD_SWORD
			65535
			Id_0x00
			-32768
			32767
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_l_alt_pwm_per
			"Cxx_max_l_alt_pwm_per"
			VALUE
			0x70E0C
			DATA_RECORD_UWORD
			209.712
			F_0v0032_p0_8
			0
			209.712
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_mes_prs_fail_sens
			"Cxx_max_mes_prs_fail_sens"
			VALUE
			0x78744
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_mv_ti_ad_fac
			"Cxx_max_mv_ti_ad_fac"
			VALUE
			0x758FF
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_mv_ti_ad_ofs
			"Cxx_max_mv_ti_ad_ofs"
			VALUE
			0x75900
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_n_ad_sp_dif
			"Cxx_max_n_ad_sp_dif"
			VALUE
			0x73C0A
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_n_fil_ofs2
			"Cxx_max_n_fil_ofs2"
			VALUE
			0x75901
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_n_ovn_ofs
			"Cxx_max_n_ovn_ofs"
			VALUE
			0x78AB6
			DATA_RECORD_SBYTE
			2040
			F_8_p0_210
			-1024
			1016
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_n_thd_oil_ovn
			"Cxx_max_n_thd_oil_ovn"
			VALUE
			0x78BA5
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_prs_fil_ofs2
			"Cxx_max_prs_fil_ofs2"
			VALUE
			0x76F6E
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_prs_spg_dif
			"Cxx_max_prs_spg_dif"
			VALUE
			0x7847B
			DATA_RECORD_UBYTE
			943.5
			F_3v7_p0_21
			0
			943.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_run_ac_dyn_iga
			"Cxx_max_run_ac_dyn_iga"
			VALUE
			0x71CCD
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_run_ac_dyn_iga1
			"Cxx_max_run_ac_dyn_iga1"
			VALUE
			0x71CCE
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_run_dyn_iga
			"Cxx_max_run_dyn_iga"
			VALUE
			0x71CCF
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_run_dyn_iga1
			"Cxx_max_run_dyn_iga1"
			VALUE
			0x71CD2
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_run_dyn_iga2
			"Cxx_max_run_dyn_iga2"
			VALUE
			0x71CD3
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_run_dyn_iga3
			"Cxx_max_run_dyn_iga3"
			VALUE
			0x71CD4
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_run_dyn_iga4
			"Cxx_max_run_dyn_iga4"
			VALUE
			0x71CD5
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_run_dyn_iga5
			"Cxx_max_run_dyn_iga5"
			VALUE
			0x71CD6
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_run_dyn_iga_fac
			"Cxx_max_run_dyn_iga_fac"
			VALUE
			0x71CD0
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_run_dyn_iga_lpg
			"Cxx_max_run_dyn_iga_lpg"
			VALUE
			0x71CD1
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_slop_thd_n_ovn
			"Cxx_max_slop_thd_n_ovn"
			VALUE
			0x7950C
			DATA_RECORD_UBYTE
			127.5
			F_0v5_p0_211
			0
			127.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_slop_tq_rat_ovn
			"Cxx_max_slop_tq_rat_ovn"
			VALUE
			0x7950D
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_stop_ac_dyn_iga
			"Cxx_max_stop_ac_dyn_iga"
			VALUE
			0x71CD7
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_stop_ac_dyn_iga1
			"Cxx_max_stop_ac_dyn_iga1"
			VALUE
			0x71CD8
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_stop_dyn_iga
			"Cxx_max_stop_dyn_iga"
			VALUE
			0x71CD9
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_stop_dyn_iga1
			"Cxx_max_stop_dyn_iga1"
			VALUE
			0x71CDB
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_stop_dyn_iga2
			"Cxx_max_stop_dyn_iga2"
			VALUE
			0x71CDC
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_stop_dyn_iga3
			"Cxx_max_stop_dyn_iga3"
			VALUE
			0x71CDD
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_stop_dyn_iga4
			"Cxx_max_stop_dyn_iga4"
			VALUE
			0x71CDE
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_stop_dyn_iga5
			"Cxx_max_stop_dyn_iga5"
			VALUE
			0x71CDF
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_stop_dyn_iga_lpg
			"Cxx_max_stop_dyn_iga_lpg"
			VALUE
			0x71CDA
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_t_toth
			"Cxx_max_t_toth"
			VALUE
			0x784A8
			DATA_RECORD_UWORD
			209.712
			F_0v0032_p0_8
			0
			209.712
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_tco_fil_ofs2
			"Cxx_max_tco_fil_ofs2"
			VALUE
			0x75902
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_thd_trt1_ini
			"Cxx_max_thd_trt1_ini"
			VALUE
			0x736D8
			DATA_RECORD_UWORD
			6399.902344
			F_0v09765625_p0_71
			0
			6399.902344
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_thd_trt2_ini
			"Cxx_max_thd_trt2_ini"
			VALUE
			0x736DA
			DATA_RECORD_UWORD
			6399.902344
			F_0v09765625_p0_71
			0
			6399.902344
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_thr_ar
			"Cxx_max_thr_ar"
			VALUE
			0x78656
			DATA_RECORD_UWORD
			3932.1
			F_0v06_p0_212
			0
			3932.1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_ti_ofs1
			"Cxx_max_ti_ofs1"
			VALUE
			0x7595C
			DATA_RECORD_SWORD
			65535
			Id_0x00
			-32768
			32767
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_ti_p_cor
			"Cxx_max_ti_p_cor"
			VALUE
			0x76F70
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_ti_p_cor_lpg
			"Cxx_max_ti_p_cor_lpg"
			VALUE
			0x76F72
			DATA_RECORD_UWORD
			65535
			F_1_p0_9
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_tq_ovn_cor
			"Cxx_max_tq_ovn_cor"
			VALUE
			0x7950E
			DATA_RECORD_UBYTE
			510
			F_2_p0_198
			0
			510
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_max_val_dif_prs_acq
			"Cxx_max_val_dif_prs_acq"
			VALUE
			0x78746
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p0_21
			0
			242479.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mdf1_clu_dly
			"Cxx_mdf1_clu_dly"
			VALUE
			0x73731
			DATA_RECORD_UBYTE
			16320
			F_64_p0_145
			0
			16320
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mdf1_clu_off_dly
			"Cxx_mdf1_clu_off_dly"
			VALUE
			0x73732
			DATA_RECORD_UBYTE
			16320
			F_64_p0_145
			0
			16320
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mdf1_is_cor
			"Cxx_mdf1_is_cor"
			VALUE
			0x73AB6
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mdf1_is_cor1
			"Cxx_mdf1_is_cor1"
			VALUE
			0x73AB9
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mdf1_is_cor_appl_dly
			"Cxx_mdf1_is_cor_appl_dly"
			VALUE
			0x73AB7
			DATA_RECORD_UBYTE
			4080
			F_16_p0_10
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mdf1_is_cor_appl_dly1
			"Cxx_mdf1_is_cor_appl_dly1"
			VALUE
			0x73AB8
			DATA_RECORD_UBYTE
			4080
			F_16_p0_10
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mdf1_off_tco_thd
			"Cxx_mdf1_off_tco_thd"
			VALUE
			0x73733
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mdf1_on_tco_thd
			"Cxx_mdf1_on_tco_thd"
			VALUE
			0x73734
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mdf1_on_tco_thd_hys
			"Cxx_mdf1_on_tco_thd_hys"
			VALUE
			0x73735
			DATA_RECORD_UBYTE
			159.375
			F_0v625_p0_143
			0
			159.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mdf1_pow
			"Cxx_mdf1_pow"
			VALUE
			0x72156
			DATA_RECORD_UBYTE
			5100
			F_20_p0_63
			0
			5100
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mdf2_is_cor
			"Cxx_mdf2_is_cor"
			VALUE
			0x73ABA
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mdf2_is_cor1
			"Cxx_mdf2_is_cor1"
			VALUE
			0x73ABD
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mdf2_is_cor_appl_dly
			"Cxx_mdf2_is_cor_appl_dly"
			VALUE
			0x73ABB
			DATA_RECORD_UBYTE
			4080
			F_16_p0_10
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mdf2_is_cor_appl_dly1
			"Cxx_mdf2_is_cor_appl_dly1"
			VALUE
			0x73ABC
			DATA_RECORD_UBYTE
			4080
			F_16_p0_10
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mdf2_off_tco_thd
			"Cxx_mdf2_off_tco_thd"
			VALUE
			0x73736
			DATA_RECORD_UBYTE
			159.375
			F_0v625_p0_143
			0
			159.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mdf2_on_tco_thd
			"Cxx_mdf2_on_tco_thd"
			VALUE
			0x73737
			DATA_RECORD_UBYTE
			159.375
			F_0v625_p0_143
			0
			159.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mdf2_pow
			"Cxx_mdf2_pow"
			VALUE
			0x72157
			DATA_RECORD_UBYTE
			5100
			F_20_p0_63
			0
			5100
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mdf_1_cmd_ena_thd_tco
			"Cxx_mdf_1_cmd_ena_thd_tco"
			VALUE
			0x73730
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mdf_ac_prs_hys
			"Cxx_mdf_ac_prs_hys"
			VALUE
			0x72196
			DATA_RECORD_UWORD
			6553.5
			F_0v1_p0_141
			0
			6553.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mdf_ac_prs_thd1
			"Cxx_mdf_ac_prs_thd1"
			VALUE
			0x72198
			DATA_RECORD_UWORD
			6553.5
			F_0v1_p0_141
			0
			6553.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mdf_ac_prs_thd2
			"Cxx_mdf_ac_prs_thd2"
			VALUE
			0x7219A
			DATA_RECORD_UWORD
			6553.5
			F_0v1_p0_141
			0
			6553.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mdf_ac_prs_thd3
			"Cxx_mdf_ac_prs_thd3"
			VALUE
			0x7219C
			DATA_RECORD_UWORD
			6553.5
			F_0v1_p0_141
			0
			6553.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mdf_cor
			"Cxx_mdf_cor"
			VALUE
			0x73AB5
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_med_zon_vh_vs_dsb
			"Cxx_med_zon_vh_vs_dsb"
			VALUE
			0x73625
			DATA_RECORD_UBYTE
			255
			F_1_p0_58
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_med_zon_wid
			"Cxx_med_zon_wid"
			VALUE
			0x73648
			DATA_RECORD_UWORD
			2867.8116
			F_0v04376_p0_180
			0
			2867.8116
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mem_tco_fail_max_tco
			"Cxx_mem_tco_fail_max_tco"
			VALUE
			0x7B191
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mem_tia_fail_max_tia
			"Cxx_mem_tia_fail_max_tia"
			VALUE
			0x70D98
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfld_dly_fac
			"Cxx_mfld_dly_fac"
			VALUE
			0x747F2
			DATA_RECORD_UBYTE
			1.9921875
			F_0v0078125_p0_213
			0
			1.9921875
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfld_mdl_fac
			"Cxx_mfld_mdl_fac"
			VALUE
			0x747F3
			DATA_RECORD_UBYTE
			7.96875
			F_0v03125_p0_214
			0
			7.96875
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfld_vol_fac
			"Cxx_mfld_vol_fac"
			VALUE
			0x7865F
			DATA_RECORD_UBYTE
			1.9921875
			F_0v0078125_p0_213
			0
			1.9921875
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfld_vol_rat
			"Cxx_mfld_vol_rat"
			VALUE
			0x7AC12
			DATA_RECORD_UWORD
			524280
			F_8_p0_215
			0
			524280
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_ac_prs
			"Cxx_mfnrsta_ac_prs"
			VALUE
			0x70ABD
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_ac_rcpt
			"Cxx_mfnrsta_ac_rcpt"
			VALUE
			0x70ABE
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_acr_oc
			"Cxx_mfnrsta_acr_oc"
			VALUE
			0x70ABF
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_acr_scg
			"Cxx_mfnrsta_acr_scg"
			VALUE
			0x70AC0
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_acr_vb_sc
			"Cxx_mfnrsta_acr_vb_sc"
			VALUE
			0x70AC1
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_actr_rly
			"Cxx_mfnrsta_actr_rly"
			VALUE
			0x70AC2
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_actr_rly_cut
			"Cxx_mfnrsta_actr_rly_cut"
			VALUE
			0x70AC3
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_agb_conv_stt
			"Cxx_mfnrsta_agb_conv_stt"
			VALUE
			0x70AC4
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_agb_gear
			"Cxx_mfnrsta_agb_gear"
			VALUE
			0x70AC5
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_agb_rcpt
			"Cxx_mfnrsta_agb_rcpt"
			VALUE
			0x70AC6
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_agb_tq_nok
			"Cxx_mfnrsta_agb_tq_nok"
			VALUE
			0x70AC7
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_air
			"Cxx_mfnrsta_air"
			VALUE
			0x70AC8
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_alt_ecu
			"Cxx_mfnrsta_alt_ecu"
			VALUE
			0x70AC9
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_alt_load_in
			"Cxx_mfnrsta_alt_load_in"
			VALUE
			0x70ACB
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_alt_mux
			"Cxx_mfnrsta_alt_mux"
			VALUE
			0x70ACA
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_bkup_mem
			"Cxx_mfnrsta_bkup_mem"
			VALUE
			0x70ACC
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_checksum
			"Cxx_mfnrsta_checksum"
			VALUE
			0x70ACD
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_clu
			"Cxx_mfnrsta_clu"
			VALUE
			0x70ACE
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_cp_oc
			"Cxx_mfnrsta_cp_oc"
			VALUE
			0x70ACF
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_cp_scg
			"Cxx_mfnrsta_cp_scg"
			VALUE
			0x70AD0
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_cp_vb_sc
			"Cxx_mfnrsta_cp_vb_sc"
			VALUE
			0x70AD1
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_crk
			"Cxx_mfnrsta_crk"
			VALUE
			0x70AD2
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_crk_nr
			"Cxx_mfnrsta_crk_nr"
			VALUE
			0x70AD3
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_cru_brk_cnt1
			"Cxx_mfnrsta_cru_brk_cnt1"
			VALUE
			0x70AD4
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_cru_brk_cnt2
			"Cxx_mfnrsta_cru_brk_cnt2"
			VALUE
			0x70AD5
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_cru_on_off_chr
			"Cxx_mfnrsta_cru_on_off_chr"
			VALUE
			0x70AD6
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_cru_whl_cmd
			"Cxx_mfnrsta_cru_whl_cmd"
			VALUE
			0x70AD7
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_el_wind_rcpt
			"Cxx_mfnrsta_el_wind_rcpt"
			VALUE
			0x70AD8
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_eng_temp_oc
			"Cxx_mfnrsta_eng_temp_oc"
			VALUE
			0x70AD9
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_eng_temp_scg
			"Cxx_mfnrsta_eng_temp_scg"
			VALUE
			0x70ADA
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_eng_temp_vb_sc
			"Cxx_mfnrsta_eng_temp_vb_sc"
			VALUE
			0x70ADB
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_eng_whl
			"Cxx_mfnrsta_eng_whl"
			VALUE
			0x70ADC
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_fsys
			"Cxx_mfnrsta_fsys"
			VALUE
			0x70ADD
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_fsys_lpg
			"Cxx_mfnrsta_fsys_lpg"
			VALUE
			0x70ADE
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_gas_pump_oc
			"Cxx_mfnrsta_gas_pump_oc"
			VALUE
			0x70ADF
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_gas_pump_scg
			"Cxx_mfnrsta_gas_pump_scg"
			VALUE
			0x70AE0
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_gas_pump_vb_sc
			"Cxx_mfnrsta_gas_pump_vb_sc"
			VALUE
			0x70AE1
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_igc_1_oc
			"Cxx_mfnrsta_igc_1_oc"
			VALUE
			0x70AE2
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_igc_1_vb_sc
			"Cxx_mfnrsta_igc_1_vb_sc"
			VALUE
			0x70AE3
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_igc_2_oc
			"Cxx_mfnrsta_igc_2_oc"
			VALUE
			0x70AE4
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_igc_2_vb_sc
			"Cxx_mfnrsta_igc_2_vb_sc"
			VALUE
			0x70AE5
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_igc_3_oc
			"Cxx_mfnrsta_igc_3_oc"
			VALUE
			0x70AE6
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_igc_3_vb_sc
			"Cxx_mfnrsta_igc_3_vb_sc"
			VALUE
			0x70AE7
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_igc_4_oc
			"Cxx_mfnrsta_igc_4_oc"
			VALUE
			0x70AE8
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_igc_4_vb_sc
			"Cxx_mfnrsta_igc_4_vb_sc"
			VALUE
			0x70AE9
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_inj1_oc
			"Cxx_mfnrsta_inj1_oc"
			VALUE
			0x70AEA
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_inj1_scg
			"Cxx_mfnrsta_inj1_scg"
			VALUE
			0x70AEB
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_inj1_vb_sc
			"Cxx_mfnrsta_inj1_vb_sc"
			VALUE
			0x70AEC
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_inj2_oc
			"Cxx_mfnrsta_inj2_oc"
			VALUE
			0x70AED
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_inj2_scg
			"Cxx_mfnrsta_inj2_scg"
			VALUE
			0x70AEE
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_inj2_vb_sc
			"Cxx_mfnrsta_inj2_vb_sc"
			VALUE
			0x70AEF
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_inj3_oc
			"Cxx_mfnrsta_inj3_oc"
			VALUE
			0x70AF0
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_inj3_scg
			"Cxx_mfnrsta_inj3_scg"
			VALUE
			0x70AF1
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_inj3_vb_sc
			"Cxx_mfnrsta_inj3_vb_sc"
			VALUE
			0x70AF2
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_inj4_oc
			"Cxx_mfnrsta_inj4_oc"
			VALUE
			0x70AF3
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_inj4_scg
			"Cxx_mfnrsta_inj4_scg"
			VALUE
			0x70AF4
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_inj4_vb_sc
			"Cxx_mfnrsta_inj4_vb_sc"
			VALUE
			0x70AF5
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_inj_ecu
			"Cxx_mfnrsta_inj_ecu"
			VALUE
			0x70AF6
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_ip_inj_cnt
			"Cxx_mfnrsta_ip_inj_cnt"
			VALUE
			0x70AF7
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_knk
			"Cxx_mfnrsta_knk"
			VALUE
			0x70AF8
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_lbdw_hot_oc
			"Cxx_mfnrsta_lbdw_hot_oc"
			VALUE
			0x70AFC
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_lbdw_hot_scg
			"Cxx_mfnrsta_lbdw_hot_scg"
			VALUE
			0x70AFD
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_lbdw_hot_vb_sc
			"Cxx_mfnrsta_lbdw_hot_vb_sc"
			VALUE
			0x70AFE
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_lbdw_oc
			"Cxx_mfnrsta_lbdw_oc"
			VALUE
			0x70AF9
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_lbdw_pump_crt
			"Cxx_mfnrsta_lbdw_pump_crt"
			VALUE
			0x70AFF
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_lbdw_scg
			"Cxx_mfnrsta_lbdw_scg"
			VALUE
			0x70AFA
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_lbdw_vb_sc
			"Cxx_mfnrsta_lbdw_vb_sc"
			VALUE
			0x70AFB
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_lbup_hot_oc
			"Cxx_mfnrsta_lbup_hot_oc"
			VALUE
			0x70B03
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_lbup_hot_scg
			"Cxx_mfnrsta_lbup_hot_scg"
			VALUE
			0x70B04
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_lbup_hot_vb_sc
			"Cxx_mfnrsta_lbup_hot_vb_sc"
			VALUE
			0x70B05
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_lbup_oc
			"Cxx_mfnrsta_lbup_oc"
			VALUE
			0x70B00
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_lbup_pump_crt
			"Cxx_mfnrsta_lbup_pump_crt"
			VALUE
			0x70B06
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_lbup_scg
			"Cxx_mfnrsta_lbup_scg"
			VALUE
			0x70B01
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_lbup_vb_sc
			"Cxx_mfnrsta_lbup_vb_sc"
			VALUE
			0x70B02
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_lpg_rcpt
			"Cxx_mfnrsta_lpg_rcpt"
			VALUE
			0x70B07
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_map
			"Cxx_mfnrsta_map"
			VALUE
			0x70B08
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_map_chr
			"Cxx_mfnrsta_map_chr"
			VALUE
			0x70B09
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_mastervac_cc
			"Cxx_mfnrsta_mastervac_cc"
			VALUE
			0x70B0A
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_mastervac_oc
			"Cxx_mfnrsta_mastervac_oc"
			VALUE
			0x70B0B
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_mcut_sens1
			"Cxx_mfnrsta_mcut_sens1"
			VALUE
			0x70B0C
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_mdf1_oc
			"Cxx_mfnrsta_mdf1_oc"
			VALUE
			0x70B0D
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_mdf1_scg
			"Cxx_mfnrsta_mdf1_scg"
			VALUE
			0x70B0E
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_mdf1_vb_sc
			"Cxx_mfnrsta_mdf1_vb_sc"
			VALUE
			0x70B0F
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_mdf2_oc
			"Cxx_mfnrsta_mdf2_oc"
			VALUE
			0x70B10
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_mdf2_scg
			"Cxx_mfnrsta_mdf2_scg"
			VALUE
			0x70B11
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_mdf2_vb_sc
			"Cxx_mfnrsta_mdf2_vb_sc"
			VALUE
			0x70B12
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_min_gas_lvl
			"Cxx_mfnrsta_min_gas_lvl"
			VALUE
			0x70B13
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_min_lpg_lvl
			"Cxx_mfnrsta_min_lpg_lvl"
			VALUE
			0x70B14
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_mis_cata
			"Cxx_mfnrsta_mis_cata"
			VALUE
			0x70B15
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_mis_cata_1
			"Cxx_mfnrsta_mis_cata_1"
			VALUE
			0x70B16
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_mis_cata_1_lpg
			"Cxx_mfnrsta_mis_cata_1_lpg"
			VALUE
			0x70B17
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_mis_cata_2
			"Cxx_mfnrsta_mis_cata_2"
			VALUE
			0x70B18
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_mis_cata_2_lpg
			"Cxx_mfnrsta_mis_cata_2_lpg"
			VALUE
			0x70B19
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_mis_cata_3
			"Cxx_mfnrsta_mis_cata_3"
			VALUE
			0x70B1A
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_mis_cata_3_lpg
			"Cxx_mfnrsta_mis_cata_3_lpg"
			VALUE
			0x70B1B
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_mis_cata_4
			"Cxx_mfnrsta_mis_cata_4"
			VALUE
			0x70B1C
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_mis_cata_4_lpg
			"Cxx_mfnrsta_mis_cata_4_lpg"
			VALUE
			0x70B1D
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_mis_cata_gas
			"Cxx_mfnrsta_mis_cata_gas"
			VALUE
			0x70B1E
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_mis_cata_lpg
			"Cxx_mfnrsta_mis_cata_lpg"
			VALUE
			0x70B1F
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_mis_fast
			"Cxx_mfnrsta_mis_fast"
			VALUE
			0x70B20
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_mis_lih
			"Cxx_mfnrsta_mis_lih"
			VALUE
			0x70B21
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_mis_polu
			"Cxx_mfnrsta_mis_polu"
			VALUE
			0x70B22
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_mis_polu_1
			"Cxx_mfnrsta_mis_polu_1"
			VALUE
			0x70B23
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_mis_polu_1_lpg
			"Cxx_mfnrsta_mis_polu_1_lpg"
			VALUE
			0x70B24
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_mis_polu_2
			"Cxx_mfnrsta_mis_polu_2"
			VALUE
			0x70B25
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_mis_polu_2_lpg
			"Cxx_mfnrsta_mis_polu_2_lpg"
			VALUE
			0x70B26
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_mis_polu_3
			"Cxx_mfnrsta_mis_polu_3"
			VALUE
			0x70B27
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_mis_polu_3_lpg
			"Cxx_mfnrsta_mis_polu_3_lpg"
			VALUE
			0x70B28
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_mis_polu_4
			"Cxx_mfnrsta_mis_polu_4"
			VALUE
			0x70B29
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_mis_polu_4_lpg
			"Cxx_mfnrsta_mis_polu_4_lpg"
			VALUE
			0x70B2A
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_mis_polu_gas
			"Cxx_mfnrsta_mis_polu_gas"
			VALUE
			0x70B2B
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_mis_polu_lpg
			"Cxx_mfnrsta_mis_polu_lpg"
			VALUE
			0x70B2C
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_mvac_pump_oc
			"Cxx_mfnrsta_mvac_pump_oc"
			VALUE
			0x70B2D
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_mvac_pump_scg
			"Cxx_mfnrsta_mvac_pump_scg"
			VALUE
			0x70B2E
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_mvac_pump_vb_sc
			"Cxx_mfnrsta_mvac_pump_vb_sc"
			VALUE
			0x70B2F
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_mvac_sys
			"Cxx_mfnrsta_mvac_sys"
			VALUE
			0x70B30
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_obd_cata
			"Cxx_mfnrsta_obd_cata"
			VALUE
			0x70B31
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_obd_lamb
			"Cxx_mfnrsta_obd_lamb"
			VALUE
			0x70B32
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_obd_sa
			"Cxx_mfnrsta_obd_sa"
			VALUE
			0x70B33
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_oil_cc
			"Cxx_mfnrsta_oil_cc"
			VALUE
			0x70B34
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_oil_co
			"Cxx_mfnrsta_oil_co"
			VALUE
			0x70B35
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_pdl_sens1_oc
			"Cxx_mfnrsta_pdl_sens1_oc"
			VALUE
			0x70B36
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_pdl_sens1_vb_sc
			"Cxx_mfnrsta_pdl_sens1_vb_sc"
			VALUE
			0x70B37
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_pdl_sens2_oc
			"Cxx_mfnrsta_pdl_sens2_oc"
			VALUE
			0x70B38
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_pdl_sens2_vb_sc
			"Cxx_mfnrsta_pdl_sens2_vb_sc"
			VALUE
			0x70B39
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_pdl_sens_chr
			"Cxx_mfnrsta_pdl_sens_chr"
			VALUE
			0x70B3A
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_pmh_cc
			"Cxx_mfnrsta_pmh_cc"
			VALUE
			0x70B3B
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_pmh_co
			"Cxx_mfnrsta_pmh_co"
			VALUE
			0x70B3C
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_pow_lbdw
			"Cxx_mfnrsta_pow_lbdw"
			VALUE
			0x70B3D
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_pow_lbup
			"Cxx_mfnrsta_pow_lbup"
			VALUE
			0x70B3E
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_ptc
			"Cxx_mfnrsta_ptc"
			VALUE
			0x70B3F
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_ptc_rov_oc
			"Cxx_mfnrsta_ptc_rov_oc"
			VALUE
			0x70B40
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_ptc_rov_scg
			"Cxx_mfnrsta_ptc_rov_scg"
			VALUE
			0x70B41
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_ptc_rov_vb_sc
			"Cxx_mfnrsta_ptc_rov_vb_sc"
			VALUE
			0x70B42
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_pws_1
			"Cxx_mfnrsta_pws_1"
			VALUE
			0x70B43
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_pws_2
			"Cxx_mfnrsta_pws_2"
			VALUE
			0x70B44
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_pws_pdl2
			"Cxx_mfnrsta_pws_pdl2"
			VALUE
			0x70B45
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_pws_thr_pdl1
			"Cxx_mfnrsta_pws_thr_pdl1"
			VALUE
			0x70B46
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_rams_map_tq
			"Cxx_mfnrsta_rams_map_tq"
			VALUE
			0x70B47
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_rams_pdl
			"Cxx_mfnrsta_rams_pdl"
			VALUE
			0x70B4A
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_rams_tq_ctl
			"Cxx_mfnrsta_rams_tq_ctl"
			VALUE
			0x70B48
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_rams_tq_req
			"Cxx_mfnrsta_rams_tq_req"
			VALUE
			0x70B49
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_reserve_3_oc
			"Cxx_mfnrsta_reserve_3_oc"
			VALUE
			0x70B4B
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_reserve_3_scg
			"Cxx_mfnrsta_reserve_3_scg"
			VALUE
			0x70B4C
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_reserve_3_vb_sc
			"Cxx_mfnrsta_reserve_3_vb_sc"
			VALUE
			0x70B4D
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_rmc_algopp
			"Cxx_mfnrsta_rmc_algopp"
			VALUE
			0x70B4E
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_rmc_clockpp
			"Cxx_mfnrsta_rmc_clockpp"
			VALUE
			0x70B4F
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_rmc_comspipp
			"Cxx_mfnrsta_rmc_comspipp"
			VALUE
			0x70B50
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_rmc_inhwp
			"Cxx_mfnrsta_rmc_inhwp"
			VALUE
			0x70B51
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_rmc_monitpp
			"Cxx_mfnrsta_rmc_monitpp"
			VALUE
			0x70B52
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_rmc_papmpp
			"Cxx_mfnrsta_rmc_papmpp"
			VALUE
			0x70B53
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_rmc_pedmpp
			"Cxx_mfnrsta_rmc_pedmpp"
			VALUE
			0x70B54
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_rmc_timeoutpp
			"Cxx_mfnrsta_rmc_timeoutpp"
			VALUE
			0x70B55
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_sa_ev_oc
			"Cxx_mfnrsta_sa_ev_oc"
			VALUE
			0x70B59
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_sa_ev_scg
			"Cxx_mfnrsta_sa_ev_scg"
			VALUE
			0x70B5A
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_sa_ev_vb_sc
			"Cxx_mfnrsta_sa_ev_vb_sc"
			VALUE
			0x70B5B
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_sa_oc
			"Cxx_mfnrsta_sa_oc"
			VALUE
			0x70B56
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_sa_scg
			"Cxx_mfnrsta_sa_scg"
			VALUE
			0x70B57
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_sa_vb_sc
			"Cxx_mfnrsta_sa_vb_sc"
			VALUE
			0x70B58
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_spg
			"Cxx_mfnrsta_spg"
			VALUE
			0x70B5C
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_spg_sys
			"Cxx_mfnrsta_spg_sys"
			VALUE
			0x70B5D
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_spi_cc
			"Cxx_mfnrsta_spi_cc"
			VALUE
			0x70B5E
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_svkl_chk_springs
			"Cxx_mfnrsta_svkl_chk_springs"
			VALUE
			0x70B5F
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_svkl_lih
			"Cxx_mfnrsta_svkl_lih"
			VALUE
			0x70B60
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_svkl_oc
			"Cxx_mfnrsta_svkl_oc"
			VALUE
			0x70B61
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_svkl_psn
			"Cxx_mfnrsta_svkl_psn"
			VALUE
			0x70B62
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_svkl_sge
			"Cxx_mfnrsta_svkl_sge"
			VALUE
			0x70B63
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_svkl_trt_srch
			"Cxx_mfnrsta_svkl_trt_srch"
			VALUE
			0x70B64
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_swlk_mem
			"Cxx_mfnrsta_swlk_mem"
			VALUE
			0x70B65
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_tco_acq
			"Cxx_mfnrsta_tco_acq"
			VALUE
			0x70B66
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_tco_chr
			"Cxx_mfnrsta_tco_chr"
			VALUE
			0x70B67
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_thpl_oc
			"Cxx_mfnrsta_thpl_oc"
			VALUE
			0x70B68
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_thpl_scg
			"Cxx_mfnrsta_thpl_scg"
			VALUE
			0x70B69
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_thpl_vb_sc
			"Cxx_mfnrsta_thpl_vb_sc"
			VALUE
			0x70B6A
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_thr_cmd_cpt
			"Cxx_mfnrsta_thr_cmd_cpt"
			VALUE
			0x70B70
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_thr_cmd_vb_sc
			"Cxx_mfnrsta_thr_cmd_vb_sc"
			VALUE
			0x70B71
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_thr_sens1_oc
			"Cxx_mfnrsta_thr_sens1_oc"
			VALUE
			0x70B6B
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_thr_sens1_vb_sc
			"Cxx_mfnrsta_thr_sens1_vb_sc"
			VALUE
			0x70B6C
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_thr_sens2_scg
			"Cxx_mfnrsta_thr_sens2_scg"
			VALUE
			0x70B6D
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_thr_sens2_vb_sc
			"Cxx_mfnrsta_thr_sens2_vb_sc"
			VALUE
			0x70B6E
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_thr_sens_chr
			"Cxx_mfnrsta_thr_sens_chr"
			VALUE
			0x70B6F
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_tia_high
			"Cxx_mfnrsta_tia_high"
			VALUE
			0x70B72
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_tia_low
			"Cxx_mfnrsta_tia_low"
			VALUE
			0x70B73
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_tjy_ctl
			"Cxx_mfnrsta_tjy_ctl"
			VALUE
			0x70B74
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_tlz_ad_b
			"Cxx_mfnrsta_tlz_ad_b"
			VALUE
			0x70B75
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_vb_high
			"Cxx_mfnrsta_vb_high"
			VALUE
			0x70B76
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_vb_low
			"Cxx_mfnrsta_vb_low"
			VALUE
			0x70B77
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_vs_eal
			"Cxx_mfnrsta_vs_eal"
			VALUE
			0x70B78
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_vs_mux
			"Cxx_mfnrsta_vs_mux"
			VALUE
			0x70B79
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_vs_parasite
			"Cxx_mfnrsta_vs_parasite"
			VALUE
			0x70B7A
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_vta_intake_pmh
			"Cxx_mfnrsta_vta_intake_pmh"
			VALUE
			0x70B7B
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_vta_intake_shift
			"Cxx_mfnrsta_vta_intake_shift"
			VALUE
			0x70B7C
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_vvt_int_ev_oc
			"Cxx_mfnrsta_vvt_int_ev_oc"
			VALUE
			0x70B7E
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_vvt_int_ev_scg
			"Cxx_mfnrsta_vvt_int_ev_scg"
			VALUE
			0x70B7F
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_vvt_int_ev_vb_sc
			"Cxx_mfnrsta_vvt_int_ev_vb_sc"
			VALUE
			0x70B80
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_vvt_int_old_off
			"Cxx_mfnrsta_vvt_int_old_off"
			VALUE
			0x70B7D
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_vvt_intake_blk
			"Cxx_mfnrsta_vvt_intake_blk"
			VALUE
			0x70B81
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_vvt_intake_bound
			"Cxx_mfnrsta_vvt_intake_bound"
			VALUE
			0x70B82
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_vvt_intake_dyn
			"Cxx_mfnrsta_vvt_intake_dyn"
			VALUE
			0x70B83
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_vvt_intake_int
			"Cxx_mfnrsta_vvt_intake_int"
			VALUE
			0x70B84
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_vvtc_toth_3
			"Cxx_mfnrsta_vvtc_toth_3"
			VALUE
			0x70B85
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_wat_temp_high
			"Cxx_mfnrsta_wat_temp_high"
			VALUE
			0x70B86
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_wat_temp_low
			"Cxx_mfnrsta_wat_temp_low"
			VALUE
			0x70B87
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_wgc_oc
			"Cxx_mfnrsta_wgc_oc"
			VALUE
			0x70B88
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_wgc_scg
			"Cxx_mfnrsta_wgc_scg"
			VALUE
			0x70B89
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_wgc_vb_sc
			"Cxx_mfnrsta_wgc_vb_sc"
			VALUE
			0x70B8A
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_wpmp_oc
			"Cxx_mfnrsta_wpmp_oc"
			VALUE
			0x70B8B
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_wpmp_scg
			"Cxx_mfnrsta_wpmp_scg"
			VALUE
			0x70B8C
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mfnrsta_wpmp_vb_sc
			"Cxx_mfnrsta_wpmp_vb_sc"
			VALUE
			0x70B8D
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_ad_fac_thd
			"Cxx_min_ad_fac_thd"
			VALUE
			0x75903
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_ad_ofs_thd
			"Cxx_min_ad_ofs_thd"
			VALUE
			0x75904
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_agb_tq_sp
			"Cxx_min_agb_tq_sp"
			VALUE
			0x71EE1
			DATA_RECORD_UBYTE
			510
			F_2_m100_36
			-100
			410
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_alt_pwm
			"Cxx_min_alt_pwm"
			VALUE
			0x70DFB
			DATA_RECORD_UBYTE
			99.9999993
			F_0v39215686_p0_209
			0
			99.9999993
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_amp
			"Cxx_min_amp"
			VALUE
			0x7B0B2
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_ar_grd_thr_adj
			"Cxx_min_ar_grd_thr_adj"
			VALUE
			0x70D82
			DATA_RECORD_UWORD
			3906.187461
			F_0v0596046_p0_76
			0
			3906.187461
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_b0_ini
			"Cxx_min_b0_ini"
			VALUE
			0x731F7
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_b1_ini
			"Cxx_min_b1_ini"
			VALUE
			0x731F8
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_b2_ini
			"Cxx_min_b2_ini"
			VALUE
			0x731F9
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_b3_ini
			"Cxx_min_b3_ini"
			VALUE
			0x731FA
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_b4_ini
			"Cxx_min_b4_ini"
			VALUE
			0x731FB
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_cl_ti_fac
			"Cxx_min_cl_ti_fac"
			VALUE
			0x75905
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_cld_fac_thd
			"Cxx_min_cld_fac_thd"
			VALUE
			0x75906
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_cld_ofs_thd
			"Cxx_min_cld_ofs_thd"
			VALUE
			0x75907
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_cp_ti
			"Cxx_min_cp_ti"
			VALUE
			0x76F74
			DATA_RECORD_UWORD
			209712
			F_3v2_p0_152
			0
			209712
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_diag_fsys_dly
			"Cxx_min_diag_fsys_dly"
			VALUE
			0x7834A
			DATA_RECORD_UWORD
			33553920
			F_512_p0_104
			0
			33553920
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_diag_fsys_eol_dly
			"Cxx_min_diag_fsys_eol_dly"
			VALUE
			0x7834C
			DATA_RECORD_UWORD
			33553920
			F_512_p0_104
			0
			33553920
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_diag_mis_dly
			"Cxx_min_diag_mis_dly"
			VALUE
			0x7834E
			DATA_RECORD_UWORD
			33553920
			F_512_p0_104
			0
			33553920
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_diag_mis_eol_dly
			"Cxx_min_diag_mis_eol_dly"
			VALUE
			0x78350
			DATA_RECORD_UWORD
			33553920
			F_512_p0_104
			0
			33553920
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_diag_ti_ofs2
			"Cxx_min_diag_ti_ofs2"
			VALUE
			0x7595E
			DATA_RECORD_SWORD
			65535
			Id_0x00
			-32768
			32767
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_dif_ti_b
			"Cxx_min_dif_ti_b"
			VALUE
			0x75908
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_dyn_gear_cge_ofs
			"Cxx_min_dyn_gear_cge_ofs"
			VALUE
			0x71D1E
			DATA_RECORD_SWORD
			8191.875
			F_0v125_p0_30
			-4096
			4095.875
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_dyn_iga_tq
			"Cxx_min_dyn_iga_tq"
			VALUE
			0x71D20
			DATA_RECORD_SWORD
			8191.875
			F_0v125_p0_30
			-4096
			4095.875
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_gas_dec
			"Cxx_min_gas_dec"
			VALUE
			0x7AC14
			DATA_RECORD_UWORD
			0.999998565
			F_0v000015259_p0_216
			0
			0.999998565
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_gas_dly
			"Cxx_min_gas_dly"
			VALUE
			0x71EE2
			DATA_RECORD_UBYTE
			130560
			F_512_p0_104
			0
			130560
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_gas_inc
			"Cxx_min_gas_inc"
			VALUE
			0x7AC16
			DATA_RECORD_UWORD
			0.999998565
			F_0v000015259_p0_216
			0
			0.999998565
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_gas_lvl_dly
			"Cxx_min_gas_lvl_dly"
			VALUE
			0x71EE3
			DATA_RECORD_UBYTE
			130560
			F_512_p0_104
			0
			130560
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_h_alt_pwm_per
			"Cxx_min_h_alt_pwm_per"
			VALUE
			0x70E12
			DATA_RECORD_UWORD
			209.712
			F_0v0032_p0_8
			0
			209.712
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_iga_dsb_t
			"Cxx_min_iga_dsb_t"
			VALUE
			0x747F4
			DATA_RECORD_UBYTE
			32640
			F_128_p0_125
			0
			32640
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_imd_ti_ad_fac
			"Cxx_min_imd_ti_ad_fac"
			VALUE
			0x75909
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_imd_ti_ad_ofs
			"Cxx_min_imd_ti_ad_ofs"
			VALUE
			0x7590A
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_is_i
			"Cxx_min_is_i"
			VALUE
			0x73C0C
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_is_i_2
			"Cxx_min_is_i_2"
			VALUE
			0x73C0E
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_is_i_ofs
			"Cxx_min_is_i_ofs"
			VALUE
			0x73C10
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_is_min_ad_pwm
			"Cxx_min_is_min_ad_pwm"
			VALUE
			0x73AE2
			DATA_RECORD_SWORD
			65535
			Id_0x00
			-32768
			32767
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_is_ti_ofs2
			"Cxx_min_is_ti_ofs2"
			VALUE
			0x75960
			DATA_RECORD_SWORD
			65535
			Id_0x00
			-32768
			32767
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_l_alt_pwm_per
			"Cxx_min_l_alt_pwm_per"
			VALUE
			0x70E10
			DATA_RECORD_UWORD
			209.712
			F_0v0032_p0_8
			0
			209.712
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_lpg_cl_n_thd
			"Cxx_min_lpg_cl_n_thd"
			VALUE
			0x737FD
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_lpg_cl_prs_thd
			"Cxx_min_lpg_cl_prs_thd"
			VALUE
			0x737FE
			DATA_RECORD_UBYTE
			943.5
			F_3v7_p103_37
			103
			1046.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_lpg_fl_n_thd
			"Cxx_min_lpg_fl_n_thd"
			VALUE
			0x737FF
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_lpg_fl_prs_thd
			"Cxx_min_lpg_fl_prs_thd"
			VALUE
			0x73800
			DATA_RECORD_UBYTE
			943.5
			F_3v7_p103_37
			103
			1046.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_lpg_lvl_dly
			"Cxx_min_lpg_lvl_dly"
			VALUE
			0x71EE4
			DATA_RECORD_UBYTE
			130560
			F_512_p0_104
			0
			130560
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_mes_prs_fail_sens
			"Cxx_min_mes_prs_fail_sens"
			VALUE
			0x78748
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_mv_ti_ad_fac
			"Cxx_min_mv_ti_ad_fac"
			VALUE
			0x7590B
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_mv_ti_ad_ofs
			"Cxx_min_mv_ti_ad_ofs"
			VALUE
			0x7590C
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_n_fil_ofs2
			"Cxx_min_n_fil_ofs2"
			VALUE
			0x7590D
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_n_test_acq
			"Cxx_min_n_test_acq"
			VALUE
			0x78739
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_otl_iga_mv_tqi
			"Cxx_min_otl_iga_mv_tqi"
			VALUE
			0x7AC18
			DATA_RECORD_UWORD
			524280
			F_8_p0_116
			0
			524280
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_otl_iga_tqi_lpg
			"Cxx_min_otl_iga_tqi_lpg"
			VALUE
			0x7AC1A
			DATA_RECORD_UWORD
			524280
			F_8_p0_116
			0
			524280
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_ovn_cor_fac
			"Cxx_min_ovn_cor_fac"
			VALUE
			0x7950F
			DATA_RECORD_UBYTE
			0.99609375
			F_0v00390625_p0_90
			0
			0.99609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_prs_fil_ofs2
			"Cxx_min_prs_fil_ofs2"
			VALUE
			0x76F76
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_pwl_dly
			"Cxx_min_pwl_dly"
			VALUE
			0x78D56
			DATA_RECORD_UBYTE
			4080
			F_16_p0_217
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_t_toth
			"Cxx_min_t_toth"
			VALUE
			0x784AA
			DATA_RECORD_UWORD
			209.712
			F_0v0032_p0_8
			0
			209.712
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_tco_ad_cor
			"Cxx_min_tco_ad_cor"
			VALUE
			0x73ABE
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_tco_fil_ofs2
			"Cxx_min_tco_fil_ofs2"
			VALUE
			0x7590E
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_thd_trt1_ini
			"Cxx_min_thd_trt1_ini"
			VALUE
			0x736DC
			DATA_RECORD_UWORD
			6399.902344
			F_0v09765625_p0_71
			0
			6399.902344
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_thd_trt2_ini
			"Cxx_min_thd_trt2_ini"
			VALUE
			0x736DE
			DATA_RECORD_UWORD
			6399.902344
			F_0v09765625_p0_71
			0
			6399.902344
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_thr_ar
			"Cxx_min_thr_ar"
			VALUE
			0x70D84
			DATA_RECORD_UWORD
			3906.187461
			F_0v0596046_p0_76
			0
			3906.187461
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_ti
			"Cxx_min_ti"
			VALUE
			0x76F78
			DATA_RECORD_UWORD
			209712
			F_3v2_p0_152
			0
			209712
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_ti_ofs2
			"Cxx_min_ti_ofs2"
			VALUE
			0x75962
			DATA_RECORD_SWORD
			65535
			Id_0x00
			-32768
			32767
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_tq_rat_ovn
			"Cxx_min_tq_rat_ovn"
			VALUE
			0x79510
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_tqe_fac
			"Cxx_min_tqe_fac"
			VALUE
			0x79511
			DATA_RECORD_UBYTE
			0.498015
			F_0v001953_p0v75_218
			0.75
			1.248015
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_tqe_fil_fac
			"Cxx_min_tqe_fil_fac"
			VALUE
			0x79512
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_min_tqe_tkof
			"Cxx_min_tqe_tkof"
			VALUE
			0x790E1
			DATA_RECORD_SBYTE
			127.5
			F_0v5_p0_28
			-64
			63.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mis_cata_win_mis_nr
			"Cxx_mis_cata_win_mis_nr"
			VALUE
			0x78352
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mis_cata_win_mis_nr_1
			"Cxx_mis_cata_win_mis_nr_1"
			VALUE
			0x78354
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mis_cata_win_tdc_nr
			"Cxx_mis_cata_win_tdc_nr"
			VALUE
			0x78356
			DATA_RECORD_UWORD
			65535
			F_1_p0_53
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mis_cyl_fail_rat
			"Cxx_mis_cyl_fail_rat"
			VALUE
			0x7771B
			DATA_RECORD_UBYTE
			0.99609375
			F_0v00390625_p0_90
			0
			0.99609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mis_diag_obd_dsb_t
			"Cxx_mis_diag_obd_dsb_t"
			VALUE
			0x7771C
			DATA_RECORD_UBYTE
			2040
			F_8_p0_56
			0
			2040
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mis_ena_n_max_thd
			"Cxx_mis_ena_n_max_thd"
			VALUE
			0x78358
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mis_ena_n_min_thd
			"Cxx_mis_ena_n_min_thd"
			VALUE
			0x7835A
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mis_ena_tco_min_thd
			"Cxx_mis_ena_tco_min_thd"
			VALUE
			0x7771D
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mis_fast_win_mis_nr
			"Cxx_mis_fast_win_mis_nr"
			VALUE
			0x7771E
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mis_fast_win_tdc_nr
			"Cxx_mis_fast_win_tdc_nr"
			VALUE
			0x7771F
			DATA_RECORD_UBYTE
			255
			F_1_p0_53
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mis_km_dly
			"Cxx_mis_km_dly"
			VALUE
			0x7835C
			DATA_RECORD_UWORD
			4772113.212
			F_72v81778_p0_219
			0
			4772113.212
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mis_lih_chk_dsb_conf
			"Cxx_mis_lih_chk_dsb_conf"
			VALUE
			0x77720
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mis_lih_mis_nr
			"Cxx_mis_lih_mis_nr"
			VALUE
			0x77721
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mis_lih_n_min
			"Cxx_mis_lih_n_min"
			VALUE
			0x7835E
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mis_lih_out_mis_nr
			"Cxx_mis_lih_out_mis_nr"
			VALUE
			0x77722
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mis_lih_re_phs_nr
			"Cxx_mis_lih_re_phs_nr"
			VALUE
			0x77723
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mis_lih_tdc_nr
			"Cxx_mis_lih_tdc_nr"
			VALUE
			0x77724
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mis_n_max_agb_clos_no
			"Cxx_mis_n_max_agb_clos_no"
			VALUE
			0x78360
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mis_n_max_thd_1_n
			"Cxx_mis_n_max_thd_1_n"
			VALUE
			0x78362
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mis_ofs_eal_agb_ena
			"Cxx_mis_ofs_eal_agb_ena"
			VALUE
			0x78364
			DATA_RECORD_UWORD
			199.9969605
			F_0v003051758_p0_220
			0
			199.9969605
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mis_polu_win_mis_nr
			"Cxx_mis_polu_win_mis_nr"
			VALUE
			0x78366
			DATA_RECORD_UWORD
			65535
			F_1_p0_53
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mis_polu_win_mis_nr_1
			"Cxx_mis_polu_win_mis_nr_1"
			VALUE
			0x78368
			DATA_RECORD_UWORD
			65535
			F_1_p0_53
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mis_polu_win_nr_fail
			"Cxx_mis_polu_win_nr_fail"
			VALUE
			0x77725
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mis_polu_win_tdc_nr
			"Cxx_mis_polu_win_tdc_nr"
			VALUE
			0x7836A
			DATA_RECORD_UWORD
			65535
			F_1_p0_53
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mis_rat_min_cyl_
			"Cxx_mis_rat_min_cyl_"
			VALUE
			0x77726
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mis_stab_tdc_nr
			"Cxx_mis_stab_tdc_nr"
			VALUE
			0x77727
			DATA_RECORD_UBYTE
			255
			F_1_p0_53
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mon_stop_tco_thd
			"Cxx_mon_stop_tco_thd"
			VALUE
			0x73738
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mux_ip_eng_c
			"Cxx_mux_ip_eng_c"
			VALUE
			0x71EE5
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mux_mfld_inv_fil_fac
			"Cxx_mux_mfld_inv_fil_fac"
			VALUE
			0x7AC1C
			DATA_RECORD_UWORD
			99.9985458
			F_0v00152588_p0_107
			0
			99.9985458
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mux_min_n
			"Cxx_mux_min_n"
			VALUE
			0x720BA
			DATA_RECORD_UWORD
			8191.875
			F_0v125_p0_30
			0
			8191.875
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mux_pdl_frm_thd1
			"Cxx_mux_pdl_frm_thd1"
			VALUE
			0x71EE6
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mux_pdl_frm_thd2
			"Cxx_mux_pdl_frm_thd2"
			VALUE
			0x71EE7
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mux_pdl_h_thd
			"Cxx_mux_pdl_h_thd"
			VALUE
			0x71EE8
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mux_pdl_psn_fac
			"Cxx_mux_pdl_psn_fac"
			VALUE
			0x71EE9
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mux_pdl_psn_ofs
			"Cxx_mux_pdl_psn_ofs"
			VALUE
			0x71EEA
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mux_pwst_prs_dly
			"Cxx_mux_pwst_prs_dly"
			VALUE
			0x73626
			DATA_RECORD_UBYTE
			4080
			F_16_p0_10
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mux_test_mil_dly
			"Cxx_mux_test_mil_dly"
			VALUE
			0x71EEB
			DATA_RECORD_UBYTE
			32640
			F_128_p0_125
			0
			32640
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mux_thr_n_mil_test
			"Cxx_mux_thr_n_mil_test"
			VALUE
			0x720BC
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mv_ad_dly
			"Cxx_mv_ad_dly"
			VALUE
			0x7590F
			DATA_RECORD_UBYTE
			32640
			F_128_p0_125
			0
			32640
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mv_ad_lsm_ctr_ini
			"Cxx_mv_ad_lsm_ctr_ini"
			VALUE
			0x7322E
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mv_ti_ad_fac_ini
			"Cxx_mv_ti_ad_fac_ini"
			VALUE
			0x731FC
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mv_ti_ad_ofs_ini
			"Cxx_mv_ti_ad_ofs_ini"
			VALUE
			0x731FD
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mv_vb_fil_fac
			"Cxx_mv_vb_fil_fac"
			VALUE
			0x78BA6
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mvac_dp_chr_h_thd
			"Cxx_mvac_dp_chr_h_thd"
			VALUE
			0x73715
			DATA_RECORD_UBYTE
			943.5
			F_3v7_p0_21
			0
			943.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mvac_dp_chr_l_thd
			"Cxx_mvac_dp_chr_l_thd"
			VALUE
			0x73716
			DATA_RECORD_UBYTE
			943.5
			F_3v7_p0_21
			0
			943.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mvac_dp_dec_brk_dft
			"Cxx_mvac_dp_dec_brk_dft"
			VALUE
			0x73717
			DATA_RECORD_UBYTE
			943.5
			F_3v7_p0_21
			0
			943.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mvac_dp_dec_vs_dft
			"Cxx_mvac_dp_dec_vs_dft"
			VALUE
			0x73718
			DATA_RECORD_UBYTE
			943.5
			F_3v7_p0_21
			0
			943.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mvac_dp_diag_dly
			"Cxx_mvac_dp_diag_dly"
			VALUE
			0x73719
			DATA_RECORD_UBYTE
			8160
			F_32_p0_122
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mvac_dp_diag_sta_dly
			"Cxx_mvac_dp_diag_sta_dly"
			VALUE
			0x7371A
			DATA_RECORD_UBYTE
			8160
			F_32_p0_122
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mvac_dp_h_thd
			"Cxx_mvac_dp_h_thd"
			VALUE
			0x7371B
			DATA_RECORD_UBYTE
			943.5
			F_3v7_p0_21
			0
			943.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mvac_dp_inc_dly
			"Cxx_mvac_dp_inc_dly"
			VALUE
			0x7371C
			DATA_RECORD_UBYTE
			8160
			F_32_p0_122
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mvac_dp_l_thd
			"Cxx_mvac_dp_l_thd"
			VALUE
			0x7371D
			DATA_RECORD_UBYTE
			943.5
			F_3v7_p0_21
			0
			943.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mvac_n_h_thd
			"Cxx_mvac_n_h_thd"
			VALUE
			0x7371E
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mvac_n_l_thd
			"Cxx_mvac_n_l_thd"
			VALUE
			0x7371F
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mvac_prs_cnt_h_dp_thd
			"Cxx_mvac_prs_cnt_h_dp_thd"
			VALUE
			0x73720
			DATA_RECORD_UBYTE
			943.5
			F_3v7_p0_21
			0
			943.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mvac_prs_cnt_l_dp_thd
			"Cxx_mvac_prs_cnt_l_dp_thd"
			VALUE
			0x73721
			DATA_RECORD_UBYTE
			943.5
			F_3v7_p0_21
			0
			943.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mvac_prs_dif_thd
			"Cxx_mvac_prs_dif_thd"
			VALUE
			0x73722
			DATA_RECORD_UBYTE
			943.5
			F_3v7_p0_21
			0
			943.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mvac_prs_fil_fac
			"Cxx_mvac_prs_fil_fac"
			VALUE
			0x73723
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mvac_pump_aftr_run_t
			"Cxx_mvac_pump_aftr_run_t"
			VALUE
			0x73724
			DATA_RECORD_UBYTE
			32640
			F_128_p0_125
			0
			32640
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mvac_pump_dft_aftr_run_t
			"Cxx_mvac_pump_dft_aftr_run_t"
			VALUE
			0x73725
			DATA_RECORD_UBYTE
			32640
			F_128_p0_125
			0
			32640
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mvac_pump_dft_max_run_t
			"Cxx_mvac_pump_dft_max_run_t"
			VALUE
			0x73726
			DATA_RECORD_UBYTE
			32640
			F_128_p0_125
			0
			32640
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_mvac_pump_max_run_t
			"Cxx_mvac_pump_max_run_t"
			VALUE
			0x73727
			DATA_RECORD_UBYTE
			32640
			F_128_p0_125
			0
			32640
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_n_ac_dsb_hys
			"Cxx_n_ac_dsb_hys"
			VALUE
			0x72158
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_n_ac_dsb_thd
			"Cxx_n_ac_dsb_thd"
			VALUE
			0x72159
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_n_alt_rat
			"Cxx_n_alt_rat"
			VALUE
			0x71EEC
			DATA_RECORD_UBYTE
			100.393755
			F_0v393701_p0_156
			0
			100.393755
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_n_cmp_n_is_sp_in_sta
			"Cxx_n_cmp_n_is_sp_in_sta"
			VALUE
			0x71CE0
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_n_drv_puls_thd
			"Cxx_n_drv_puls_thd"
			VALUE
			0x790E2
			DATA_RECORD_SBYTE
			4845
			F_19_p0_221
			-2432
			2413
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_n_h_alt_crt
			"Cxx_n_h_alt_crt"
			VALUE
			0x70DF5
			DATA_RECORD_UBYTE
			12.036
			F_0v0472_p0_154
			0
			12.036
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_n_iga_tco_thd
			"Cxx_n_iga_tco_thd"
			VALUE
			0x71CE1
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_n_l_alt_crt
			"Cxx_n_l_alt_crt"
			VALUE
			0x70DF4
			DATA_RECORD_UBYTE
			12.036
			F_0v0472_p0_154
			0
			12.036
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_n_lim_is_dyn_iga_dly
			"Cxx_n_lim_is_dyn_iga_dly"
			VALUE
			0x71CE2
			DATA_RECORD_UBYTE
			4080
			F_16_p0_10
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_n_lim_l_tco_thd
			"Cxx_n_lim_l_tco_thd"
			VALUE
			0x736FE
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_n_lim_sta_iga_dec
			"Cxx_n_lim_sta_iga_dec"
			VALUE
			0x71CE3
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_n_lim_sta_iga_inc
			"Cxx_n_lim_sta_iga_inc"
			VALUE
			0x71CE4
			DATA_RECORD_UBYTE
			255
			F_1_p0_53
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_n_lim_up_tco_thd
			"Cxx_n_lim_up_tco_thd"
			VALUE
			0x736FF
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_n_max_clc_dsb
			"Cxx_n_max_clc_dsb"
			VALUE
			0x784C7
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_n_max_cru_sl_dsb
			"Cxx_n_max_cru_sl_dsb"
			VALUE
			0x78FD0
			DATA_RECORD_UWORD
			2097120
			F_32_p0_46
			0
			2097120
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_n_max_thr_adj
			"Cxx_n_max_thr_adj"
			VALUE
			0x70D86
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_n_min_cru_sl_dsb
			"Cxx_n_min_cru_sl_dsb"
			VALUE
			0x78FD2
			DATA_RECORD_UWORD
			2097120
			F_32_p0_46
			0
			2097120
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_n_min_mmv
			"Cxx_n_min_mmv"
			VALUE
			0x78BA7
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_n_min_out_cart_iga
			"Cxx_n_min_out_cart_iga"
			VALUE
			0x71CE5
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_n_min_thr_adj
			"Cxx_n_min_thr_adj"
			VALUE
			0x70D88
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_n_mux_emt_max
			"Cxx_n_mux_emt_max"
			VALUE
			0x71EED
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_n_ofs_cart_iga_run_vh
			"Cxx_n_ofs_cart_iga_run_vh"
			VALUE
			0x71CE6
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_n_ofs_cart_iga_stop
			"Cxx_n_ofs_cart_iga_stop"
			VALUE
			0x71CE7
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_n_ofs_cart_iga_stop2
			"Cxx_n_ofs_cart_iga_stop2"
			VALUE
			0x71CE8
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_n_ofs_in_sta_iga
			"Cxx_n_ofs_in_sta_iga"
			VALUE
			0x71CE9
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_n_ofs_is_iga_run_vh
			"Cxx_n_ofs_is_iga_run_vh"
			VALUE
			0x71CEA
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_n_ofs_is_iga_run_vh1
			"Cxx_n_ofs_is_iga_run_vh1"
			VALUE
			0x71CEB
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_n_ofs_is_iga_stop_vh
			"Cxx_n_ofs_is_iga_stop_vh"
			VALUE
			0x71CEC
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_n_ofs_is_iga_stop_vh1
			"Cxx_n_ofs_is_iga_stop_vh1"
			VALUE
			0x71CED
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_n_ofs_is_iga_stop_vh2
			"Cxx_n_ofs_is_iga_stop_vh2"
			VALUE
			0x71CEE
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_n_ofs_is_iga_stop_vh3
			"Cxx_n_ofs_is_iga_stop_vh3"
			VALUE
			0x71CEF
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_n_ofs_out_sta_iga
			"Cxx_n_ofs_out_sta_iga"
			VALUE
			0x71CF0
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_n_ofs_swi_iga_stop
			"Cxx_n_ofs_swi_iga_stop"
			VALUE
			0x75910
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_n_ofs_swi_iga_stop1
			"Cxx_n_ofs_swi_iga_stop1"
			VALUE
			0x75911
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_n_ovs_cor_fac
			"Cxx_n_ovs_cor_fac"
			VALUE
			0x79513
			DATA_RECORD_UBYTE
			0.099609375
			F_0v000390625_p0_222
			0
			0.099609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_n_puls_fil_fac_ovn
			"Cxx_n_puls_fil_fac_ovn"
			VALUE
			0x79514
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_n_tkof_fil_fac
			"Cxx_n_tkof_fil_fac"
			VALUE
			0x73676
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_n_tkof_inrt_0
			"Cxx_n_tkof_inrt_0"
			VALUE
			0x73677
			DATA_RECORD_UBYTE
			2.55
			F_0v01_p0_223
			0
			2.55
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_n_tkof_inrt_1
			"Cxx_n_tkof_inrt_1"
			VALUE
			0x73678
			DATA_RECORD_UBYTE
			2.55
			F_0v01_p0_223
			0
			2.55
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_neut_ad_is_fil
			"Cxx_neut_ad_is_fil"
			VALUE
			0x73ABF
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_neut_sp_is_cor
			"Cxx_neut_sp_is_cor"
			VALUE
			0x73AC0
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_no_chr_brk_dly
			"Cxx_no_chr_brk_dly"
			VALUE
			0x78F20
			DATA_RECORD_UBYTE
			25.5
			F_0v1_p0_173
			0
			25.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_no_lim_zon_ref_dif_1
			"Cxx_no_lim_zon_ref_dif_1"
			VALUE
			0x7364A
			DATA_RECORD_UWORD
			2867.8116
			F_0v04376_p0_180
			0
			2867.8116
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_no_lim_zon_ref_dif_2
			"Cxx_no_lim_zon_ref_dif_2"
			VALUE
			0x7364C
			DATA_RECORD_UWORD
			2867.8116
			F_0v04376_p0_180
			0
			2867.8116
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_no_lim_zon_ref_dif_3
			"Cxx_no_lim_zon_ref_dif_3"
			VALUE
			0x7364E
			DATA_RECORD_UWORD
			2867.8116
			F_0v04376_p0_180
			0
			2867.8116
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_no_min_gas_dly
			"Cxx_no_min_gas_dly"
			VALUE
			0x71EEE
			DATA_RECORD_UBYTE
			130560
			F_512_p0_104
			0
			130560
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_no_min_gas_lvl_dly
			"Cxx_no_min_gas_lvl_dly"
			VALUE
			0x71EEF
			DATA_RECORD_UBYTE
			130560
			F_512_p0_104
			0
			130560
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_no_min_lpg_lvl_dly
			"Cxx_no_min_lpg_lvl_dly"
			VALUE
			0x71EF0
			DATA_RECORD_UBYTE
			130560
			F_512_p0_104
			0
			130560
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_nr_cyl_dsb_n_thd
			"Cxx_nr_cyl_dsb_n_thd"
			VALUE
			0x71EF1
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_nr_tdc_dif_prs_fail
			"Cxx_nr_tdc_dif_prs_fail"
			VALUE
			0x7873A
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_nr_tdc_inj_cut
			"Cxx_nr_tdc_inj_cut"
			VALUE
			0x7B0B4
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_nr_vld_crk_fail1
			"Cxx_nr_vld_crk_fail1"
			VALUE
			0x7849B
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_obd_conf_diag_prmt
			"Cxx_obd_conf_diag_prmt"
			VALUE
			0x731FE
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_obd_conf_diag_schd
			"Cxx_obd_conf_diag_schd"
			VALUE
			0x731FF
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_obd_conf_lamb
			"Cxx_obd_conf_lamb"
			VALUE
			0x73200
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_obd_conf_mod_1_1
			"Cxx_obd_conf_mod_1_1"
			VALUE
			0x731D3
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_obd_conf_mod_1_2
			"Cxx_obd_conf_mod_1_2"
			VALUE
			0x731D4
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_obd_conf_mod_1_3
			"Cxx_obd_conf_mod_1_3"
			VALUE
			0x731D5
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_obd_conf_mod_1_4
			"Cxx_obd_conf_mod_1_4"
			VALUE
			0x731D6
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_obd_conf_mod_1_5
			"Cxx_obd_conf_mod_1_5"
			VALUE
			0x731D7
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_obd_conf_mod_1_6
			"Cxx_obd_conf_mod_1_6"
			VALUE
			0x731D8
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_obd_conf_mod_1_7
			"Cxx_obd_conf_mod_1_7"
			VALUE
			0x731D9
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_obd_conf_mod_1_8
			"Cxx_obd_conf_mod_1_8"
			VALUE
			0x731DA
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_obd_conf_mod_2_1
			"Cxx_obd_conf_mod_2_1"
			VALUE
			0x731DB
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_obd_conf_mod_2_2
			"Cxx_obd_conf_mod_2_2"
			VALUE
			0x731DC
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_obd_conf_mod_2_3
			"Cxx_obd_conf_mod_2_3"
			VALUE
			0x731DD
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_obd_conf_mod_2_4
			"Cxx_obd_conf_mod_2_4"
			VALUE
			0x731DE
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_obd_conf_mod_6_1
			"Cxx_obd_conf_mod_6_1"
			VALUE
			0x731DF
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_obd_conf_mod_6_2
			"Cxx_obd_conf_mod_6_2"
			VALUE
			0x731E0
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_obd_conf_mod_6_3
			"Cxx_obd_conf_mod_6_3"
			VALUE
			0x731E1
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_obd_conf_mod_6_4
			"Cxx_obd_conf_mod_6_4"
			VALUE
			0x731E2
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_obd_conf_mod_9_1
			"Cxx_obd_conf_mod_9_1"
			VALUE
			0x731E3
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_obd_conf_mod_9_2
			"Cxx_obd_conf_mod_9_2"
			VALUE
			0x731E4
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_obd_conf_mod_9_3
			"Cxx_obd_conf_mod_9_3"
			VALUE
			0x731E5
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_obd_conf_mod_9_4
			"Cxx_obd_conf_mod_9_4"
			VALUE
			0x731E6
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_obd_conf_obd
			"Cxx_obd_conf_obd"
			VALUE
			0x73201
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_obd_fail_off_vld_dly
			"Cxx_obd_fail_off_vld_dly"
			VALUE
			0x736CD
			DATA_RECORD_UBYTE
			1020
			F_4_p0_163
			0
			1020
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_obd_max_alti
			"Cxx_obd_max_alti"
			VALUE
			0x77728
			DATA_RECORD_UBYTE
			943.5
			F_3v7_p0_21
			0
			943.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_obd_max_tco
			"Cxx_obd_max_tco"
			VALUE
			0x77729
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_obd_max_tia
			"Cxx_obd_max_tia"
			VALUE
			0x7772A
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_obd_min_tco
			"Cxx_obd_min_tco"
			VALUE
			0x7772B
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_obd_min_tia
			"Cxx_obd_min_tia"
			VALUE
			0x7772C
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_off_crk_dly
			"Cxx_off_crk_dly"
			VALUE
			0x7849C
			DATA_RECORD_UBYTE
			2040
			F_8_p0_56
			0
			2040
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_off_syn_max_toth_nr
			"Cxx_off_syn_max_toth_nr"
			VALUE
			0x70CD1
			DATA_RECORD_UBYTE
			255
			F_1_p0_165
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ok_ini_dly
			"Cxx_ok_ini_dly"
			VALUE
			0x73202
			DATA_RECORD_UBYTE
			32640
			F_128_p0_125
			0
			32640
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ol_ti_fac_dec
			"Cxx_ol_ti_fac_dec"
			VALUE
			0x76F7A
			DATA_RECORD_UWORD
			170.664281
			F_0v00260417_p0_224
			0
			170.664281
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ol_ti_fac_inc
			"Cxx_ol_ti_fac_inc"
			VALUE
			0x76F7C
			DATA_RECORD_UWORD
			170.664281
			F_0v00260417_p0_224
			0
			170.664281
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_oten_prmt_trg_dly
			"Cxx_oten_prmt_trg_dly"
			VALUE
			0x7836C
			DATA_RECORD_UWORD
			65535
			F_1_p0_53
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_oten_schd_trg_dly
			"Cxx_oten_schd_trg_dly"
			VALUE
			0x7836E
			DATA_RECORD_UWORD
			524280
			F_8_p0_56
			0
			524280
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_out_inj_sta_n_thd
			"Cxx_out_inj_sta_n_thd"
			VALUE
			0x75912
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ovn_cor_dec
			"Cxx_ovn_cor_dec"
			VALUE
			0x79515
			DATA_RECORD_UBYTE
			0.0255
			F_m0v0001_p0_225
			-0.0255
			0
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ovn_cor_inc
			"Cxx_ovn_cor_inc"
			VALUE
			0x79516
			DATA_RECORD_UBYTE
			0.0255
			F_0v0001_p0_226
			0
			0.0255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ovt_dly
			"Cxx_ovt_dly"
			VALUE
			0x79517
			DATA_RECORD_UBYTE
			127.5
			F_0v5_p0_227
			0
			127.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ovt_gear_thd
			"Cxx_ovt_gear_thd"
			VALUE
			0x79518
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ovt_inc_lim
			"Cxx_ovt_inc_lim"
			VALUE
			0x7AC1E
			DATA_RECORD_UWORD
			511.9921875
			F_0v0078125_p0_15
			0
			511.9921875
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pb7_conf
			"Cxx_pb7_conf"
			VALUE
			0x7B0CD
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pdl_fast_ad_trs_nr
			"Cxx_pdl_fast_ad_trs_nr"
			VALUE
			0x784C8
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pdl_frm_dec
			"Cxx_pdl_frm_dec"
			VALUE
			0x78F21
			DATA_RECORD_UBYTE
			99.603
			F_0v3906_p0_228
			0
			99.603
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pdl_frm_inc
			"Cxx_pdl_frm_inc"
			VALUE
			0x78F22
			DATA_RECORD_UBYTE
			99.603
			F_0v3906_p0_228
			0
			99.603
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pdl_max_psn_thd
			"Cxx_pdl_max_psn_thd"
			VALUE
			0x784C9
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pdl_sens_shift_diag_dly
			"Cxx_pdl_sens_shift_diag_dly"
			VALUE
			0x73254
			DATA_RECORD_UBYTE
			4080
			F_16_p0_10
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pdl_slow_ad_trs_nr
			"Cxx_pdl_slow_ad_trs_nr"
			VALUE
			0x784CA
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pdl_ufld_psn_thd
			"Cxx_pdl_ufld_psn_thd"
			VALUE
			0x784CB
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_perf_ac_dsb_gear_thd
			"Cxx_perf_ac_dsb_gear_thd"
			VALUE
			0x7215A
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_perf_ac_dsb_max_dly
			"Cxx_perf_ac_dsb_max_dly"
			VALUE
			0x7215B
			DATA_RECORD_UBYTE
			32640
			F_128_p0_125
			0
			32640
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_perf_ac_dsb_n_hys
			"Cxx_perf_ac_dsb_n_hys"
			VALUE
			0x7215C
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_perf_ac_dsb_n_thd
			"Cxx_perf_ac_dsb_n_thd"
			VALUE
			0x7215D
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_perf_ac_dsb_pow_thd
			"Cxx_perf_ac_dsb_pow_thd"
			VALUE
			0x7215E
			DATA_RECORD_UBYTE
			5100
			F_20_p0_63
			0
			5100
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_perf_ac_dsb_vs_hys
			"Cxx_perf_ac_dsb_vs_hys"
			VALUE
			0x7215F
			DATA_RECORD_UBYTE
			255
			F_1_p0_58
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_perf_ac_dsb_vs_thd
			"Cxx_perf_ac_dsb_vs_thd"
			VALUE
			0x72160
			DATA_RECORD_UBYTE
			255
			F_1_p0_58
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_perf_inj_tco_thd
			"Cxx_perf_inj_tco_thd"
			VALUE
			0x75913
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_ac_prs
			"Cxx_pfdec_ac_prs"
			VALUE
			0x709EC
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_ac_rcpt
			"Cxx_pfdec_ac_rcpt"
			VALUE
			0x709ED
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_acr_oc
			"Cxx_pfdec_acr_oc"
			VALUE
			0x709EE
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_acr_scg
			"Cxx_pfdec_acr_scg"
			VALUE
			0x709EF
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_acr_vb_sc
			"Cxx_pfdec_acr_vb_sc"
			VALUE
			0x709F0
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_actr_rly
			"Cxx_pfdec_actr_rly"
			VALUE
			0x709F1
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_actr_rly_cut
			"Cxx_pfdec_actr_rly_cut"
			VALUE
			0x709F2
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_agb_conv_stt
			"Cxx_pfdec_agb_conv_stt"
			VALUE
			0x709F3
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_agb_gear
			"Cxx_pfdec_agb_gear"
			VALUE
			0x709F4
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_agb_rcpt
			"Cxx_pfdec_agb_rcpt"
			VALUE
			0x709F5
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_agb_tq_nok
			"Cxx_pfdec_agb_tq_nok"
			VALUE
			0x709F6
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_air
			"Cxx_pfdec_air"
			VALUE
			0x709F7
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_alt_ecu
			"Cxx_pfdec_alt_ecu"
			VALUE
			0x709F8
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_alt_load_in
			"Cxx_pfdec_alt_load_in"
			VALUE
			0x709FA
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_alt_mux
			"Cxx_pfdec_alt_mux"
			VALUE
			0x709F9
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_bkup_mem
			"Cxx_pfdec_bkup_mem"
			VALUE
			0x709FB
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_checksum
			"Cxx_pfdec_checksum"
			VALUE
			0x709FC
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_clu
			"Cxx_pfdec_clu"
			VALUE
			0x709FD
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_cp_oc
			"Cxx_pfdec_cp_oc"
			VALUE
			0x709FE
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_cp_scg
			"Cxx_pfdec_cp_scg"
			VALUE
			0x709FF
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_cp_vb_sc
			"Cxx_pfdec_cp_vb_sc"
			VALUE
			0x70A00
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_crk
			"Cxx_pfdec_crk"
			VALUE
			0x70A01
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_crk_nr
			"Cxx_pfdec_crk_nr"
			VALUE
			0x70A02
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_cru_brk_cnt1
			"Cxx_pfdec_cru_brk_cnt1"
			VALUE
			0x70A03
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_cru_brk_cnt2
			"Cxx_pfdec_cru_brk_cnt2"
			VALUE
			0x70A04
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_cru_on_off_chr
			"Cxx_pfdec_cru_on_off_chr"
			VALUE
			0x70A05
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_cru_whl_cmd
			"Cxx_pfdec_cru_whl_cmd"
			VALUE
			0x70A06
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_el_wind_rcpt
			"Cxx_pfdec_el_wind_rcpt"
			VALUE
			0x70A07
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_eng_temp_oc
			"Cxx_pfdec_eng_temp_oc"
			VALUE
			0x70A08
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_eng_temp_scg
			"Cxx_pfdec_eng_temp_scg"
			VALUE
			0x70A09
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_eng_temp_vb_sc
			"Cxx_pfdec_eng_temp_vb_sc"
			VALUE
			0x70A0A
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_eng_whl
			"Cxx_pfdec_eng_whl"
			VALUE
			0x70A0B
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_fsys
			"Cxx_pfdec_fsys"
			VALUE
			0x70A0C
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_fsys_lpg
			"Cxx_pfdec_fsys_lpg"
			VALUE
			0x70A0D
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_gas_pump_oc
			"Cxx_pfdec_gas_pump_oc"
			VALUE
			0x70A0E
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_gas_pump_scg
			"Cxx_pfdec_gas_pump_scg"
			VALUE
			0x70A0F
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_gas_pump_vb_sc
			"Cxx_pfdec_gas_pump_vb_sc"
			VALUE
			0x70A10
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_igc
			"Cxx_pfdec_igc"
			VALUE
			0x71E3A
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_igc_1_oc
			"Cxx_pfdec_igc_1_oc"
			VALUE
			0x70A11
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_igc_1_vb_sc
			"Cxx_pfdec_igc_1_vb_sc"
			VALUE
			0x70A12
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_igc_2_oc
			"Cxx_pfdec_igc_2_oc"
			VALUE
			0x70A13
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_igc_2_vb_sc
			"Cxx_pfdec_igc_2_vb_sc"
			VALUE
			0x70A14
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_igc_3_oc
			"Cxx_pfdec_igc_3_oc"
			VALUE
			0x70A15
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_igc_3_vb_sc
			"Cxx_pfdec_igc_3_vb_sc"
			VALUE
			0x70A16
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_igc_4_oc
			"Cxx_pfdec_igc_4_oc"
			VALUE
			0x70A17
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_igc_4_vb_sc
			"Cxx_pfdec_igc_4_vb_sc"
			VALUE
			0x70A18
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_inj1_oc
			"Cxx_pfdec_inj1_oc"
			VALUE
			0x70A19
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_inj1_scg
			"Cxx_pfdec_inj1_scg"
			VALUE
			0x70A1A
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_inj1_vb_sc
			"Cxx_pfdec_inj1_vb_sc"
			VALUE
			0x70A1B
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_inj2_oc
			"Cxx_pfdec_inj2_oc"
			VALUE
			0x70A1C
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_inj2_scg
			"Cxx_pfdec_inj2_scg"
			VALUE
			0x70A1D
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_inj2_vb_sc
			"Cxx_pfdec_inj2_vb_sc"
			VALUE
			0x70A1E
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_inj3_oc
			"Cxx_pfdec_inj3_oc"
			VALUE
			0x70A1F
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_inj3_scg
			"Cxx_pfdec_inj3_scg"
			VALUE
			0x70A20
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_inj3_vb_sc
			"Cxx_pfdec_inj3_vb_sc"
			VALUE
			0x70A21
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_inj4_oc
			"Cxx_pfdec_inj4_oc"
			VALUE
			0x70A22
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_inj4_scg
			"Cxx_pfdec_inj4_scg"
			VALUE
			0x70A23
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_inj4_vb_sc
			"Cxx_pfdec_inj4_vb_sc"
			VALUE
			0x70A24
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_inj_ecu
			"Cxx_pfdec_inj_ecu"
			VALUE
			0x70A25
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_ip_inj_cnt
			"Cxx_pfdec_ip_inj_cnt"
			VALUE
			0x70A26
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_knk
			"Cxx_pfdec_knk"
			VALUE
			0x70A27
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_lbdw_hot_oc
			"Cxx_pfdec_lbdw_hot_oc"
			VALUE
			0x70A2B
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_lbdw_hot_scg
			"Cxx_pfdec_lbdw_hot_scg"
			VALUE
			0x70A2C
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_lbdw_hot_vb_sc
			"Cxx_pfdec_lbdw_hot_vb_sc"
			VALUE
			0x70A2D
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_lbdw_oc
			"Cxx_pfdec_lbdw_oc"
			VALUE
			0x70A28
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_lbdw_pump_crt
			"Cxx_pfdec_lbdw_pump_crt"
			VALUE
			0x70A2E
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_lbdw_scg
			"Cxx_pfdec_lbdw_scg"
			VALUE
			0x70A29
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_lbdw_vb_sc
			"Cxx_pfdec_lbdw_vb_sc"
			VALUE
			0x70A2A
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_lbup_hot_oc
			"Cxx_pfdec_lbup_hot_oc"
			VALUE
			0x70A32
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_lbup_hot_scg
			"Cxx_pfdec_lbup_hot_scg"
			VALUE
			0x70A33
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_lbup_hot_vb_sc
			"Cxx_pfdec_lbup_hot_vb_sc"
			VALUE
			0x70A34
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_lbup_oc
			"Cxx_pfdec_lbup_oc"
			VALUE
			0x70A2F
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_lbup_pump_crt
			"Cxx_pfdec_lbup_pump_crt"
			VALUE
			0x70A35
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_lbup_scg
			"Cxx_pfdec_lbup_scg"
			VALUE
			0x70A30
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_lbup_vb_sc
			"Cxx_pfdec_lbup_vb_sc"
			VALUE
			0x70A31
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_lpg_rcpt
			"Cxx_pfdec_lpg_rcpt"
			VALUE
			0x70A36
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_map
			"Cxx_pfdec_map"
			VALUE
			0x70A37
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_map_chr
			"Cxx_pfdec_map_chr"
			VALUE
			0x70A38
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_mastervac_cc
			"Cxx_pfdec_mastervac_cc"
			VALUE
			0x70A39
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_mastervac_oc
			"Cxx_pfdec_mastervac_oc"
			VALUE
			0x70A3A
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_mcut_sens1
			"Cxx_pfdec_mcut_sens1"
			VALUE
			0x70A3B
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_mdf1_oc
			"Cxx_pfdec_mdf1_oc"
			VALUE
			0x70A3C
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_mdf1_scg
			"Cxx_pfdec_mdf1_scg"
			VALUE
			0x70A3D
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_mdf1_vb_sc
			"Cxx_pfdec_mdf1_vb_sc"
			VALUE
			0x70A3E
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_mdf2_oc
			"Cxx_pfdec_mdf2_oc"
			VALUE
			0x70A3F
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_mdf2_scg
			"Cxx_pfdec_mdf2_scg"
			VALUE
			0x70A40
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_mdf2_vb_sc
			"Cxx_pfdec_mdf2_vb_sc"
			VALUE
			0x70A41
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_min_gas_lvl
			"Cxx_pfdec_min_gas_lvl"
			VALUE
			0x70A42
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_min_lpg_lvl
			"Cxx_pfdec_min_lpg_lvl"
			VALUE
			0x70A43
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_mis_cata
			"Cxx_pfdec_mis_cata"
			VALUE
			0x70A44
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_mis_cata_1
			"Cxx_pfdec_mis_cata_1"
			VALUE
			0x70A45
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_mis_cata_1_lpg
			"Cxx_pfdec_mis_cata_1_lpg"
			VALUE
			0x70A46
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_mis_cata_2
			"Cxx_pfdec_mis_cata_2"
			VALUE
			0x70A47
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_mis_cata_2_lpg
			"Cxx_pfdec_mis_cata_2_lpg"
			VALUE
			0x70A48
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_mis_cata_3
			"Cxx_pfdec_mis_cata_3"
			VALUE
			0x70A49
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_mis_cata_3_lpg
			"Cxx_pfdec_mis_cata_3_lpg"
			VALUE
			0x70A4A
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_mis_cata_4
			"Cxx_pfdec_mis_cata_4"
			VALUE
			0x70A4B
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_mis_cata_4_lpg
			"Cxx_pfdec_mis_cata_4_lpg"
			VALUE
			0x70A4C
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_mis_cata_gas
			"Cxx_pfdec_mis_cata_gas"
			VALUE
			0x70A4D
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_mis_cata_lpg
			"Cxx_pfdec_mis_cata_lpg"
			VALUE
			0x70A4E
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_mis_fast
			"Cxx_pfdec_mis_fast"
			VALUE
			0x70A4F
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_mis_lih
			"Cxx_pfdec_mis_lih"
			VALUE
			0x70A50
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_mis_polu
			"Cxx_pfdec_mis_polu"
			VALUE
			0x70A51
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_mis_polu_1
			"Cxx_pfdec_mis_polu_1"
			VALUE
			0x70A52
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_mis_polu_1_lpg
			"Cxx_pfdec_mis_polu_1_lpg"
			VALUE
			0x70A53
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_mis_polu_2
			"Cxx_pfdec_mis_polu_2"
			VALUE
			0x70A54
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_mis_polu_2_lpg
			"Cxx_pfdec_mis_polu_2_lpg"
			VALUE
			0x70A55
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_mis_polu_3
			"Cxx_pfdec_mis_polu_3"
			VALUE
			0x70A56
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_mis_polu_3_lpg
			"Cxx_pfdec_mis_polu_3_lpg"
			VALUE
			0x70A57
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_mis_polu_4
			"Cxx_pfdec_mis_polu_4"
			VALUE
			0x70A58
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_mis_polu_4_lpg
			"Cxx_pfdec_mis_polu_4_lpg"
			VALUE
			0x70A59
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_mis_polu_gas
			"Cxx_pfdec_mis_polu_gas"
			VALUE
			0x70A5A
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_mis_polu_lpg
			"Cxx_pfdec_mis_polu_lpg"
			VALUE
			0x70A5B
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_mvac_pump_oc
			"Cxx_pfdec_mvac_pump_oc"
			VALUE
			0x70A5C
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_mvac_pump_scg
			"Cxx_pfdec_mvac_pump_scg"
			VALUE
			0x70A5D
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_mvac_pump_vb_sc
			"Cxx_pfdec_mvac_pump_vb_sc"
			VALUE
			0x70A5E
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_mvac_sys
			"Cxx_pfdec_mvac_sys"
			VALUE
			0x70A5F
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_obd_cata
			"Cxx_pfdec_obd_cata"
			VALUE
			0x70A60
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_obd_lamb
			"Cxx_pfdec_obd_lamb"
			VALUE
			0x70A61
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_obd_sa
			"Cxx_pfdec_obd_sa"
			VALUE
			0x70A62
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_oil_cc
			"Cxx_pfdec_oil_cc"
			VALUE
			0x70A63
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_oil_co
			"Cxx_pfdec_oil_co"
			VALUE
			0x70A64
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_pdl_sens1_oc
			"Cxx_pfdec_pdl_sens1_oc"
			VALUE
			0x70A65
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_pdl_sens1_vb_sc
			"Cxx_pfdec_pdl_sens1_vb_sc"
			VALUE
			0x70A66
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_pdl_sens2_oc
			"Cxx_pfdec_pdl_sens2_oc"
			VALUE
			0x70A67
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_pdl_sens2_vb_sc
			"Cxx_pfdec_pdl_sens2_vb_sc"
			VALUE
			0x70A68
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_pdl_sens_chr
			"Cxx_pfdec_pdl_sens_chr"
			VALUE
			0x70A69
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_pmh_cc
			"Cxx_pfdec_pmh_cc"
			VALUE
			0x70A6A
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_pmh_co
			"Cxx_pfdec_pmh_co"
			VALUE
			0x70A6B
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_pow_lbdw
			"Cxx_pfdec_pow_lbdw"
			VALUE
			0x70A6C
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_pow_lbup
			"Cxx_pfdec_pow_lbup"
			VALUE
			0x70A6D
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_ptc
			"Cxx_pfdec_ptc"
			VALUE
			0x70A6E
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_ptc_rov_oc
			"Cxx_pfdec_ptc_rov_oc"
			VALUE
			0x70A6F
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_ptc_rov_scg
			"Cxx_pfdec_ptc_rov_scg"
			VALUE
			0x70A70
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_ptc_rov_vb_sc
			"Cxx_pfdec_ptc_rov_vb_sc"
			VALUE
			0x70A71
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_pws_1
			"Cxx_pfdec_pws_1"
			VALUE
			0x70A72
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_pws_2
			"Cxx_pfdec_pws_2"
			VALUE
			0x70A73
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_pws_pdl2
			"Cxx_pfdec_pws_pdl2"
			VALUE
			0x70A74
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_pws_thr_pdl1
			"Cxx_pfdec_pws_thr_pdl1"
			VALUE
			0x70A75
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_rams_map_tq
			"Cxx_pfdec_rams_map_tq"
			VALUE
			0x70A76
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_rams_pdl
			"Cxx_pfdec_rams_pdl"
			VALUE
			0x70A79
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_rams_tq_ctl
			"Cxx_pfdec_rams_tq_ctl"
			VALUE
			0x70A77
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_rams_tq_req
			"Cxx_pfdec_rams_tq_req"
			VALUE
			0x70A78
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_reserve_3_oc
			"Cxx_pfdec_reserve_3_oc"
			VALUE
			0x70A7A
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_reserve_3_scg
			"Cxx_pfdec_reserve_3_scg"
			VALUE
			0x70A7B
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_reserve_3_vb_sc
			"Cxx_pfdec_reserve_3_vb_sc"
			VALUE
			0x70A7C
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_rmc_algopp
			"Cxx_pfdec_rmc_algopp"
			VALUE
			0x70A7D
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_rmc_clockpp
			"Cxx_pfdec_rmc_clockpp"
			VALUE
			0x70A7E
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_rmc_comspipp
			"Cxx_pfdec_rmc_comspipp"
			VALUE
			0x70A7F
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_rmc_inhwp
			"Cxx_pfdec_rmc_inhwp"
			VALUE
			0x70A80
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_rmc_monitpp
			"Cxx_pfdec_rmc_monitpp"
			VALUE
			0x70A81
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_rmc_papmpp
			"Cxx_pfdec_rmc_papmpp"
			VALUE
			0x70A82
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_rmc_pedmpp
			"Cxx_pfdec_rmc_pedmpp"
			VALUE
			0x70A83
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_rmc_timeoutpp
			"Cxx_pfdec_rmc_timeoutpp"
			VALUE
			0x70A84
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_sa_ev_oc
			"Cxx_pfdec_sa_ev_oc"
			VALUE
			0x70A88
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_sa_ev_scg
			"Cxx_pfdec_sa_ev_scg"
			VALUE
			0x70A89
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_sa_ev_vb_sc
			"Cxx_pfdec_sa_ev_vb_sc"
			VALUE
			0x70A8A
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_sa_oc
			"Cxx_pfdec_sa_oc"
			VALUE
			0x70A85
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_sa_scg
			"Cxx_pfdec_sa_scg"
			VALUE
			0x70A86
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_sa_vb_sc
			"Cxx_pfdec_sa_vb_sc"
			VALUE
			0x70A87
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_spg
			"Cxx_pfdec_spg"
			VALUE
			0x70A8B
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_spg_sys
			"Cxx_pfdec_spg_sys"
			VALUE
			0x70A8C
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_spi_cc
			"Cxx_pfdec_spi_cc"
			VALUE
			0x70A8D
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_svkl_chk_springs
			"Cxx_pfdec_svkl_chk_springs"
			VALUE
			0x70A8E
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_svkl_lih
			"Cxx_pfdec_svkl_lih"
			VALUE
			0x70A8F
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_svkl_oc
			"Cxx_pfdec_svkl_oc"
			VALUE
			0x70A90
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_svkl_psn
			"Cxx_pfdec_svkl_psn"
			VALUE
			0x70A91
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_svkl_sge
			"Cxx_pfdec_svkl_sge"
			VALUE
			0x70A92
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_svkl_trt_srch
			"Cxx_pfdec_svkl_trt_srch"
			VALUE
			0x70A93
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_swlk_mem
			"Cxx_pfdec_swlk_mem"
			VALUE
			0x70A94
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_tco_acq
			"Cxx_pfdec_tco_acq"
			VALUE
			0x70A95
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_tco_chr
			"Cxx_pfdec_tco_chr"
			VALUE
			0x70A96
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_thpl_oc
			"Cxx_pfdec_thpl_oc"
			VALUE
			0x70A97
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_thpl_scg
			"Cxx_pfdec_thpl_scg"
			VALUE
			0x70A98
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_thpl_vb_sc
			"Cxx_pfdec_thpl_vb_sc"
			VALUE
			0x70A99
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_thr_cmd_cpt
			"Cxx_pfdec_thr_cmd_cpt"
			VALUE
			0x70A9F
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_thr_cmd_vb_sc
			"Cxx_pfdec_thr_cmd_vb_sc"
			VALUE
			0x70AA0
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_thr_sens1_oc
			"Cxx_pfdec_thr_sens1_oc"
			VALUE
			0x70A9A
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_thr_sens1_vb_sc
			"Cxx_pfdec_thr_sens1_vb_sc"
			VALUE
			0x70A9B
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_thr_sens2_scg
			"Cxx_pfdec_thr_sens2_scg"
			VALUE
			0x70A9C
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_thr_sens2_vb_sc
			"Cxx_pfdec_thr_sens2_vb_sc"
			VALUE
			0x70A9D
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_thr_sens_chr
			"Cxx_pfdec_thr_sens_chr"
			VALUE
			0x70A9E
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_tia_high
			"Cxx_pfdec_tia_high"
			VALUE
			0x70AA1
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_tia_low
			"Cxx_pfdec_tia_low"
			VALUE
			0x70AA2
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_tjy_ctl
			"Cxx_pfdec_tjy_ctl"
			VALUE
			0x70AA3
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_tlz_ad_b
			"Cxx_pfdec_tlz_ad_b"
			VALUE
			0x70AA4
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_vb_high
			"Cxx_pfdec_vb_high"
			VALUE
			0x70AA5
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_vb_low
			"Cxx_pfdec_vb_low"
			VALUE
			0x70AA6
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_vs_eal
			"Cxx_pfdec_vs_eal"
			VALUE
			0x70AA7
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_vs_mux
			"Cxx_pfdec_vs_mux"
			VALUE
			0x70AA8
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_vs_parasite
			"Cxx_pfdec_vs_parasite"
			VALUE
			0x70AA9
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_vta_intake_pmh
			"Cxx_pfdec_vta_intake_pmh"
			VALUE
			0x70AAA
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_vta_intake_shift
			"Cxx_pfdec_vta_intake_shift"
			VALUE
			0x70AAB
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_vvt_int_ev_oc
			"Cxx_pfdec_vvt_int_ev_oc"
			VALUE
			0x70AAD
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_vvt_int_ev_scg
			"Cxx_pfdec_vvt_int_ev_scg"
			VALUE
			0x70AAE
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_vvt_int_ev_vb_sc
			"Cxx_pfdec_vvt_int_ev_vb_sc"
			VALUE
			0x70AAF
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_vvt_int_old_off
			"Cxx_pfdec_vvt_int_old_off"
			VALUE
			0x70AAC
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_vvt_intake_blk
			"Cxx_pfdec_vvt_intake_blk"
			VALUE
			0x70AB0
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_vvt_intake_bound
			"Cxx_pfdec_vvt_intake_bound"
			VALUE
			0x70AB1
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_vvt_intake_dyn
			"Cxx_pfdec_vvt_intake_dyn"
			VALUE
			0x70AB2
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_vvt_intake_int
			"Cxx_pfdec_vvt_intake_int"
			VALUE
			0x70AB3
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_vvtc_toth_3
			"Cxx_pfdec_vvtc_toth_3"
			VALUE
			0x70AB4
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_wat_temp_high
			"Cxx_pfdec_wat_temp_high"
			VALUE
			0x70AB5
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_wat_temp_low
			"Cxx_pfdec_wat_temp_low"
			VALUE
			0x70AB6
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_wgc_oc
			"Cxx_pfdec_wgc_oc"
			VALUE
			0x70AB7
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_wgc_scg
			"Cxx_pfdec_wgc_scg"
			VALUE
			0x70AB8
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_wgc_vb_sc
			"Cxx_pfdec_wgc_vb_sc"
			VALUE
			0x70AB9
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_wpmp_oc
			"Cxx_pfdec_wpmp_oc"
			VALUE
			0x70ABA
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_wpmp_scg
			"Cxx_pfdec_wpmp_scg"
			VALUE
			0x70ABB
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfdec_wpmp_vb_sc
			"Cxx_pfdec_wpmp_vb_sc"
			VALUE
			0x70ABC
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_ac_prs
			"Cxx_pfinc_ac_prs"
			VALUE
			0x7091B
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_ac_rcpt
			"Cxx_pfinc_ac_rcpt"
			VALUE
			0x7091C
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_acr_oc
			"Cxx_pfinc_acr_oc"
			VALUE
			0x7091D
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_acr_scg
			"Cxx_pfinc_acr_scg"
			VALUE
			0x7091E
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_acr_vb_sc
			"Cxx_pfinc_acr_vb_sc"
			VALUE
			0x7091F
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_actr_rly
			"Cxx_pfinc_actr_rly"
			VALUE
			0x70920
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_actr_rly_cut
			"Cxx_pfinc_actr_rly_cut"
			VALUE
			0x70921
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_agb_conv_stt
			"Cxx_pfinc_agb_conv_stt"
			VALUE
			0x70922
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_agb_gear
			"Cxx_pfinc_agb_gear"
			VALUE
			0x70923
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_agb_rcpt
			"Cxx_pfinc_agb_rcpt"
			VALUE
			0x70924
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_agb_tq_nok
			"Cxx_pfinc_agb_tq_nok"
			VALUE
			0x70925
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_air
			"Cxx_pfinc_air"
			VALUE
			0x70926
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_alt_ecu
			"Cxx_pfinc_alt_ecu"
			VALUE
			0x70927
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_alt_load_in
			"Cxx_pfinc_alt_load_in"
			VALUE
			0x70929
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_alt_mux
			"Cxx_pfinc_alt_mux"
			VALUE
			0x70928
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_bkup_mem
			"Cxx_pfinc_bkup_mem"
			VALUE
			0x7092A
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_checksum
			"Cxx_pfinc_checksum"
			VALUE
			0x7092B
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_clu
			"Cxx_pfinc_clu"
			VALUE
			0x7092C
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_cp_oc
			"Cxx_pfinc_cp_oc"
			VALUE
			0x7092D
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_cp_scg
			"Cxx_pfinc_cp_scg"
			VALUE
			0x7092E
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_cp_vb_sc
			"Cxx_pfinc_cp_vb_sc"
			VALUE
			0x7092F
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_crk
			"Cxx_pfinc_crk"
			VALUE
			0x70930
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_crk_nr
			"Cxx_pfinc_crk_nr"
			VALUE
			0x70931
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_cru_brk_cnt1
			"Cxx_pfinc_cru_brk_cnt1"
			VALUE
			0x70932
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_cru_brk_cnt2
			"Cxx_pfinc_cru_brk_cnt2"
			VALUE
			0x70933
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_cru_on_off_chr
			"Cxx_pfinc_cru_on_off_chr"
			VALUE
			0x70934
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_cru_whl_cmd
			"Cxx_pfinc_cru_whl_cmd"
			VALUE
			0x70935
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_el_wind_rcpt
			"Cxx_pfinc_el_wind_rcpt"
			VALUE
			0x70936
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_eng_temp_oc
			"Cxx_pfinc_eng_temp_oc"
			VALUE
			0x70937
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_eng_temp_scg
			"Cxx_pfinc_eng_temp_scg"
			VALUE
			0x70938
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_eng_temp_vb_sc
			"Cxx_pfinc_eng_temp_vb_sc"
			VALUE
			0x70939
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_eng_whl
			"Cxx_pfinc_eng_whl"
			VALUE
			0x7093A
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_fsys
			"Cxx_pfinc_fsys"
			VALUE
			0x7093B
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_fsys_lpg
			"Cxx_pfinc_fsys_lpg"
			VALUE
			0x7093C
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_gas_pump_oc
			"Cxx_pfinc_gas_pump_oc"
			VALUE
			0x7093D
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_gas_pump_scg
			"Cxx_pfinc_gas_pump_scg"
			VALUE
			0x7093E
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_gas_pump_vb_sc
			"Cxx_pfinc_gas_pump_vb_sc"
			VALUE
			0x7093F
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_igc
			"Cxx_pfinc_igc"
			VALUE
			0x71E3C
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_igc_1_oc
			"Cxx_pfinc_igc_1_oc"
			VALUE
			0x70940
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_igc_1_vb_sc
			"Cxx_pfinc_igc_1_vb_sc"
			VALUE
			0x70941
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_igc_2_oc
			"Cxx_pfinc_igc_2_oc"
			VALUE
			0x70942
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_igc_2_vb_sc
			"Cxx_pfinc_igc_2_vb_sc"
			VALUE
			0x70943
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_igc_3_oc
			"Cxx_pfinc_igc_3_oc"
			VALUE
			0x70944
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_igc_3_vb_sc
			"Cxx_pfinc_igc_3_vb_sc"
			VALUE
			0x70945
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_igc_4_oc
			"Cxx_pfinc_igc_4_oc"
			VALUE
			0x70946
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_igc_4_vb_sc
			"Cxx_pfinc_igc_4_vb_sc"
			VALUE
			0x70947
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_inj1_oc
			"Cxx_pfinc_inj1_oc"
			VALUE
			0x70948
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_inj1_scg
			"Cxx_pfinc_inj1_scg"
			VALUE
			0x70949
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_inj1_vb_sc
			"Cxx_pfinc_inj1_vb_sc"
			VALUE
			0x7094A
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_inj2_oc
			"Cxx_pfinc_inj2_oc"
			VALUE
			0x7094B
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_inj2_scg
			"Cxx_pfinc_inj2_scg"
			VALUE
			0x7094C
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_inj2_vb_sc
			"Cxx_pfinc_inj2_vb_sc"
			VALUE
			0x7094D
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_inj3_oc
			"Cxx_pfinc_inj3_oc"
			VALUE
			0x7094E
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_inj3_scg
			"Cxx_pfinc_inj3_scg"
			VALUE
			0x7094F
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_inj3_vb_sc
			"Cxx_pfinc_inj3_vb_sc"
			VALUE
			0x70950
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_inj4_oc
			"Cxx_pfinc_inj4_oc"
			VALUE
			0x70951
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_inj4_scg
			"Cxx_pfinc_inj4_scg"
			VALUE
			0x70952
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_inj4_vb_sc
			"Cxx_pfinc_inj4_vb_sc"
			VALUE
			0x70953
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_inj_ecu
			"Cxx_pfinc_inj_ecu"
			VALUE
			0x70954
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_ip_inj_cnt
			"Cxx_pfinc_ip_inj_cnt"
			VALUE
			0x70955
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_knk
			"Cxx_pfinc_knk"
			VALUE
			0x70956
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_lbdw_hot_oc
			"Cxx_pfinc_lbdw_hot_oc"
			VALUE
			0x7095A
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_lbdw_hot_scg
			"Cxx_pfinc_lbdw_hot_scg"
			VALUE
			0x7095B
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_lbdw_hot_vb_sc
			"Cxx_pfinc_lbdw_hot_vb_sc"
			VALUE
			0x7095C
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_lbdw_oc
			"Cxx_pfinc_lbdw_oc"
			VALUE
			0x70957
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_lbdw_pump_crt
			"Cxx_pfinc_lbdw_pump_crt"
			VALUE
			0x7095D
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_lbdw_scg
			"Cxx_pfinc_lbdw_scg"
			VALUE
			0x70958
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_lbdw_vb_sc
			"Cxx_pfinc_lbdw_vb_sc"
			VALUE
			0x70959
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_lbup_hot_oc
			"Cxx_pfinc_lbup_hot_oc"
			VALUE
			0x70961
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_lbup_hot_scg
			"Cxx_pfinc_lbup_hot_scg"
			VALUE
			0x70962
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_lbup_hot_vb_sc
			"Cxx_pfinc_lbup_hot_vb_sc"
			VALUE
			0x70963
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_lbup_oc
			"Cxx_pfinc_lbup_oc"
			VALUE
			0x7095E
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_lbup_pump_crt
			"Cxx_pfinc_lbup_pump_crt"
			VALUE
			0x70964
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_lbup_scg
			"Cxx_pfinc_lbup_scg"
			VALUE
			0x7095F
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_lbup_vb_sc
			"Cxx_pfinc_lbup_vb_sc"
			VALUE
			0x70960
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_lpg_rcpt
			"Cxx_pfinc_lpg_rcpt"
			VALUE
			0x70965
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_map
			"Cxx_pfinc_map"
			VALUE
			0x70966
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_map_chr
			"Cxx_pfinc_map_chr"
			VALUE
			0x70967
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_mastervac_cc
			"Cxx_pfinc_mastervac_cc"
			VALUE
			0x70968
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_mastervac_oc
			"Cxx_pfinc_mastervac_oc"
			VALUE
			0x70969
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_mcut_sens1
			"Cxx_pfinc_mcut_sens1"
			VALUE
			0x7096A
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_mdf1_oc
			"Cxx_pfinc_mdf1_oc"
			VALUE
			0x7096B
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_mdf1_scg
			"Cxx_pfinc_mdf1_scg"
			VALUE
			0x7096C
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_mdf1_vb_sc
			"Cxx_pfinc_mdf1_vb_sc"
			VALUE
			0x7096D
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_mdf2_oc
			"Cxx_pfinc_mdf2_oc"
			VALUE
			0x7096E
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_mdf2_scg
			"Cxx_pfinc_mdf2_scg"
			VALUE
			0x7096F
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_mdf2_vb_sc
			"Cxx_pfinc_mdf2_vb_sc"
			VALUE
			0x70970
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_min_gas_lvl
			"Cxx_pfinc_min_gas_lvl"
			VALUE
			0x70971
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_min_lpg_lvl
			"Cxx_pfinc_min_lpg_lvl"
			VALUE
			0x70972
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_mis_cata
			"Cxx_pfinc_mis_cata"
			VALUE
			0x70973
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_mis_cata_1
			"Cxx_pfinc_mis_cata_1"
			VALUE
			0x70974
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_mis_cata_1_lpg
			"Cxx_pfinc_mis_cata_1_lpg"
			VALUE
			0x70975
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_mis_cata_2
			"Cxx_pfinc_mis_cata_2"
			VALUE
			0x70976
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_mis_cata_2_lpg
			"Cxx_pfinc_mis_cata_2_lpg"
			VALUE
			0x70977
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_mis_cata_3
			"Cxx_pfinc_mis_cata_3"
			VALUE
			0x70978
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_mis_cata_3_lpg
			"Cxx_pfinc_mis_cata_3_lpg"
			VALUE
			0x70979
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_mis_cata_4
			"Cxx_pfinc_mis_cata_4"
			VALUE
			0x7097A
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_mis_cata_4_lpg
			"Cxx_pfinc_mis_cata_4_lpg"
			VALUE
			0x7097B
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_mis_cata_gas
			"Cxx_pfinc_mis_cata_gas"
			VALUE
			0x7097C
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_mis_cata_lpg
			"Cxx_pfinc_mis_cata_lpg"
			VALUE
			0x7097D
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_mis_fast
			"Cxx_pfinc_mis_fast"
			VALUE
			0x7097E
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_mis_lih
			"Cxx_pfinc_mis_lih"
			VALUE
			0x7097F
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_mis_polu
			"Cxx_pfinc_mis_polu"
			VALUE
			0x70980
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_mis_polu_1
			"Cxx_pfinc_mis_polu_1"
			VALUE
			0x70981
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_mis_polu_1_lpg
			"Cxx_pfinc_mis_polu_1_lpg"
			VALUE
			0x70982
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_mis_polu_2
			"Cxx_pfinc_mis_polu_2"
			VALUE
			0x70983
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_mis_polu_2_lpg
			"Cxx_pfinc_mis_polu_2_lpg"
			VALUE
			0x70984
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_mis_polu_3
			"Cxx_pfinc_mis_polu_3"
			VALUE
			0x70985
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_mis_polu_3_lpg
			"Cxx_pfinc_mis_polu_3_lpg"
			VALUE
			0x70986
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_mis_polu_4
			"Cxx_pfinc_mis_polu_4"
			VALUE
			0x70987
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_mis_polu_4_lpg
			"Cxx_pfinc_mis_polu_4_lpg"
			VALUE
			0x70988
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_mis_polu_gas
			"Cxx_pfinc_mis_polu_gas"
			VALUE
			0x70989
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_mis_polu_lpg
			"Cxx_pfinc_mis_polu_lpg"
			VALUE
			0x7098A
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_mvac_pump_oc
			"Cxx_pfinc_mvac_pump_oc"
			VALUE
			0x7098B
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_mvac_pump_scg
			"Cxx_pfinc_mvac_pump_scg"
			VALUE
			0x7098C
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_mvac_pump_vb_sc
			"Cxx_pfinc_mvac_pump_vb_sc"
			VALUE
			0x7098D
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_mvac_sys
			"Cxx_pfinc_mvac_sys"
			VALUE
			0x7098E
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_obd_cata
			"Cxx_pfinc_obd_cata"
			VALUE
			0x7098F
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_obd_lamb
			"Cxx_pfinc_obd_lamb"
			VALUE
			0x70990
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_obd_sa
			"Cxx_pfinc_obd_sa"
			VALUE
			0x70991
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_oil_cc
			"Cxx_pfinc_oil_cc"
			VALUE
			0x70992
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_oil_co
			"Cxx_pfinc_oil_co"
			VALUE
			0x70993
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_pdl_sens1_oc
			"Cxx_pfinc_pdl_sens1_oc"
			VALUE
			0x70994
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_pdl_sens1_vb_sc
			"Cxx_pfinc_pdl_sens1_vb_sc"
			VALUE
			0x70995
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_pdl_sens2_oc
			"Cxx_pfinc_pdl_sens2_oc"
			VALUE
			0x70996
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_pdl_sens2_vb_sc
			"Cxx_pfinc_pdl_sens2_vb_sc"
			VALUE
			0x70997
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_pdl_sens_chr
			"Cxx_pfinc_pdl_sens_chr"
			VALUE
			0x70998
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_pmh_cc
			"Cxx_pfinc_pmh_cc"
			VALUE
			0x70999
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_pmh_co
			"Cxx_pfinc_pmh_co"
			VALUE
			0x7099A
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_pow_lbdw
			"Cxx_pfinc_pow_lbdw"
			VALUE
			0x7099B
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_pow_lbup
			"Cxx_pfinc_pow_lbup"
			VALUE
			0x7099C
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_ptc
			"Cxx_pfinc_ptc"
			VALUE
			0x7099D
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_ptc_rov_oc
			"Cxx_pfinc_ptc_rov_oc"
			VALUE
			0x7099E
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_ptc_rov_scg
			"Cxx_pfinc_ptc_rov_scg"
			VALUE
			0x7099F
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_ptc_rov_vb_sc
			"Cxx_pfinc_ptc_rov_vb_sc"
			VALUE
			0x709A0
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_pws_1
			"Cxx_pfinc_pws_1"
			VALUE
			0x709A1
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_pws_2
			"Cxx_pfinc_pws_2"
			VALUE
			0x709A2
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_pws_pdl2
			"Cxx_pfinc_pws_pdl2"
			VALUE
			0x709A3
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_pws_thr_pdl1
			"Cxx_pfinc_pws_thr_pdl1"
			VALUE
			0x709A4
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_rams_map_tq
			"Cxx_pfinc_rams_map_tq"
			VALUE
			0x709A5
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_rams_pdl
			"Cxx_pfinc_rams_pdl"
			VALUE
			0x709A8
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_rams_tq_ctl
			"Cxx_pfinc_rams_tq_ctl"
			VALUE
			0x709A6
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_rams_tq_req
			"Cxx_pfinc_rams_tq_req"
			VALUE
			0x709A7
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_reserve_3_oc
			"Cxx_pfinc_reserve_3_oc"
			VALUE
			0x709A9
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_reserve_3_scg
			"Cxx_pfinc_reserve_3_scg"
			VALUE
			0x709AA
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_reserve_3_vb_sc
			"Cxx_pfinc_reserve_3_vb_sc"
			VALUE
			0x709AB
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_rmc_algopp
			"Cxx_pfinc_rmc_algopp"
			VALUE
			0x709AC
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_rmc_clockpp
			"Cxx_pfinc_rmc_clockpp"
			VALUE
			0x709AD
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_rmc_comspipp
			"Cxx_pfinc_rmc_comspipp"
			VALUE
			0x709AE
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_rmc_inhwp
			"Cxx_pfinc_rmc_inhwp"
			VALUE
			0x709AF
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_rmc_monitpp
			"Cxx_pfinc_rmc_monitpp"
			VALUE
			0x709B0
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_rmc_papmpp
			"Cxx_pfinc_rmc_papmpp"
			VALUE
			0x709B1
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_rmc_pedmpp
			"Cxx_pfinc_rmc_pedmpp"
			VALUE
			0x709B2
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_rmc_timeoutpp
			"Cxx_pfinc_rmc_timeoutpp"
			VALUE
			0x709B3
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_sa_ev_oc
			"Cxx_pfinc_sa_ev_oc"
			VALUE
			0x709B7
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_sa_ev_scg
			"Cxx_pfinc_sa_ev_scg"
			VALUE
			0x709B8
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_sa_ev_vb_sc
			"Cxx_pfinc_sa_ev_vb_sc"
			VALUE
			0x709B9
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_sa_oc
			"Cxx_pfinc_sa_oc"
			VALUE
			0x709B4
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_sa_scg
			"Cxx_pfinc_sa_scg"
			VALUE
			0x709B5
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_sa_vb_sc
			"Cxx_pfinc_sa_vb_sc"
			VALUE
			0x709B6
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_spg
			"Cxx_pfinc_spg"
			VALUE
			0x709BA
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_spg_sys
			"Cxx_pfinc_spg_sys"
			VALUE
			0x709BB
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_spi_cc
			"Cxx_pfinc_spi_cc"
			VALUE
			0x709BC
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_svkl_chk_springs
			"Cxx_pfinc_svkl_chk_springs"
			VALUE
			0x709BD
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_svkl_lih
			"Cxx_pfinc_svkl_lih"
			VALUE
			0x709BE
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_svkl_oc
			"Cxx_pfinc_svkl_oc"
			VALUE
			0x709BF
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_svkl_psn
			"Cxx_pfinc_svkl_psn"
			VALUE
			0x709C0
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_svkl_sge
			"Cxx_pfinc_svkl_sge"
			VALUE
			0x709C1
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_svkl_trt_srch
			"Cxx_pfinc_svkl_trt_srch"
			VALUE
			0x709C2
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_swlk_mem
			"Cxx_pfinc_swlk_mem"
			VALUE
			0x709C3
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_tco_acq
			"Cxx_pfinc_tco_acq"
			VALUE
			0x709C4
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_tco_chr
			"Cxx_pfinc_tco_chr"
			VALUE
			0x709C5
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_thpl_oc
			"Cxx_pfinc_thpl_oc"
			VALUE
			0x709C6
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_thpl_scg
			"Cxx_pfinc_thpl_scg"
			VALUE
			0x709C7
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_thpl_vb_sc
			"Cxx_pfinc_thpl_vb_sc"
			VALUE
			0x709C8
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_thr_cmd_cpt
			"Cxx_pfinc_thr_cmd_cpt"
			VALUE
			0x709CE
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_thr_cmd_vb_sc
			"Cxx_pfinc_thr_cmd_vb_sc"
			VALUE
			0x709CF
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_thr_sens1_oc
			"Cxx_pfinc_thr_sens1_oc"
			VALUE
			0x709C9
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_thr_sens1_vb_sc
			"Cxx_pfinc_thr_sens1_vb_sc"
			VALUE
			0x709CA
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_thr_sens2_scg
			"Cxx_pfinc_thr_sens2_scg"
			VALUE
			0x709CB
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_thr_sens2_vb_sc
			"Cxx_pfinc_thr_sens2_vb_sc"
			VALUE
			0x709CC
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_thr_sens_chr
			"Cxx_pfinc_thr_sens_chr"
			VALUE
			0x709CD
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_tia_high
			"Cxx_pfinc_tia_high"
			VALUE
			0x709D0
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_tia_low
			"Cxx_pfinc_tia_low"
			VALUE
			0x709D1
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_tjy_ctl
			"Cxx_pfinc_tjy_ctl"
			VALUE
			0x709D2
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_tlz_ad_b
			"Cxx_pfinc_tlz_ad_b"
			VALUE
			0x709D3
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_vb_high
			"Cxx_pfinc_vb_high"
			VALUE
			0x709D4
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_vb_low
			"Cxx_pfinc_vb_low"
			VALUE
			0x709D5
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_vs_eal
			"Cxx_pfinc_vs_eal"
			VALUE
			0x709D6
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_vs_mux
			"Cxx_pfinc_vs_mux"
			VALUE
			0x709D7
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_vs_parasite
			"Cxx_pfinc_vs_parasite"
			VALUE
			0x709D8
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_vta_intake_pmh
			"Cxx_pfinc_vta_intake_pmh"
			VALUE
			0x709D9
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_vta_intake_shift
			"Cxx_pfinc_vta_intake_shift"
			VALUE
			0x709DA
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_vvt_int_ev_oc
			"Cxx_pfinc_vvt_int_ev_oc"
			VALUE
			0x709DC
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_vvt_int_ev_scg
			"Cxx_pfinc_vvt_int_ev_scg"
			VALUE
			0x709DD
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_vvt_int_ev_vb_sc
			"Cxx_pfinc_vvt_int_ev_vb_sc"
			VALUE
			0x709DE
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_vvt_int_old_off
			"Cxx_pfinc_vvt_int_old_off"
			VALUE
			0x709DB
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_vvt_intake_blk
			"Cxx_pfinc_vvt_intake_blk"
			VALUE
			0x709DF
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_vvt_intake_bound
			"Cxx_pfinc_vvt_intake_bound"
			VALUE
			0x709E0
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_vvt_intake_dyn
			"Cxx_pfinc_vvt_intake_dyn"
			VALUE
			0x709E1
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_vvt_intake_int
			"Cxx_pfinc_vvt_intake_int"
			VALUE
			0x709E2
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_vvtc_toth_3
			"Cxx_pfinc_vvtc_toth_3"
			VALUE
			0x709E3
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_wat_temp_high
			"Cxx_pfinc_wat_temp_high"
			VALUE
			0x709E4
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_wat_temp_low
			"Cxx_pfinc_wat_temp_low"
			VALUE
			0x709E5
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_wgc_oc
			"Cxx_pfinc_wgc_oc"
			VALUE
			0x709E6
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_wgc_scg
			"Cxx_pfinc_wgc_scg"
			VALUE
			0x709E7
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_wgc_vb_sc
			"Cxx_pfinc_wgc_vb_sc"
			VALUE
			0x709E8
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_wpmp_oc
			"Cxx_pfinc_wpmp_oc"
			VALUE
			0x709E9
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_wpmp_scg
			"Cxx_pfinc_wpmp_scg"
			VALUE
			0x709EA
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pfinc_wpmp_vb_sc
			"Cxx_pfinc_wpmp_vb_sc"
			VALUE
			0x709EB
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_agb_rcpt
			"Cxx_pftv_agb_rcpt"
			VALUE
			0x70B8E
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_air
			"Cxx_pftv_air"
			VALUE
			0x70B8F
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_bkup_mem
			"Cxx_pftv_bkup_mem"
			VALUE
			0x70B90
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_clu
			"Cxx_pftv_clu"
			VALUE
			0x70B91
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_cp
			"Cxx_pftv_cp"
			VALUE
			0x70BBD
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_crk
			"Cxx_pftv_crk"
			VALUE
			0x70B92
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_crk_nr
			"Cxx_pftv_crk_nr"
			VALUE
			0x70B93
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_eng_whl
			"Cxx_pftv_eng_whl"
			VALUE
			0x70B94
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_fsys
			"Cxx_pftv_fsys"
			VALUE
			0x70B95
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_fsys_lpg
			"Cxx_pftv_fsys_lpg"
			VALUE
			0x70B96
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_gas_pump
			"Cxx_pftv_gas_pump"
			VALUE
			0x70BBE
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_igc_1
			"Cxx_pftv_igc_1"
			VALUE
			0x70BBF
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_igc_2
			"Cxx_pftv_igc_2"
			VALUE
			0x70BC0
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_igc_3
			"Cxx_pftv_igc_3"
			VALUE
			0x70BC1
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_igc_4
			"Cxx_pftv_igc_4"
			VALUE
			0x70BC2
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_inj1
			"Cxx_pftv_inj1"
			VALUE
			0x70BC3
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_inj2
			"Cxx_pftv_inj2"
			VALUE
			0x70BC4
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_inj3
			"Cxx_pftv_inj3"
			VALUE
			0x70BC5
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_inj4
			"Cxx_pftv_inj4"
			VALUE
			0x70BC6
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_inj_ecu
			"Cxx_pftv_inj_ecu"
			VALUE
			0x70B97
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_knk
			"Cxx_pftv_knk"
			VALUE
			0x70B98
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_lbdw
			"Cxx_pftv_lbdw"
			VALUE
			0x70BC7
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_lbdw_hot
			"Cxx_pftv_lbdw_hot"
			VALUE
			0x70BC8
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_lbup
			"Cxx_pftv_lbup"
			VALUE
			0x70BC9
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_lbup_hot
			"Cxx_pftv_lbup_hot"
			VALUE
			0x70BCA
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_lpg_rcpt
			"Cxx_pftv_lpg_rcpt"
			VALUE
			0x70B99
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_map
			"Cxx_pftv_map"
			VALUE
			0x70B9A
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_min_gas_lvl
			"Cxx_pftv_min_gas_lvl"
			VALUE
			0x70B9B
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_mis_cata
			"Cxx_pftv_mis_cata"
			VALUE
			0x70B9C
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_mis_cata_1
			"Cxx_pftv_mis_cata_1"
			VALUE
			0x70B9D
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_mis_cata_1_lpg
			"Cxx_pftv_mis_cata_1_lpg"
			VALUE
			0x70B9E
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_mis_cata_2
			"Cxx_pftv_mis_cata_2"
			VALUE
			0x70B9F
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_mis_cata_2_lpg
			"Cxx_pftv_mis_cata_2_lpg"
			VALUE
			0x70BA0
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_mis_cata_3
			"Cxx_pftv_mis_cata_3"
			VALUE
			0x70BA1
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_mis_cata_3_lpg
			"Cxx_pftv_mis_cata_3_lpg"
			VALUE
			0x70BA2
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_mis_cata_4
			"Cxx_pftv_mis_cata_4"
			VALUE
			0x70BA3
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_mis_cata_4_lpg
			"Cxx_pftv_mis_cata_4_lpg"
			VALUE
			0x70BA4
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_mis_cata_gas
			"Cxx_pftv_mis_cata_gas"
			VALUE
			0x70BA5
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_mis_cata_lpg
			"Cxx_pftv_mis_cata_lpg"
			VALUE
			0x70BA6
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_mis_polu
			"Cxx_pftv_mis_polu"
			VALUE
			0x70BA7
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_mis_polu_1
			"Cxx_pftv_mis_polu_1"
			VALUE
			0x70BA8
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_mis_polu_1_lpg
			"Cxx_pftv_mis_polu_1_lpg"
			VALUE
			0x70BA9
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_mis_polu_2
			"Cxx_pftv_mis_polu_2"
			VALUE
			0x70BAA
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_mis_polu_2_lpg
			"Cxx_pftv_mis_polu_2_lpg"
			VALUE
			0x70BAB
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_mis_polu_3
			"Cxx_pftv_mis_polu_3"
			VALUE
			0x70BAC
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_mis_polu_3_lpg
			"Cxx_pftv_mis_polu_3_lpg"
			VALUE
			0x70BAD
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_mis_polu_4
			"Cxx_pftv_mis_polu_4"
			VALUE
			0x70BAE
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_mis_polu_4_lpg
			"Cxx_pftv_mis_polu_4_lpg"
			VALUE
			0x70BAF
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_mis_polu_gas
			"Cxx_pftv_mis_polu_gas"
			VALUE
			0x70BB0
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_mis_polu_lpg
			"Cxx_pftv_mis_polu_lpg"
			VALUE
			0x70BB1
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_obd_cata
			"Cxx_pftv_obd_cata"
			VALUE
			0x70BB2
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_obd_lamb
			"Cxx_pftv_obd_lamb"
			VALUE
			0x70BB3
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_obd_sa
			"Cxx_pftv_obd_sa"
			VALUE
			0x70BB4
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_pow_lbdw
			"Cxx_pftv_pow_lbdw"
			VALUE
			0x70BB5
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_pow_lbup
			"Cxx_pftv_pow_lbup"
			VALUE
			0x70BB6
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_rams_pdl
			"Cxx_pftv_rams_pdl"
			VALUE
			0x70BB7
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_sa
			"Cxx_pftv_sa"
			VALUE
			0x70BCB
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_sa_ev
			"Cxx_pftv_sa_ev"
			VALUE
			0x70BCC
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_spg
			"Cxx_pftv_spg"
			VALUE
			0x70BB8
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_spg_sys
			"Cxx_pftv_spg_sys"
			VALUE
			0x70BB9
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_tco
			"Cxx_pftv_tco"
			VALUE
			0x70BCD
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_tia
			"Cxx_pftv_tia"
			VALUE
			0x70BCE
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_tlz_ad_b
			"Cxx_pftv_tlz_ad_b"
			VALUE
			0x70BBA
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_vs
			"Cxx_pftv_vs"
			VALUE
			0x70BCF
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_vta_intake
			"Cxx_pftv_vta_intake"
			VALUE
			0x70BD0
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_vvt_int_ev
			"Cxx_pftv_vvt_int_ev"
			VALUE
			0x70BD1
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_vvt_int_old_off
			"Cxx_pftv_vvt_int_old_off"
			VALUE
			0x70BBB
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_vvt_intake
			"Cxx_pftv_vvt_intake"
			VALUE
			0x70BD2
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_vvtc_toth_3
			"Cxx_pftv_vvtc_toth_3"
			VALUE
			0x70BBC
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pftv_wgc
			"Cxx_pftv_wgc"
			VALUE
			0x70BD3
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_phs_mem_toth_nr
			"Cxx_phs_mem_toth_nr"
			VALUE
			0x70CD2
			DATA_RECORD_UBYTE
			255
			F_1_p0_165
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pn_ac_min_is_n
			"Cxx_pn_ac_min_is_n"
			VALUE
			0x78BA8
			DATA_RECORD_UBYTE
			4080
			F_16_p0_83
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pn_ptc_min_is_n
			"Cxx_pn_ptc_min_is_n"
			VALUE
			0x78BA9
			DATA_RECORD_UBYTE
			4080
			F_16_p0_83
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pn_pwst_min_is_n
			"Cxx_pn_pwst_min_is_n"
			VALUE
			0x78BAA
			DATA_RECORD_UBYTE
			4080
			F_16_p0_83
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pn_tco_is_n_ofs
			"Cxx_pn_tco_is_n_ofs"
			VALUE
			0x78BAB
			DATA_RECORD_UBYTE
			4080
			F_16_p0_83
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pn_vh_min_is_n
			"Cxx_pn_vh_min_is_n"
			VALUE
			0x78BAC
			DATA_RECORD_UBYTE
			4080
			F_16_p0_83
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pn_wind_min_is_n
			"Cxx_pn_wind_min_is_n"
			VALUE
			0x78BAD
			DATA_RECORD_UBYTE
			4080
			F_16_p0_83
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pred_map_dif_dz
			"Cxx_pred_map_dif_dz"
			VALUE
			0x78664
			DATA_RECORD_SWORD
			30309.9375
			F_0v4625_p0_229
			-15155.2
			15154.7375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pred_map_dif_max_fac
			"Cxx_pred_map_dif_max_fac"
			VALUE
			0x78660
			DATA_RECORD_UBYTE
			3.984375
			F_0v015625_p0_13
			0
			3.984375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pred_map_dif_neg_fac
			"Cxx_pred_map_dif_neg_fac"
			VALUE
			0x78661
			DATA_RECORD_UBYTE
			1.9921875
			F_0v0078125_p0_213
			0
			1.9921875
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pred_map_dif_pos_fac
			"Cxx_pred_map_dif_pos_fac"
			VALUE
			0x78662
			DATA_RECORD_UBYTE
			1.9921875
			F_0v0078125_p0_213
			0
			1.9921875
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_prmt_n_ac_dsb_dly
			"Cxx_prmt_n_ac_dsb_dly"
			VALUE
			0x72161
			DATA_RECORD_UBYTE
			32640
			F_128_p0_125
			0
			32640
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_prmt_n_ac_dsb_hys
			"Cxx_prmt_n_ac_dsb_hys"
			VALUE
			0x72162
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_prmt_n_ac_dsb_thd
			"Cxx_prmt_n_ac_dsb_thd"
			VALUE
			0x72163
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_prog_nr1
			"Cxx_prog_nr1"
			VALUE
			0x73212
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_prog_nr2
			"Cxx_prog_nr2"
			VALUE
			0x73213
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_prs_ac_swi_dsb_n_thd
			"Cxx_prs_ac_swi_dsb_n_thd"
			VALUE
			0x72164
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_prs_ac_swi_dsb_vs_thd
			"Cxx_prs_ac_swi_dsb_vs_thd"
			VALUE
			0x72165
			DATA_RECORD_UBYTE
			255
			F_1_p0_58
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_prs_dft_min_is_n
			"Cxx_prs_dft_min_is_n"
			VALUE
			0x78BAE
			DATA_RECORD_UBYTE
			4080
			F_16_p0_83
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_prs_dif_lpg_cdn_thd
			"Cxx_prs_dif_lpg_cdn_thd"
			VALUE
			0x73866
			DATA_RECORD_UWORD
			327675
			F_5_p0_230
			0
			327675
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_prs_pred_prs_dif_thd
			"Cxx_prs_pred_prs_dif_thd"
			VALUE
			0x71CF1
			DATA_RECORD_UBYTE
			943.5
			F_3v7_p0_21
			0
			943.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_prs_spg_fil_fac
			"Cxx_prs_spg_fil_fac"
			VALUE
			0x7847C
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_prs_thd_inj_cut
			"Cxx_prs_thd_inj_cut"
			VALUE
			0x7ADCB
			DATA_RECORD_UBYTE
			943.5
			F_3v7_p0_21
			0
			943.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_prs_zon
			"Cxx_prs_zon"
			VALUE
			0x76F7E
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p0_21
			0
			242479.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_prs_zon0
			"Cxx_prs_zon0"
			VALUE
			0x76F80
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p0_21
			0
			242479.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ptc_cor
			"Cxx_ptc_cor"
			VALUE
			0x73AC1
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ptc_cut_eng_inc
			"Cxx_ptc_cut_eng_inc"
			VALUE
			0x78780
			DATA_RECORD_UWORD
			524280
			F_8_p0_56
			0
			524280
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ptc_cut_n_n_l_thd
			"Cxx_ptc_cut_n_n_l_thd"
			VALUE
			0x78782
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ptc_cut_n_n_up_thd
			"Cxx_ptc_cut_n_n_up_thd"
			VALUE
			0x78784
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ptc_eal_n_l_thd
			"Cxx_ptc_eal_n_l_thd"
			VALUE
			0x78786
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ptc_eal_n_up_thd
			"Cxx_ptc_eal_n_up_thd"
			VALUE
			0x78788
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ptc_eal_pdl_l_thd
			"Cxx_ptc_eal_pdl_l_thd"
			VALUE
			0x78773
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ptc_eal_pdl_up_thd
			"Cxx_ptc_eal_pdl_up_thd"
			VALUE
			0x78774
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ptc_eal_vs_l_thd
			"Cxx_ptc_eal_vs_l_thd"
			VALUE
			0x78775
			DATA_RECORD_UBYTE
			255
			F_1_p0_58
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ptc_eal_vs_up_thd
			"Cxx_ptc_eal_vs_up_thd"
			VALUE
			0x78776
			DATA_RECORD_UBYTE
			255
			F_1_p0_58
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ptc_is_cor_appl_dly
			"Cxx_ptc_is_cor_appl_dly"
			VALUE
			0x73AC2
			DATA_RECORD_UBYTE
			4080
			F_16_p0_10
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ptc_is_cor_appl_dly1
			"Cxx_ptc_is_cor_appl_dly1"
			VALUE
			0x73AC3
			DATA_RECORD_UBYTE
			4080
			F_16_p0_10
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ptc_lbup_conf
			"Cxx_ptc_lbup_conf"
			VALUE
			0x783B4
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ptc_lih_pow
			"Cxx_ptc_lih_pow"
			VALUE
			0x71EF2
			DATA_RECORD_UBYTE
			25500
			F_100_p0_70
			0
			25500
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ptc_max_pow_ena_inc
			"Cxx_ptc_max_pow_ena_inc"
			VALUE
			0x78777
			DATA_RECORD_UBYTE
			255
			F_1_p0_231
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ptc_mem_dly
			"Cxx_ptc_mem_dly"
			VALUE
			0x78778
			DATA_RECORD_UBYTE
			261.12
			F_1v024_p0_119
			0
			261.12
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ptc_mem_inc
			"Cxx_ptc_mem_inc"
			VALUE
			0x78779
			DATA_RECORD_UBYTE
			255
			F_1_p0_232
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ptc_min_is_n_step
			"Cxx_ptc_min_is_n_step"
			VALUE
			0x78BAF
			DATA_RECORD_UBYTE
			4080
			F_16_p0_83
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ptc_min_is_n_step_dly
			"Cxx_ptc_min_is_n_step_dly"
			VALUE
			0x78BB0
			DATA_RECORD_UBYTE
			32640
			F_128_p0_125
			0
			32640
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ptc_min_pow_ena_min
			"Cxx_ptc_min_pow_ena_min"
			VALUE
			0x7877A
			DATA_RECORD_UBYTE
			5100
			F_20_p0_63
			0
			5100
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ptc_pow
			"Cxx_ptc_pow"
			VALUE
			0x73AC4
			DATA_RECORD_UBYTE
			25500
			F_100_p0_70
			0
			25500
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ptc_rov_tia_hys
			"Cxx_ptc_rov_tia_hys"
			VALUE
			0x78D5C
			DATA_RECORD_UBYTE
			159.375
			F_0v625_p0_143
			0
			159.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ptc_rov_tia_thd
			"Cxx_ptc_rov_tia_thd"
			VALUE
			0x78D5D
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ptc_tkof_gear_l_thd
			"Cxx_ptc_tkof_gear_l_thd"
			VALUE
			0x7877B
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ptc_tkof_gear_up_thd
			"Cxx_ptc_tkof_gear_up_thd"
			VALUE
			0x7877C
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ptc_tkof_n_l_thd
			"Cxx_ptc_tkof_n_l_thd"
			VALUE
			0x7878A
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ptc_tkof_n_up_thd
			"Cxx_ptc_tkof_n_up_thd"
			VALUE
			0x7878C
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ptc_tkof_pdl_up_thd
			"Cxx_ptc_tkof_pdl_up_thd"
			VALUE
			0x7877D
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ptc_tkof_vs_l_thd
			"Cxx_ptc_tkof_vs_l_thd"
			VALUE
			0x7877E
			DATA_RECORD_UBYTE
			255
			F_1_p0_58
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ptc_tkof_vs_up_thd
			"Cxx_ptc_tkof_vs_up_thd"
			VALUE
			0x7877F
			DATA_RECORD_UBYTE
			255
			F_1_p0_58
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pump_mvac_dp_max_rat
			"Cxx_pump_mvac_dp_max_rat"
			VALUE
			0x73728
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pump_mvac_prs_fil_fac
			"Cxx_pump_mvac_prs_fil_fac"
			VALUE
			0x73729
			DATA_RECORD_UBYTE
			2.55
			F_0v01_p0_233
			0
			2.55
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pwl_dly
			"Cxx_pwl_dly"
			VALUE
			0x78D57
			DATA_RECORD_UBYTE
			4080
			F_16_p0_217
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pws_1_fil_fac
			"Cxx_pws_1_fil_fac"
			VALUE
			0x70DD4
			DATA_RECORD_UBYTE
			0.99609375
			F_0v00390625_p0_90
			0
			0.99609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pwst_iga_cor_cge_t
			"Cxx_pwst_iga_cor_cge_t"
			VALUE
			0x71CF2
			DATA_RECORD_UBYTE
			4080
			F_16_p0_10
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pwst_min_is_n_dec
			"Cxx_pwst_min_is_n_dec"
			VALUE
			0x78BB1
			DATA_RECORD_UBYTE
			4080
			F_16_p0_83
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pwst_min_is_n_dec_dly
			"Cxx_pwst_min_is_n_dec_dly"
			VALUE
			0x78BB2
			DATA_RECORD_UBYTE
			32640
			F_128_p0_125
			0
			32640
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pwst_min_is_n_rtn_dly
			"Cxx_pwst_min_is_n_rtn_dly"
			VALUE
			0x78BB3
			DATA_RECORD_UBYTE
			32.64
			F_0v128_p0_75
			0
			32.64
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pwst_off_is_cor_dly
			"Cxx_pwst_off_is_cor_dly"
			VALUE
			0x73AC5
			DATA_RECORD_UBYTE
			4.08
			F_0v016_p0_234
			0
			4.08
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pwst_on_is_cor_dly
			"Cxx_pwst_on_is_cor_dly"
			VALUE
			0x73AC6
			DATA_RECORD_UBYTE
			4.08
			F_0v016_p0_234
			0
			4.08
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pwst_prs_tco_thd
			"Cxx_pwst_prs_tco_thd"
			VALUE
			0x73627
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_pwst_tq_loss
			"Cxx_pwst_tq_loss"
			VALUE
			0x79519
			DATA_RECORD_UBYTE
			127.5
			F_0v5_p0_28
			0
			127.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_rams_acel_fil_thr
			"Cxx_rams_acel_fil_thr"
			VALUE
			0x7951A
			DATA_RECORD_UBYTE
			0.99609375
			F_0v00390625_p0_90
			0
			0.99609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_rams_ct_pdl_psn
			"Cxx_rams_ct_pdl_psn"
			VALUE
			0x78FF5
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_rams_ena_diag_dly_1
			"Cxx_rams_ena_diag_dly_1"
			VALUE
			0x7AC20
			DATA_RECORD_UWORD
			524280
			F_8_p0_56
			0
			524280
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_rams_ena_diag_dly_2
			"Cxx_rams_ena_diag_dly_2"
			VALUE
			0x7AC22
			DATA_RECORD_UWORD
			524280
			F_8_p0_56
			0
			524280
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_rams_ena_diag_dly_3
			"Cxx_rams_ena_diag_dly_3"
			VALUE
			0x7AC24
			DATA_RECORD_UWORD
			524280
			F_8_p0_56
			0
			524280
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_rams_ena_diag_gear
			"Cxx_rams_ena_diag_gear"
			VALUE
			0x7AC26
			DATA_RECORD_UWORD
			511.9921875
			F_0v0078125_m100_35
			-100
			411.9921875
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_rams_ena_diag_n_thd
			"Cxx_rams_ena_diag_n_thd"
			VALUE
			0x7AC28
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_rams_ena_diag_tco_thd
			"Cxx_rams_ena_diag_tco_thd"
			VALUE
			0x7951B
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_rams_ena_diag_tkof_tq
			"Cxx_rams_ena_diag_tkof_tq"
			VALUE
			0x79570
			DATA_RECORD_SWORD
			511.9921875
			F_0v0078125_p0_15
			-256
			255.9921875
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_rams_esti_tq_fail_thd
			"Cxx_rams_esti_tq_fail_thd"
			VALUE
			0x7951C
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_rams_fail_dec
			"Cxx_rams_fail_dec"
			VALUE
			0x7951D
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_rams_fail_dec_dly
			"Cxx_rams_fail_dec_dly"
			VALUE
			0x7951E
			DATA_RECORD_UBYTE
			16320
			F_64_p0_145
			0
			16320
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_rams_fl_tqr_thd1
			"Cxx_rams_fl_tqr_thd1"
			VALUE
			0x7951F
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_rams_fl_tqr_thd2
			"Cxx_rams_fl_tqr_thd2"
			VALUE
			0x79520
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_rams_fmt_pdl_vs_thd
			"Cxx_rams_fmt_pdl_vs_thd"
			VALUE
			0x79521
			DATA_RECORD_UBYTE
			255
			F_1_p0_58
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_rams_max_ct_pdl
			"Cxx_rams_max_ct_pdl"
			VALUE
			0x78FF6
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_rams_max_tq_dec
			"Cxx_rams_max_tq_dec"
			VALUE
			0x7AC2A
			DATA_RECORD_UWORD
			511.9921875
			F_0v0078125_p0_15
			0
			511.9921875
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_rams_min_ct_pdl
			"Cxx_rams_min_ct_pdl"
			VALUE
			0x78FF7
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_rams_ovt_dly
			"Cxx_rams_ovt_dly"
			VALUE
			0x79522
			DATA_RECORD_UBYTE
			32640
			F_128_p0_125
			0
			32640
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_rams_pdl_dif
			"Cxx_rams_pdl_dif"
			VALUE
			0x78FF8
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_rams_pdl_max_psn_thd
			"Cxx_rams_pdl_max_psn_thd"
			VALUE
			0x7AC2C
			DATA_RECORD_UWORD
			6399.902344
			F_0v09765625_p0_71
			0
			6399.902344
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_rams_pwst_tq_loss
			"Cxx_rams_pwst_tq_loss"
			VALUE
			0x79523
			DATA_RECORD_UBYTE
			127.5
			F_0v5_p0_28
			0
			127.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_rams_tkof_n_thd
			"Cxx_rams_tkof_n_thd"
			VALUE
			0x7AC2E
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_rams_tkof_tqe_cor
			"Cxx_rams_tkof_tqe_cor"
			VALUE
			0x790E3
			DATA_RECORD_SBYTE
			255
			F_1_p0_235
			-128
			127
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_rams_tq_dec_mask_t
			"Cxx_rams_tq_dec_mask_t"
			VALUE
			0x79524
			DATA_RECORD_UBYTE
			4080
			F_16_p0_10
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_rams_tq_req_fail_thd
			"Cxx_rams_tq_req_fail_thd"
			VALUE
			0x79525
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_rel_thd_thr_prs_h_err
			"Cxx_rel_thd_thr_prs_h_err"
			VALUE
			0x7873B
			DATA_RECORD_UBYTE
			102
			F_0v4_p0_236
			0
			102
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_rest1_ufld_cor
			"Cxx_rest1_ufld_cor"
			VALUE
			0x78AAD
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_rest_mod_dsb_max_dly
			"Cxx_rest_mod_dsb_max_dly"
			VALUE
			0x75914
			DATA_RECORD_UBYTE
			4080
			F_16_p0_217
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_rest_mod_dsb_tco_thd
			"Cxx_rest_mod_dsb_tco_thd"
			VALUE
			0x75915
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_rest_pinj_cor_fac
			"Cxx_rest_pinj_cor_fac"
			VALUE
			0x75916
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_rest_tco_l_ofs
			"Cxx_rest_tco_l_ofs"
			VALUE
			0x78AAA
			DATA_RECORD_UBYTE
			159.375
			F_0v625_p0_143
			0
			159.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_rest_tco_l_ofs_lpg
			"Cxx_rest_tco_l_ofs_lpg"
			VALUE
			0x73801
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_rest_tco_up_ofs
			"Cxx_rest_tco_up_ofs"
			VALUE
			0x78AAB
			DATA_RECORD_UBYTE
			159.375
			F_0v625_p0_143
			0
			159.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_rest_tco_up_ofs_lpg
			"Cxx_rest_tco_up_ofs_lpg"
			VALUE
			0x73802
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_rest_ufld_cor
			"Cxx_rest_ufld_cor"
			VALUE
			0x78AAC
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_rich_cl_alti_fac
			"Cxx_rich_cl_alti_fac"
			VALUE
			0x75917
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_rich_cl_tco_thd
			"Cxx_rich_cl_tco_thd"
			VALUE
			0x75918
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_rich_cor_ena_n_thd
			"Cxx_rich_cor_ena_n_thd"
			VALUE
			0x75919
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_rich_lean_trs_dly
			"Cxx_rich_lean_trs_dly"
			VALUE
			0x783B5
			DATA_RECORD_UBYTE
			2040
			F_8_p0_56
			0
			2040
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_rich_ol_ti_thd
			"Cxx_rich_ol_ti_thd"
			VALUE
			0x76F82
			DATA_RECORD_UWORD
			209712
			F_3v2_p0_152
			0
			209712
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_rich_sta_tco_thd
			"Cxx_rich_sta_tco_thd"
			VALUE
			0x7591A
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_rich_tia_thd
			"Cxx_rich_tia_thd"
			VALUE
			0x7591B
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_run_ac_dyn_iga_fac
			"Cxx_run_ac_dyn_iga_fac"
			VALUE
			0x71CF3
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_run_dyn_iga_ofs
			"Cxx_run_dyn_iga_ofs"
			VALUE
			0x71CF4
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_run_dyn_iga_ofs_lpg
			"Cxx_run_dyn_iga_ofs_lpg"
			VALUE
			0x71CF5
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_run_mdf1_off_tco_thd
			"Cxx_run_mdf1_off_tco_thd"
			VALUE
			0x73739
			DATA_RECORD_UBYTE
			159.375
			F_0v625_p0_143
			0
			159.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_run_ufld_ctr_inc1
			"Cxx_run_ufld_ctr_inc1"
			VALUE
			0x78AAE
			DATA_RECORD_UBYTE
			255
			F_1_p0_53
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_run_ufld_ctr_inc2
			"Cxx_run_ufld_ctr_inc2"
			VALUE
			0x78AAF
			DATA_RECORD_UBYTE
			255
			F_1_p0_53
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_run_vh_dsb_dly
			"Cxx_run_vh_dsb_dly"
			VALUE
			0x73628
			DATA_RECORD_UBYTE
			4080
			F_16_p0_10
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_run_vh_min_is_n
			"Cxx_run_vh_min_is_n"
			VALUE
			0x78BB4
			DATA_RECORD_UBYTE
			4080
			F_16_p0_83
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_sa_alt_dly_is_cor
			"Cxx_sa_alt_dly_is_cor"
			VALUE
			0x7ADCC
			DATA_RECORD_UBYTE
			32640
			F_128_p0_125
			0
			32640
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_sa_dec_nr
			"Cxx_sa_dec_nr"
			VALUE
			0x7772D
			DATA_RECORD_UBYTE
			16320
			F_64_p0_145
			0
			16320
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_sa_diag_lbdw_thd
			"Cxx_sa_diag_lbdw_thd"
			VALUE
			0x7B0B6
			DATA_RECORD_UWORD
			2498.521875
			F_0v038125_p0_237
			0
			2498.521875
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_sa_dly_is_cor
			"Cxx_sa_dly_is_cor"
			VALUE
			0x7ADCD
			DATA_RECORD_UBYTE
			32640
			F_128_p0_125
			0
			32640
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_sa_eol_tco_min
			"Cxx_sa_eol_tco_min"
			VALUE
			0x7772E
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_sa_lbdw_dif_thd
			"Cxx_sa_lbdw_dif_thd"
			VALUE
			0x78370
			DATA_RECORD_UWORD
			2498.521875
			F_0v038125_p0_237
			0
			2498.521875
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_sa_maf_max
			"Cxx_sa_maf_max"
			VALUE
			0x7772F
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_sa_maf_min
			"Cxx_sa_maf_min"
			VALUE
			0x77730
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_sa_map_dif_max
			"Cxx_sa_map_dif_max"
			VALUE
			0x77731
			DATA_RECORD_UBYTE
			943.5
			F_3v7_p0_21
			0
			943.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_sa_map_fac
			"Cxx_sa_map_fac"
			VALUE
			0x77732
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_sa_map_max
			"Cxx_sa_map_max"
			VALUE
			0x77733
			DATA_RECORD_UBYTE
			943.5
			F_3v7_p103_37
			103
			1046.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_sa_map_min
			"Cxx_sa_map_min"
			VALUE
			0x77734
			DATA_RECORD_UBYTE
			943.5
			F_3v7_p103_37
			103
			1046.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_sa_mes_dly
			"Cxx_sa_mes_dly"
			VALUE
			0x77735
			DATA_RECORD_UBYTE
			16320
			F_64_p0_145
			0
			16320
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_sa_n_dif_max
			"Cxx_sa_n_dif_max"
			VALUE
			0x77736
			DATA_RECORD_UBYTE
			65280
			F_256_p0_238
			0
			65280
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_sa_n_max
			"Cxx_sa_n_max"
			VALUE
			0x78372
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_sa_n_min
			"Cxx_sa_n_min"
			VALUE
			0x78374
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_sa_stop_diag_lbdw_thd
			"Cxx_sa_stop_diag_lbdw_thd"
			VALUE
			0x78376
			DATA_RECORD_UWORD
			2498.521875
			F_0v038125_p0_237
			0
			2498.521875
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_sa_tco_min
			"Cxx_sa_tco_min"
			VALUE
			0x77737
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_sa_vb_min
			"Cxx_sa_vb_min"
			VALUE
			0x77738
			DATA_RECORD_UBYTE
			7968.75
			F_31v25_p8000_239
			8000
			15968.75
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_sens_dif_alti_prs_thd
			"Cxx_sens_dif_alti_prs_thd"
			VALUE
			0x7847D
			DATA_RECORD_UBYTE
			943.5
			F_3v7_p0_21
			0
			943.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_sens_pdl_fil_max_grd
			"Cxx_sens_pdl_fil_max_grd"
			VALUE
			0x7338E
			DATA_RECORD_UWORD
			399992.8725
			F_6v1035_p0_240
			0
			399992.8725
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_set_stal_dly
			"Cxx_set_stal_dly"
			VALUE
			0x73700
			DATA_RECORD_UBYTE
			2040
			F_8_p0_56
			0
			2040
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_sfg_seq_trs_ctr
			"Cxx_sfg_seq_trs_ctr"
			VALUE
			0x7591C
			DATA_RECORD_UBYTE
			1020
			F_4_p0_178
			0
			1020
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_sfg_seq_trs_n_thd
			"Cxx_sfg_seq_trs_n_thd"
			VALUE
			0x7591D
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_sfg_seq_trs_ti_fac
			"Cxx_sfg_seq_trs_ti_fac"
			VALUE
			0x7591E
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_sl_cmf_cut_tqe_inc
			"Cxx_sl_cmf_cut_tqe_inc"
			VALUE
			0x78FD4
			DATA_RECORD_UWORD
			31999.4298
			F_0v48828_p0_241
			0
			31999.4298
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_sl_efv_vs_thd
			"Cxx_sl_efv_vs_thd"
			VALUE
			0x78F23
			DATA_RECORD_UBYTE
			25.5
			F_0v1_p0_167
			0
			25.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_sl_lk_ena_dly
			"Cxx_sl_lk_ena_dly"
			VALUE
			0x78F24
			DATA_RECORD_UBYTE
			32.64
			F_0v128_p0_75
			0
			32.64
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_sl_max_tq
			"Cxx_sl_max_tq"
			VALUE
			0x78F25
			DATA_RECORD_UBYTE
			510
			F_2_m100_36
			-100
			410
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_sl_max_vs
			"Cxx_sl_max_vs"
			VALUE
			0x78F26
			DATA_RECORD_UBYTE
			255
			F_1_p0_58
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_sl_min_vs
			"Cxx_sl_min_vs"
			VALUE
			0x78F27
			DATA_RECORD_UBYTE
			255
			F_1_p0_58
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_sl_no_efv_vs_thd
			"Cxx_sl_no_efv_vs_thd"
			VALUE
			0x78F28
			DATA_RECORD_UBYTE
			25.5
			F_0v1_p0_167
			0
			25.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_sl_sp_max_dec
			"Cxx_sl_sp_max_dec"
			VALUE
			0x78FD6
			DATA_RECORD_UWORD
			31999.4298
			F_0v48828_p0_241
			0
			31999.4298
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_sl_svkl_ig
			"Cxx_sl_svkl_ig"
			VALUE
			0x78FD8
			DATA_RECORD_UWORD
			1953.093731
			F_0v0298023_p0_175
			0
			1953.093731
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_sl_svkl_max_i_cor
			"Cxx_sl_svkl_max_i_cor"
			VALUE
			0x78F36
			DATA_RECORD_SWORD
			124.9949055
			F_0v0019073_p0_176
			-62.4984064
			62.4964991
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_sl_svkl_min_i_cor
			"Cxx_sl_svkl_min_i_cor"
			VALUE
			0x78F38
			DATA_RECORD_SWORD
			124.9949055
			F_0v0019073_p0_176
			-62.4984064
			62.4964991
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_sl_svkl_pg
			"Cxx_sl_svkl_pg"
			VALUE
			0x78FDA
			DATA_RECORD_UWORD
			124.9949055
			F_0v0019073_p0_177
			0
			124.9949055
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_sl_svkl_vs_thd
			"Cxx_sl_svkl_vs_thd"
			VALUE
			0x78D65
			DATA_RECORD_SBYTE
			255
			F_1_p0_58
			-128
			127
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_slop_ac_dsb_dly
			"Cxx_slop_ac_dsb_dly"
			VALUE
			0x72166
			DATA_RECORD_UBYTE
			32640
			F_128_p0_125
			0
			32640
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_slop_ac_dsb_gear_hys
			"Cxx_slop_ac_dsb_gear_hys"
			VALUE
			0x72167
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_slop_ac_dsb_gear_thd
			"Cxx_slop_ac_dsb_gear_thd"
			VALUE
			0x72168
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_slop_ac_dsb_n_hys1
			"Cxx_slop_ac_dsb_n_hys1"
			VALUE
			0x72169
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_slop_ac_dsb_n_hys2
			"Cxx_slop_ac_dsb_n_hys2"
			VALUE
			0x7216A
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_slop_ac_dsb_n_thd
			"Cxx_slop_ac_dsb_n_thd"
			VALUE
			0x7216B
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_slop_ac_dsb_thr_thd
			"Cxx_slop_ac_dsb_thr_thd"
			VALUE
			0x7219E
			DATA_RECORD_UWORD
			3932.1
			F_0v06_p0_212
			0
			3932.1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_slop_ac_dsb_vs_hys
			"Cxx_slop_ac_dsb_vs_hys"
			VALUE
			0x7216C
			DATA_RECORD_UBYTE
			255
			F_1_p0_58
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_slop_ac_dsb_vs_thd
			"Cxx_slop_ac_dsb_vs_thd"
			VALUE
			0x7216D
			DATA_RECORD_UBYTE
			255
			F_1_p0_58
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_slop_fil_map_fac
			"Cxx_slop_fil_map_fac"
			VALUE
			0x78658
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_sp_vs_dif_brk_det
			"Cxx_sp_vs_dif_brk_det"
			VALUE
			0x78F29
			DATA_RECORD_UBYTE
			255
			F_1_p0_58
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_spg_ad_alti_thd
			"Cxx_spg_ad_alti_thd"
			VALUE
			0x7ADCE
			DATA_RECORD_UBYTE
			943.5
			F_3v7_p0_21
			0
			943.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_spg_ad_down_vb_thd
			"Cxx_spg_ad_down_vb_thd"
			VALUE
			0x7ADCF
			DATA_RECORD_UBYTE
			8.16
			F_0v032_p8_130
			8
			16.16
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_spg_ad_n_thd
			"Cxx_spg_ad_n_thd"
			VALUE
			0x7B0B8
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_spg_ad_pwm_fac
			"Cxx_spg_ad_pwm_fac"
			VALUE
			0x7ADD0
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_spg_ad_pwm_max_cor
			"Cxx_spg_ad_pwm_max_cor"
			VALUE
			0x7AC3C
			DATA_RECORD_SBYTE
			99.609375
			F_0v390625_p0_4
			-50
			49.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_spg_ad_pwm_min_cor
			"Cxx_spg_ad_pwm_min_cor"
			VALUE
			0x7AC3D
			DATA_RECORD_SBYTE
			99.609375
			F_0v390625_p0_4
			-50
			49.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_spg_ad_spg_thd
			"Cxx_spg_ad_spg_thd"
			VALUE
			0x7ADD1
			DATA_RECORD_UBYTE
			943.5
			F_3v7_p851_242
			851
			1794.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_spg_ad_stab_prs_thd
			"Cxx_spg_ad_stab_prs_thd"
			VALUE
			0x7ADD2
			DATA_RECORD_UBYTE
			943.5
			F_3v7_p0_21
			0
			943.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_spg_ad_up_vb_thd
			"Cxx_spg_ad_up_vb_thd"
			VALUE
			0x7ADD3
			DATA_RECORD_UBYTE
			8.16
			F_0v032_p8_130
			8
			16.16
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_spg_alti_ofs_fac
			"Cxx_spg_alti_ofs_fac"
			VALUE
			0x7ADD4
			DATA_RECORD_UBYTE
			1.9921875
			F_0v0078125_p0_213
			0
			1.9921875
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_spg_alti_ofs_ofs
			"Cxx_spg_alti_ofs_ofs"
			VALUE
			0x7AC3E
			DATA_RECORD_SBYTE
			943.5
			F_3v7_p0_21
			-473.6
			469.9
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_spg_alti_ol_pwm_fac
			"Cxx_spg_alti_ol_pwm_fac"
			VALUE
			0x7ADD5
			DATA_RECORD_UBYTE
			1.9921875
			F_0v0078125_p0_213
			0
			1.9921875
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_spg_cl_tco_thd
			"Cxx_spg_cl_tco_thd"
			VALUE
			0x7ADD6
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_spg_diag_dsb
			"Cxx_spg_diag_dsb"
			VALUE
			0x7ADD7
			DATA_RECORD_UBYTE
			943.5
			F_3v7_p0_21
			0
			943.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_spg_diag_max_tia
			"Cxx_spg_diag_max_tia"
			VALUE
			0x7ADD8
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_spg_diag_min_tia
			"Cxx_spg_diag_min_tia"
			VALUE
			0x7ADD9
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_spg_dly
			"Cxx_spg_dly"
			VALUE
			0x7ADDA
			DATA_RECORD_UBYTE
			32640
			F_128_p0_125
			0
			32640
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_spg_down_ad_dz
			"Cxx_spg_down_ad_dz"
			VALUE
			0x7AC3F
			DATA_RECORD_SBYTE
			99.609375
			F_0v390625_p0_4
			-50
			49.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_spg_drv_pwm_fac
			"Cxx_spg_drv_pwm_fac"
			VALUE
			0x7ADDB
			DATA_RECORD_UBYTE
			3.978
			F_0v0156_p0_243
			0
			3.978
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_spg_err_down_thd_drv
			"Cxx_spg_err_down_thd_drv"
			VALUE
			0x7AC40
			DATA_RECORD_SBYTE
			943.5
			F_3v7_p0_21
			-473.6
			469.9
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_spg_err_drv_fil_fac
			"Cxx_spg_err_drv_fil_fac"
			VALUE
			0x7ADDC
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_spg_err_up_thd_drv
			"Cxx_spg_err_up_thd_drv"
			VALUE
			0x7AC41
			DATA_RECORD_SBYTE
			943.5
			F_3v7_p0_21
			-473.6
			469.9
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_spg_fail_ctr
			"Cxx_spg_fail_ctr"
			VALUE
			0x7ADDD
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_spg_fail_l_thd
			"Cxx_spg_fail_l_thd"
			VALUE
			0x7B0BA
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_spg_fail_up_thd
			"Cxx_spg_fail_up_thd"
			VALUE
			0x7B0BC
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_spg_i_pwm_fac
			"Cxx_spg_i_pwm_fac"
			VALUE
			0x7ADDE
			DATA_RECORD_UBYTE
			52.581
			F_0v2062_p0_244
			0
			52.581
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_spg_i_pwm_max_cor
			"Cxx_spg_i_pwm_max_cor"
			VALUE
			0x7AC42
			DATA_RECORD_SBYTE
			99.609375
			F_0v390625_p0_4
			-50
			49.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_spg_i_pwm_min_cor
			"Cxx_spg_i_pwm_min_cor"
			VALUE
			0x7AC43
			DATA_RECORD_SBYTE
			99.609375
			F_0v390625_p0_4
			-50
			49.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_spg_i_pwm_sp
			"Cxx_spg_i_pwm_sp"
			VALUE
			0x7AC44
			DATA_RECORD_SBYTE
			99.609375
			F_0v390625_p0_4
			-50
			49.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_spg_max_err_drv
			"Cxx_spg_max_err_drv"
			VALUE
			0x7AC45
			DATA_RECORD_SBYTE
			235.875
			F_0v925_p0_245
			-118.4
			117.475
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_spg_max_prs_dif
			"Cxx_spg_max_prs_dif"
			VALUE
			0x7ADDF
			DATA_RECORD_UBYTE
			943.5
			F_3v7_p0_21
			0
			943.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_spg_max_pwm
			"Cxx_spg_max_pwm"
			VALUE
			0x7ADE0
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_spg_min
			"Cxx_spg_min"
			VALUE
			0x7B0BE
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_spg_min_err_drv
			"Cxx_spg_min_err_drv"
			VALUE
			0x7AC46
			DATA_RECORD_SBYTE
			235.875
			F_0v925_p0_245
			-118.4
			117.475
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_spg_min_pwm
			"Cxx_spg_min_pwm"
			VALUE
			0x7ADE1
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_spg_n_thd
			"Cxx_spg_n_thd"
			VALUE
			0x7ADE2
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_spg_ol_spg_sp_thd
			"Cxx_spg_ol_spg_sp_thd"
			VALUE
			0x7ADE3
			DATA_RECORD_UBYTE
			943.5
			F_3v7_p851_242
			851
			1794.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_spg_prop_dz
			"Cxx_spg_prop_dz"
			VALUE
			0x7ADE4
			DATA_RECORD_UBYTE
			943.5
			F_3v7_p0_21
			0
			943.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_spg_prop_pwm_fac
			"Cxx_spg_prop_pwm_fac"
			VALUE
			0x7ADE5
			DATA_RECORD_UBYTE
			420.64545
			F_1v64959_p0_246
			0
			420.64545
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_spg_pwm_bch_mod_val
			"Cxx_spg_pwm_bch_mod_val"
			VALUE
			0x7ADE6
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_spg_pwm_dif_trt_ad
			"Cxx_spg_pwm_dif_trt_ad"
			VALUE
			0x7ADE7
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_spg_sys_diag_dly
			"Cxx_spg_sys_diag_dly"
			VALUE
			0x7ADE8
			DATA_RECORD_UBYTE
			32640
			F_128_p0_125
			0
			32640
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_spg_up_ad_dz
			"Cxx_spg_up_ad_dz"
			VALUE
			0x7AC47
			DATA_RECORD_SBYTE
			99.609375
			F_0v390625_p0_4
			-50
			49.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_sta_ac_dsb_dly
			"Cxx_sta_ac_dsb_dly"
			VALUE
			0x7216E
			DATA_RECORD_UBYTE
			32640
			F_128_p0_125
			0
			32640
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_sta_dyn_iga_mv_n_fac
			"Cxx_sta_dyn_iga_mv_n_fac"
			VALUE
			0x71CF6
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_sta_fl_off_dly
			"Cxx_sta_fl_off_dly"
			VALUE
			0x7591F
			DATA_RECORD_UBYTE
			2088.96
			F_8v192_p0_247
			0
			2088.96
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_sta_fl_off_dly_lpg
			"Cxx_sta_fl_off_dly_lpg"
			VALUE
			0x75920
			DATA_RECORD_UBYTE
			2088.96
			F_8v192_p0_247
			0
			2088.96
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_sta_gas_pump_n_thd
			"Cxx_sta_gas_pump_n_thd"
			VALUE
			0x78D58
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_sta_iga_dec
			"Cxx_sta_iga_dec"
			VALUE
			0x71CF7
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_sta_iga_dec_tdc_nr
			"Cxx_sta_iga_dec_tdc_nr"
			VALUE
			0x71CF8
			DATA_RECORD_UBYTE
			255
			F_1_p0_53
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_sta_iga_vld_ctr
			"Cxx_sta_iga_vld_ctr"
			VALUE
			0x747F5
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_sta_inj_sta_angl
			"Cxx_sta_inj_sta_angl"
			VALUE
			0x75921
			DATA_RECORD_UBYTE
			765
			F_3_p0_111
			0
			765
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_sta_n_fil_fac
			"Cxx_sta_n_fil_fac"
			VALUE
			0x71CF9
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_sta_pinj_toth_nr
			"Cxx_sta_pinj_toth_nr"
			VALUE
			0x76F9C
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_sta_rich_dec_nr
			"Cxx_sta_rich_dec_nr"
			VALUE
			0x75922
			DATA_RECORD_UBYTE
			255
			F_1_p0_53
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_sta_stt_is_in_dly
			"Cxx_sta_stt_is_in_dly"
			VALUE
			0x73AC7
			DATA_RECORD_UBYTE
			8160
			F_32_p0_122
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_sta_tco_ti_dec_fac
			"Cxx_sta_tco_ti_dec_fac"
			VALUE
			0x75923
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_sta_tco_ti_rest_fac
			"Cxx_sta_tco_ti_rest_fac"
			VALUE
			0x75924
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_stab_aj_fast_tq_fac
			"Cxx_stab_aj_fast_tq_fac"
			VALUE
			0x71CFA
			DATA_RECORD_UBYTE
			15.9375
			F_0v0625_p0_39
			0
			15.9375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_stab_aj_fast_tq_ofs
			"Cxx_stab_aj_fast_tq_ofs"
			VALUE
			0x71CFB
			DATA_RECORD_UBYTE
			127.5
			F_0v5_p0_28
			0
			127.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_stab_dyn_dif_prs_thd
			"Cxx_stab_dyn_dif_prs_thd"
			VALUE
			0x71DD6
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p0_21
			0
			242479.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_stab_dyn_iga_fil_fac
			"Cxx_stab_dyn_iga_fil_fac"
			VALUE
			0x71CFC
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_stab_dyn_iga_n_thd
			"Cxx_stab_dyn_iga_n_thd"
			VALUE
			0x71DD8
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_stab_dyn_prs_l_thd
			"Cxx_stab_dyn_prs_l_thd"
			VALUE
			0x71DDA
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_stab_dyn_prs_up_thd
			"Cxx_stab_dyn_prs_up_thd"
			VALUE
			0x71DDC
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_stab_spg_dif_thd
			"Cxx_stab_spg_dif_thd"
			VALUE
			0x7B0C0
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p0_21
			0
			242479.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_stal_ac_dsb_dly
			"Cxx_stal_ac_dsb_dly"
			VALUE
			0x7216F
			DATA_RECORD_UBYTE
			261.12
			F_1v024_p0_119
			0
			261.12
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_stal_ac_dsb_n_thd
			"Cxx_stal_ac_dsb_n_thd"
			VALUE
			0x72170
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_stal_det_swlk_dly
			"Cxx_stal_det_swlk_dly"
			VALUE
			0x73701
			DATA_RECORD_UBYTE
			2088.96
			F_8v192_p0_248
			0
			2088.96
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_stal_det_thd
			"Cxx_stal_det_thd"
			VALUE
			0x784AC
			DATA_RECORD_UWORD
			209.712
			F_0v0032_p0_8
			0
			209.712
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_stal_dly
			"Cxx_stal_dly"
			VALUE
			0x73702
			DATA_RECORD_UBYTE
			2040
			F_8_p0_56
			0
			2040
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_stal_rest_fac
			"Cxx_stal_rest_fac"
			VALUE
			0x78AB0
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_stal_step
			"Cxx_stal_step"
			VALUE
			0x70CD3
			DATA_RECORD_UBYTE
			255
			F_1_p0_165
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_stat_whl_acq_dif
			"Cxx_stat_whl_acq_dif"
			VALUE
			0x73629
			DATA_RECORD_UBYTE
			557.94
			F_2v188_p0_202
			0
			557.94
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_stat_whl_dly
			"Cxx_stat_whl_dly"
			VALUE
			0x7362A
			DATA_RECORD_UBYTE
			4080
			F_16_p0_10
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_stat_whl_thd
			"Cxx_stat_whl_thd"
			VALUE
			0x73650
			DATA_RECORD_UWORD
			143390.58
			F_2v188_p0_202
			0
			143390.58
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_stop_ac_dyn_iga_fac
			"Cxx_stop_ac_dyn_iga_fac"
			VALUE
			0x71CFD
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_stop_dyn_iga_ofs
			"Cxx_stop_dyn_iga_ofs"
			VALUE
			0x71CFE
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_stop_dyn_iga_ofs_lpg
			"Cxx_stop_dyn_iga_ofs_lpg"
			VALUE
			0x71CFF
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_stop_edic_rec
			"Cxx_stop_edic_rec"
			VALUE
			0x77739
			DATA_RECORD_UBYTE
			65280
			F_256_p0_142
			0
			65280
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_stop_eng_dly
			"Cxx_stop_eng_dly"
			VALUE
			0x7902A
			DATA_RECORD_UBYTE
			8160
			F_32_p0_122
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_stop_oten_rec
			"Cxx_stop_oten_rec"
			VALUE
			0x7773A
			DATA_RECORD_UBYTE
			65280
			F_256_p0_142
			0
			65280
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_stop_rest_tco_thd
			"Cxx_stop_rest_tco_thd"
			VALUE
			0x78AB1
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_stop_rest_ufld_thd
			"Cxx_stop_rest_ufld_thd"
			VALUE
			0x78AB2
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_stop_tkof_fil_fac
			"Cxx_stop_tkof_fil_fac"
			VALUE
			0x79526
			DATA_RECORD_UBYTE
			0.99609375
			F_0v00390625_p0_90
			0
			0.99609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_stop_toil_fil
			"Cxx_stop_toil_fil"
			VALUE
			0x77016
			DATA_RECORD_UWORD
			99.99847412
			F_0v0015258789_p0_115
			0
			99.99847412
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_stop_ufld_ctr_inc
			"Cxx_stop_ufld_ctr_inc"
			VALUE
			0x78AB3
			DATA_RECORD_UBYTE
			65280
			F_256_p0_142
			0
			65280
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_sudn_brk_det_dly
			"Cxx_sudn_brk_det_dly"
			VALUE
			0x78F2A
			DATA_RECORD_UBYTE
			8160
			F_32_p0_122
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_sudn_brk_min_decl_thd
			"Cxx_sudn_brk_min_decl_thd"
			VALUE
			0x78F2B
			DATA_RECORD_UBYTE
			25.5
			F_0v1_p0_159
			0
			25.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_supl_nr1
			"Cxx_supl_nr1"
			VALUE
			0x7320A
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_supl_nr2
			"Cxx_supl_nr2"
			VALUE
			0x7320B
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_supl_nr3
			"Cxx_supl_nr3"
			VALUE
			0x7320C
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_svkl_oc_detect_delay
			"Cxx_svkl_oc_detect_delay"
			VALUE
			0x73255
			DATA_RECORD_UBYTE
			510
			F_2_p0_249
			0
			510
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_svkl_oc_diag_dsb_delay
			"Cxx_svkl_oc_diag_dsb_delay"
			VALUE
			0x73256
			DATA_RECORD_UBYTE
			510
			F_2_p0_249
			0
			510
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_svkl_oc_lh_pos_thresh
			"Cxx_svkl_oc_lh_pos_thresh"
			VALUE
			0x73257
			DATA_RECORD_UBYTE
			24.90234375
			F_0v09765625_p0_71
			0
			24.90234375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_svkl_oc_max_error
			"Cxx_svkl_oc_max_error"
			VALUE
			0x73390
			DATA_RECORD_UWORD
			6399.902344
			F_0v09765625_m100_250
			-100
			6299.902344
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_swi_ac_dsb_pow_thd
			"Cxx_swi_ac_dsb_pow_thd"
			VALUE
			0x75925
			DATA_RECORD_UBYTE
			4998
			F_19v6_p0_251
			0
			4998
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_swi_cor_n_thd
			"Cxx_swi_cor_n_thd"
			VALUE
			0x71D00
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_swi_cor_stop_n_thd
			"Cxx_swi_cor_stop_n_thd"
			VALUE
			0x75926
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_swi_ena_drv_n_thd
			"Cxx_swi_ena_drv_n_thd"
			VALUE
			0x75927
			DATA_RECORD_UBYTE
			4845
			F_19_p0_95
			0
			4845
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_swi_is_ofs
			"Cxx_swi_is_ofs"
			VALUE
			0x75928
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_swi_is_ofs_lpg
			"Cxx_swi_is_ofs_lpg"
			VALUE
			0x75929
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_sys_c_nr
			"Cxx_sys_c_nr"
			VALUE
			0x73219
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_t_dly_cge
			"Cxx_t_dly_cge"
			VALUE
			0x79527
			DATA_RECORD_UBYTE
			32.64
			F_0v128_p0_75
			0
			32.64
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_t_dly_n_drv_puls
			"Cxx_t_dly_n_drv_puls"
			VALUE
			0x79528
			DATA_RECORD_UBYTE
			32.64
			F_0v128_p0_75
			0
			32.64
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_t_pred_dly_ref
			"Cxx_t_pred_dly_ref"
			VALUE
			0x78728
			DATA_RECORD_UWORD
			3999938.555
			F_61v03515_p0_252
			0
			3999938.555
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tbn_prs_dif_cut_fac
			"Cxx_tbn_prs_dif_cut_fac"
			VALUE
			0x7ADE9
			DATA_RECORD_UBYTE
			99.603
			F_0v3906_p0_133
			0
			99.603
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tco_chr_fil_dly
			"Cxx_tco_chr_fil_dly"
			VALUE
			0x7B192
			DATA_RECORD_UBYTE
			261.12
			F_1v024_p0_119
			0
			261.12
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tco_cor_vld_alt_typ
			"Cxx_tco_cor_vld_alt_typ"
			VALUE
			0x79529
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tco_fail_cmd_mdf_dly
			"Cxx_tco_fail_cmd_mdf_dly"
			VALUE
			0x7373A
			DATA_RECORD_UBYTE
			4177.92
			F_16v384_p0_161
			0
			4177.92
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tco_fail_pinj_t
			"Cxx_tco_fail_pinj_t"
			VALUE
			0x7592A
			DATA_RECORD_UBYTE
			1020
			F_4_p0_128
			0
			1020
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tco_inc_tdc_nr
			"Cxx_tco_inc_tdc_nr"
			VALUE
			0x7B193
			DATA_RECORD_UBYTE
			255
			F_1_p0_53
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tco_is_n_ofs_rat_lim
			"Cxx_tco_is_n_ofs_rat_lim"
			VALUE
			0x78BB5
			DATA_RECORD_UBYTE
			4080
			F_16_p0_83
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tco_kd_rich_cor_fac
			"Cxx_tco_kd_rich_cor_fac"
			VALUE
			0x7592B
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tco_mdf_dly
			"Cxx_tco_mdf_dly"
			VALUE
			0x7373B
			DATA_RECORD_UBYTE
			4177.92
			F_16v384_p0_161
			0
			4177.92
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tco_mdl_max
			"Cxx_tco_mdl_max"
			VALUE
			0x7B194
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tco_mon_dly
			"Cxx_tco_mon_dly"
			VALUE
			0x7B195
			DATA_RECORD_UBYTE
			261.12
			F_1v024_p0_119
			0
			261.12
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tco_ti_fil_nr
			"Cxx_tco_ti_fil_nr"
			VALUE
			0x7592C
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tco_ti_fil_nr2
			"Cxx_tco_ti_fil_nr2"
			VALUE
			0x7592D
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tco_toil_fil
			"Cxx_tco_toil_fil"
			VALUE
			0x77018
			DATA_RECORD_UWORD
			99.99847412
			F_0v0015258789_p0_115
			0
			99.99847412
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tco_toil_thd
			"Cxx_tco_toil_thd"
			VALUE
			0x76FEF
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tco_wup_thd
			"Cxx_tco_wup_thd"
			VALUE
			0x736CE
			DATA_RECORD_UBYTE
			159.375
			F_0v625_p0_143
			0
			159.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tdc_nr_bfr_gas_lpg
			"Cxx_tdc_nr_bfr_gas_lpg"
			VALUE
			0x73803
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tdc_nr_bfr_lpg_gas
			"Cxx_tdc_nr_bfr_lpg_gas"
			VALUE
			0x73804
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tdc_nr_pred_dly_ref
			"Cxx_tdc_nr_pred_dly_ref"
			VALUE
			0x7872A
			DATA_RECORD_UWORD
			511.95942
			F_0v007812_p0_253
			0
			511.95942
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tdc_per_fac
			"Cxx_tdc_per_fac"
			VALUE
			0x7AC30
			DATA_RECORD_UWORD
			62258.25
			F_0v95_p0_254
			0
			62258.25
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_temp_ac_dsb_dly
			"Cxx_temp_ac_dsb_dly"
			VALUE
			0x72171
			DATA_RECORD_UBYTE
			32640
			F_128_p0_125
			0
			32640
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_temp_ac_dsb_n_thd
			"Cxx_temp_ac_dsb_n_thd"
			VALUE
			0x72172
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_temp_ac_dsb_prs_thd
			"Cxx_temp_ac_dsb_prs_thd"
			VALUE
			0x721A0
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_temp_ac_dsb_tco_thd
			"Cxx_temp_ac_dsb_tco_thd"
			VALUE
			0x72173
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_thd_can_ncyl_dly
			"Cxx_thd_can_ncyl_dly"
			VALUE
			0x720BE
			DATA_RECORD_UWORD
			209712
			F_3v2_p0_152
			0
			209712
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_thd_map_in_thr_adj
			"Cxx_thd_map_in_thr_adj"
			VALUE
			0x70D8A
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p0_21
			0
			242479.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_thd_map_out_thr_adj
			"Cxx_thd_map_out_thr_adj"
			VALUE
			0x70D8C
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p0_21
			0
			242479.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_thd_n_diag
			"Cxx_thd_n_diag"
			VALUE
			0x71DE9
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_thd_n_in_thr_adj
			"Cxx_thd_n_in_thr_adj"
			VALUE
			0x70D8E
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_thd_n_out_thr_adj
			"Cxx_thd_n_out_thr_adj"
			VALUE
			0x70D90
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_thd_syn_fail_per
			"Cxx_thd_syn_fail_per"
			VALUE
			0x7849D
			DATA_RECORD_UBYTE
			261120
			F_1024_p0_255
			0
			261120
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_thd_vb_fail
			"Cxx_thd_vb_fail"
			VALUE
			0x71DEA
			DATA_RECORD_UBYTE
			8.16
			F_0v032_p8_130
			8
			16.16
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_thpl1_is_cor
			"Cxx_thpl1_is_cor"
			VALUE
			0x73ACA
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_thpl2_is_cor
			"Cxx_thpl2_is_cor"
			VALUE
			0x73ACB
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_thpl3_is_cor
			"Cxx_thpl3_is_cor"
			VALUE
			0x73ACC
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_thpl_dsb_max_dly
			"Cxx_thpl_dsb_max_dly"
			VALUE
			0x790B3
			DATA_RECORD_UBYTE
			261.12
			F_1v024_p0_119
			0
			261.12
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_thpl_fil_vb_fac
			"Cxx_thpl_fil_vb_fac"
			VALUE
			0x790B4
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_thpl_is_cor_dec
			"Cxx_thpl_is_cor_dec"
			VALUE
			0x73AC8
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_thpl_is_cor_dly
			"Cxx_thpl_is_cor_dly"
			VALUE
			0x73AC9
			DATA_RECORD_UBYTE
			4080
			F_16_p0_10
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_thpl_neg_el_csm_fac
			"Cxx_thpl_neg_el_csm_fac"
			VALUE
			0x790B5
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_thpl_neg_el_csm_thd
			"Cxx_thpl_neg_el_csm_thd"
			VALUE
			0x790BC
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_thpl_off_dly
			"Cxx_thpl_off_dly"
			VALUE
			0x790B6
			DATA_RECORD_UBYTE
			32640
			F_128_p0_125
			0
			32640
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_thpl_pos_el_csm_fac
			"Cxx_thpl_pos_el_csm_fac"
			VALUE
			0x790B7
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_thpl_pos_el_csm_thd
			"Cxx_thpl_pos_el_csm_thd"
			VALUE
			0x790BE
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_thpl_pow
			"Cxx_thpl_pow"
			VALUE
			0x7952A
			DATA_RECORD_UBYTE
			5100
			F_20_p0_63
			0
			5100
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_thpl_tco_hys
			"Cxx_thpl_tco_hys"
			VALUE
			0x790B8
			DATA_RECORD_UBYTE
			159.375
			F_0v625_p0_256
			0
			159.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_thpl_vb_aftr_sta_dly
			"Cxx_thpl_vb_aftr_sta_dly"
			VALUE
			0x790B9
			DATA_RECORD_UBYTE
			32640
			F_128_p0_125
			0
			32640
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_thr_acel_thd
			"Cxx_thr_acel_thd"
			VALUE
			0x7AC32
			DATA_RECORD_UWORD
			3905.886
			F_0v0596_p0_108
			0
			3905.886
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_thr_ar_max_slop
			"Cxx_thr_ar_max_slop"
			VALUE
			0x7872C
			DATA_RECORD_UWORD
			3906.187461
			F_0v0596046_p0_257
			0
			3906.187461
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_thr_chk_lh_cmd_cut_dly
			"Cxx_thr_chk_lh_cmd_cut_dly"
			VALUE
			0x73258
			DATA_RECORD_UBYTE
			2088.96
			F_8v192_p0_248
			0
			2088.96
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_thr_chk_lh_ena_dly
			"Cxx_thr_chk_lh_ena_dly"
			VALUE
			0x73259
			DATA_RECORD_UBYTE
			2088.96
			F_8v192_p0_248
			0
			2088.96
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_thr_chk_lh_h_sp
			"Cxx_thr_chk_lh_h_sp"
			VALUE
			0x73392
			DATA_RECORD_UWORD
			3199.951172
			F_0v048828125_p0_199
			0
			3199.951172
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_thr_chk_lh_l_sp
			"Cxx_thr_chk_lh_l_sp"
			VALUE
			0x73394
			DATA_RECORD_UWORD
			3199.951172
			F_0v048828125_p0_199
			0
			3199.951172
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_thr_chk_lh_stab_dly
			"Cxx_thr_chk_lh_stab_dly"
			VALUE
			0x7325A
			DATA_RECORD_UBYTE
			2088.96
			F_8v192_p0_248
			0
			2088.96
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_thr_ctl_h_v_lim
			"Cxx_thr_ctl_h_v_lim"
			VALUE
			0x732D0
			DATA_RECORD_SWORD
			40959.375
			F_0v625_p0_258
			-20480
			20479.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_thr_ctl_l_v_lim
			"Cxx_thr_ctl_l_v_lim"
			VALUE
			0x732D2
			DATA_RECORD_SWORD
			40959.375
			F_0v625_p0_258
			-20480
			20479.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_thr_l_trt_ofs
			"Cxx_thr_l_trt_ofs"
			VALUE
			0x73396
			DATA_RECORD_UWORD
			6399.88596
			F_0v097656_p0_5
			0
			6399.88596
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_thr_mcut_chr_thd
			"Cxx_thr_mcut_chr_thd"
			VALUE
			0x73398
			DATA_RECORD_UWORD
			6399.902344
			F_0v09765625_p0_71
			0
			6399.902344
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_thr_mcut_det_done
			"Cxx_thr_mcut_det_done"
			VALUE
			0x732D4
			DATA_RECORD_SWORD
			6399.902344
			F_0v09765625_p0_71
			-3200
			3199.902344
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_thr_mcut_det_thd
			"Cxx_thr_mcut_det_thd"
			VALUE
			0x7339A
			DATA_RECORD_UWORD
			6399.902344
			F_0v09765625_p0_71
			0
			6399.902344
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_thr_mcut_svkl_frz_dly
			"Cxx_thr_mcut_svkl_frz_dly"
			VALUE
			0x7325B
			DATA_RECORD_UBYTE
			510
			F_2_p0_249
			0
			510
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_thr_mcut_thd_ctr
			"Cxx_thr_mcut_thd_ctr"
			VALUE
			0x7325C
			DATA_RECORD_UBYTE
			255
			F_1_p0_9
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_thr_mdl_fil_fac
			"Cxx_thr_mdl_fil_fac"
			VALUE
			0x747F6
			DATA_RECORD_UBYTE
			0.99609375
			F_0v00390625_p0_90
			0
			0.99609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_thr_mov_rat_lim
			"Cxx_thr_mov_rat_lim"
			VALUE
			0x74864
			DATA_RECORD_UWORD
			8191.875
			F_0v125_p0_259
			0
			8191.875
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_thr_pos_dyn_lim
			"Cxx_thr_pos_dyn_lim"
			VALUE
			0x7AC34
			DATA_RECORD_UWORD
			8191.875
			F_0v125_p0_259
			0
			8191.875
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_thr_pos_lim
			"Cxx_thr_pos_lim"
			VALUE
			0x7339C
			DATA_RECORD_UWORD
			3199.951172
			F_0v048828125_p0_260
			0
			3199.951172
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_thr_pos_max_thr_adj
			"Cxx_thr_pos_max_thr_adj"
			VALUE
			0x70D92
			DATA_RECORD_UWORD
			6399.88596
			F_0v097656_p0_5
			0
			6399.88596
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_thr_pos_min_thr_adj
			"Cxx_thr_pos_min_thr_adj"
			VALUE
			0x70D94
			DATA_RECORD_UWORD
			6399.88596
			F_0v097656_p0_5
			0
			6399.88596
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_thr_pos_sc_asd
			"Cxx_thr_pos_sc_asd"
			VALUE
			0x7AC36
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_thr_pos_sc_bch
			"Cxx_thr_pos_sc_bch"
			VALUE
			0x7AC38
			DATA_RECORD_UWORD
			65535
			F_1_p0_9
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_thr_psn_cge_fil_fac
			"Cxx_thr_psn_cge_fil_fac"
			VALUE
			0x7847E
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_thr_psn_dif_thd
			"Cxx_thr_psn_dif_thd"
			VALUE
			0x7ADEA
			DATA_RECORD_UBYTE
			102
			F_0v4_p0_106
			0
			102
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_thr_psn_fil_fac
			"Cxx_thr_psn_fil_fac"
			VALUE
			0x784CC
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_thr_sens_shift_diag_dly
			"Cxx_thr_sens_shift_diag_dly"
			VALUE
			0x7325D
			DATA_RECORD_UBYTE
			510
			F_2_p0_249
			0
			510
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_thr_sge_dsb_dly
			"Cxx_thr_sge_dsb_dly"
			VALUE
			0x7339E
			DATA_RECORD_UWORD
			131070
			F_2_p0_249
			0
			131070
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_thr_sge_err_dly
			"Cxx_thr_sge_err_dly"
			VALUE
			0x733A0
			DATA_RECORD_UWORD
			131070
			F_2_p0_249
			0
			131070
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_thr_sge_err_thd
			"Cxx_thr_sge_err_thd"
			VALUE
			0x733A2
			DATA_RECORD_UWORD
			6399.902344
			F_0v09765625_p0_71
			0
			6399.902344
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_thr_sge_fil_fac_1
			"Cxx_thr_sge_fil_fac_1"
			VALUE
			0x732D6
			DATA_RECORD_SWORD
			47997.834
			F_0v7324_p0_261
			-23999.2832
			23998.5508
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_thr_sge_fil_fac_2
			"Cxx_thr_sge_fil_fac_2"
			VALUE
			0x732D8
			DATA_RECORD_SWORD
			47997.834
			F_0v7324_p0_261
			-23999.2832
			23998.5508
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_thr_sge_fil_fac_3
			"Cxx_thr_sge_fil_fac_3"
			VALUE
			0x732DA
			DATA_RECORD_SWORD
			47997.834
			F_0v7324_p0_261
			-23999.2832
			23998.5508
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_thr_sge_fil_fac_4
			"Cxx_thr_sge_fil_fac_4"
			VALUE
			0x732DC
			DATA_RECORD_SWORD
			47997.834
			F_0v7324_p0_261
			-23999.2832
			23998.5508
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_thr_sge_fil_fac_5
			"Cxx_thr_sge_fil_fac_5"
			VALUE
			0x732DE
			DATA_RECORD_SWORD
			47997.834
			F_0v7324_p0_261
			-23999.2832
			23998.5508
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_thr_sge_svkl_int_thd
			"Cxx_thr_sge_svkl_int_thd"
			VALUE
			0x733A4
			DATA_RECORD_UWORD
			40959.375
			F_0v625_p0_258
			0
			40959.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_thr_sge_svkl_ol_dly
			"Cxx_thr_sge_svkl_ol_dly"
			VALUE
			0x733A6
			DATA_RECORD_UWORD
			131070
			F_2_p0_249
			0
			131070
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ti_ad1_zon0_ini
			"Cxx_ti_ad1_zon0_ini"
			VALUE
			0x731E7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ti_ad1_zon1_ini
			"Cxx_ti_ad1_zon1_ini"
			VALUE
			0x731E7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x2
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ti_ad1_zon2_ini
			"Cxx_ti_ad1_zon2_ini"
			VALUE
			0x731E7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x4
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ti_ad1_zon3_ini
			"Cxx_ti_ad1_zon3_ini"
			VALUE
			0x731E7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x8
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ti_ad1_zon4_ini
			"Cxx_ti_ad1_zon4_ini"
			VALUE
			0x731E7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x10
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ti_ad_max_n
			"Cxx_ti_ad_max_n"
			VALUE
			0x7592E
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ti_ad_prs_l_thd
			"Cxx_ti_ad_prs_l_thd"
			VALUE
			0x76F84
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ti_ad_prs_trs_thd
			"Cxx_ti_ad_prs_trs_thd"
			VALUE
			0x76F86
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p0_21
			0
			242479.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ti_ad_prs_up_thd
			"Cxx_ti_ad_prs_up_thd"
			VALUE
			0x76F88
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ti_ad_tco_thd
			"Cxx_ti_ad_tco_thd"
			VALUE
			0x7592F
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ti_i2_cor_fac
			"Cxx_ti_i2_cor_fac"
			VALUE
			0x75932
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ti_i_cor_fac
			"Cxx_ti_i_cor_fac"
			VALUE
			0x75930
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ti_i_cor_fac_lpg
			"Cxx_ti_i_cor_fac_lpg"
			VALUE
			0x75931
			DATA_RECORD_UBYTE
			255
			F_1_p0_9
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ti_ofs_vs_thd
			"Cxx_ti_ofs_vs_thd"
			VALUE
			0x75933
			DATA_RECORD_UBYTE
			255
			F_1_p0_58
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ti_ofs_vs_thd_lpg
			"Cxx_ti_ofs_vs_thd_lpg"
			VALUE
			0x75934
			DATA_RECORD_UBYTE
			255
			F_1_p0_58
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ti_p2_cor_fac
			"Cxx_ti_p2_cor_fac"
			VALUE
			0x75935
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ti_p_prs_thd
			"Cxx_ti_p_prs_thd"
			VALUE
			0x76F8A
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ti_p_prs_thd_lpg
			"Cxx_ti_p_prs_thd_lpg"
			VALUE
			0x76F8C
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tia_fac
			"Cxx_tia_fac"
			VALUE
			0x75936
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tia_iga_cor_prs
			"Cxx_tia_iga_cor_prs"
			VALUE
			0x71DDE
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tia_max_thr_adj
			"Cxx_tia_max_thr_adj"
			VALUE
			0x70D4C
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tia_min_thr_adj
			"Cxx_tia_min_thr_adj"
			VALUE
			0x70D4D
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tia_reprog_max
			"Cxx_tia_reprog_max"
			VALUE
			0x73203
			DATA_RECORD_UBYTE
			159.375
			F_0v625_p50_262
			50
			209.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tia_tco_fail_sta_tco
			"Cxx_tia_tco_fail_sta_tco"
			VALUE
			0x7B196
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tia_tco_fail_sta_tia
			"Cxx_tia_tco_fail_sta_tia"
			VALUE
			0x70D99
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tkof_ac_dsb_dly
			"Cxx_tkof_ac_dsb_dly"
			VALUE
			0x72174
			DATA_RECORD_UBYTE
			261.12
			F_1v024_p0_119
			0
			261.12
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tkof_ac_dsb_gear_thd
			"Cxx_tkof_ac_dsb_gear_thd"
			VALUE
			0x72175
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tkof_ac_dsb_h_thr_thd
			"Cxx_tkof_ac_dsb_h_thr_thd"
			VALUE
			0x721A2
			DATA_RECORD_UWORD
			3932.1
			F_0v06_p0_212
			0
			3932.1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tkof_ac_dsb_l_thr_thd
			"Cxx_tkof_ac_dsb_l_thr_thd"
			VALUE
			0x721A4
			DATA_RECORD_UWORD
			3932.1
			F_0v06_p0_212
			0
			3932.1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tkof_ac_dsb_n_hys
			"Cxx_tkof_ac_dsb_n_hys"
			VALUE
			0x72176
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tkof_ac_dsb_n_thd
			"Cxx_tkof_ac_dsb_n_thd"
			VALUE
			0x72177
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tkof_ac_dsb_pow_thd
			"Cxx_tkof_ac_dsb_pow_thd"
			VALUE
			0x72178
			DATA_RECORD_UBYTE
			5100
			F_20_p0_63
			0
			5100
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tkof_ac_dsb_vs_hys
			"Cxx_tkof_ac_dsb_vs_hys"
			VALUE
			0x72179
			DATA_RECORD_UBYTE
			255
			F_1_p0_58
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tkof_ac_dsb_vs_thd
			"Cxx_tkof_ac_dsb_vs_thd"
			VALUE
			0x7217A
			DATA_RECORD_UBYTE
			255
			F_1_p0_58
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tkof_ena_vs_thd
			"Cxx_tkof_ena_vs_thd"
			VALUE
			0x736A0
			DATA_RECORD_UWORD
			655.35
			F_0v01_p0_62
			0
			655.35
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tkof_fl_rich_fac
			"Cxx_tkof_fl_rich_fac"
			VALUE
			0x76F8E
			DATA_RECORD_UWORD
			170.664281
			F_0v00260417_p0v667_32
			0.667
			171.331281
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tkof_fl_rich_fac_lpg
			"Cxx_tkof_fl_rich_fac_lpg"
			VALUE
			0x76F90
			DATA_RECORD_UWORD
			170.664281
			F_0v00260417_p0v667_32
			0.667
			171.331281
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tkof_fl_tia_thd
			"Cxx_tkof_fl_tia_thd"
			VALUE
			0x73679
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tkof_gear_thd
			"Cxx_tkof_gear_thd"
			VALUE
			0x7367A
			DATA_RECORD_UBYTE
			255
			F_1_p0_9
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tkof_h_dyn_efy_cor
			"Cxx_tkof_h_dyn_efy_cor"
			VALUE
			0x74866
			DATA_RECORD_UWORD
			15999.7149
			F_0v24414_p0_263
			0
			15999.7149
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tkof_l_dyn_efy_cor
			"Cxx_tkof_l_dyn_efy_cor"
			VALUE
			0x74868
			DATA_RECORD_UWORD
			15999.7149
			F_0v24414_p0_263
			0
			15999.7149
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tkof_map_hys
			"Cxx_tkof_map_hys"
			VALUE
			0x736A2
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p0_21
			0
			242479.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tkof_map_thd
			"Cxx_tkof_map_thd"
			VALUE
			0x736A4
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tkof_mfld_mdl_fac
			"Cxx_tkof_mfld_mdl_fac"
			VALUE
			0x7367B
			DATA_RECORD_UBYTE
			7.96875
			F_0v03125_p0_91
			0
			7.96875
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tkof_n_dif_inrt_cge
			"Cxx_tkof_n_dif_inrt_cge"
			VALUE
			0x7367C
			DATA_RECORD_UBYTE
			8160
			F_32_p0_264
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tkof_n_h_thd
			"Cxx_tkof_n_h_thd"
			VALUE
			0x7367D
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tkof_n_hys
			"Cxx_tkof_n_hys"
			VALUE
			0x7367E
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tkof_n_l_thd
			"Cxx_tkof_n_l_thd"
			VALUE
			0x7367F
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tkof_n_thd
			"Cxx_tkof_n_thd"
			VALUE
			0x73680
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tkof_tq_d_max
			"Cxx_tkof_tq_d_max"
			VALUE
			0x790E4
			DATA_RECORD_SBYTE
			255
			F_1_p0_235
			-128
			127
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tkof_tq_d_min
			"Cxx_tkof_tq_d_min"
			VALUE
			0x790E5
			DATA_RECORD_SBYTE
			255
			F_1_p0_235
			-128
			127
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tkof_tq_p_max
			"Cxx_tkof_tq_p_max"
			VALUE
			0x790E6
			DATA_RECORD_SBYTE
			255
			F_1_p0_235
			-128
			127
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tkof_tq_p_min
			"Cxx_tkof_tq_p_min"
			VALUE
			0x790E7
			DATA_RECORD_SBYTE
			255
			F_1_p0_235
			-128
			127
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tkof_tq_vs_thd
			"Cxx_tkof_tq_vs_thd"
			VALUE
			0x73681
			DATA_RECORD_UBYTE
			255
			F_1_p0_58
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tkof_tqe_fil_fac_1
			"Cxx_tkof_tqe_fil_fac_1"
			VALUE
			0x736A6
			DATA_RECORD_UWORD
			0.999998565
			F_0v000015259_p0_216
			0
			0.999998565
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tkof_tqe_fil_fac_2
			"Cxx_tkof_tqe_fil_fac_2"
			VALUE
			0x736A8
			DATA_RECORD_UWORD
			0.999998565
			F_0v000015259_p0_216
			0
			0.999998565
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tkof_tqe_fil_fac_3
			"Cxx_tkof_tqe_fil_fac_3"
			VALUE
			0x736AA
			DATA_RECORD_UWORD
			0.999998565
			F_0v000015259_p0_216
			0
			0.999998565
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tkof_tqe_grd_fil_fac
			"Cxx_tkof_tqe_grd_fil_fac"
			VALUE
			0x73682
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tkof_vs_n_rat_thd
			"Cxx_tkof_vs_n_rat_thd"
			VALUE
			0x736AC
			DATA_RECORD_UWORD
			99.9998565
			F_0v0015259_p0_78
			0
			99.9998565
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tkof_vs_thd
			"Cxx_tkof_vs_thd"
			VALUE
			0x73683
			DATA_RECORD_UBYTE
			255
			F_1_p0_58
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tlz_a
			"Cxx_tlz_a"
			VALUE
			0x7314C
			DATA_RECORD_UWORD
			65535
			F_1_p0_9
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tlz_ad_b1_fil_ini
			"Cxx_tlz_ad_b1_fil_ini"
			VALUE
			0x73224
			DATA_RECORD_SWORD
			65535
			Id_0x00
			-32768
			32767
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tlz_ad_b2_fil_ini
			"Cxx_tlz_ad_b2_fil_ini"
			VALUE
			0x73226
			DATA_RECORD_SWORD
			65535
			Id_0x00
			-32768
			32767
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tlz_ad_b_fil_fac
			"Cxx_tlz_ad_b_fil_fac"
			VALUE
			0x7311F
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tlz_ad_b_max
			"Cxx_tlz_ad_b_max"
			VALUE
			0x73188
			DATA_RECORD_SLONG
			4294967295
			F_1_p0_9
			-2147483648
			2147483647
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tlz_ad_b_min
			"Cxx_tlz_ad_b_min"
			VALUE
			0x7318C
			DATA_RECORD_SLONG
			4294967295
			F_1_p0_9
			-2147483648
			2147483647
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tlz_ad_b_n_max
			"Cxx_tlz_ad_b_n_max"
			VALUE
			0x7314E
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tlz_ad_b_n_max_1
			"Cxx_tlz_ad_b_n_max_1"
			VALUE
			0x73150
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tlz_ad_b_n_max_2
			"Cxx_tlz_ad_b_n_max_2"
			VALUE
			0x73152
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tlz_ad_b_n_max_3
			"Cxx_tlz_ad_b_n_max_3"
			VALUE
			0x73154
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tlz_ad_b_n_max_4
			"Cxx_tlz_ad_b_n_max_4"
			VALUE
			0x73156
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tlz_ad_b_n_max_5
			"Cxx_tlz_ad_b_n_max_5"
			VALUE
			0x73158
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tlz_ad_b_n_max_6
			"Cxx_tlz_ad_b_n_max_6"
			VALUE
			0x7315A
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tlz_ad_b_n_min
			"Cxx_tlz_ad_b_n_min"
			VALUE
			0x7315C
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tlz_ad_b_n_min_1
			"Cxx_tlz_ad_b_n_min_1"
			VALUE
			0x7315E
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tlz_ad_b_n_min_2
			"Cxx_tlz_ad_b_n_min_2"
			VALUE
			0x73160
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tlz_ad_b_n_min_3
			"Cxx_tlz_ad_b_n_min_3"
			VALUE
			0x73162
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tlz_ad_b_n_min_4
			"Cxx_tlz_ad_b_n_min_4"
			VALUE
			0x73164
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tlz_ad_b_n_min_5
			"Cxx_tlz_ad_b_n_min_5"
			VALUE
			0x73166
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tlz_ad_b_n_min_6
			"Cxx_tlz_ad_b_n_min_6"
			VALUE
			0x73168
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tlz_ad_b_nr_tdc
			"Cxx_tlz_ad_b_nr_tdc"
			VALUE
			0x7316A
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tlz_ad_b_slow_nr_tdc
			"Cxx_tlz_ad_b_slow_nr_tdc"
			VALUE
			0x73120
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tlz_ad_cor_fil_fac
			"Cxx_tlz_ad_cor_fil_fac"
			VALUE
			0x73121
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tlz_ad_cor_fil_ini
			"Cxx_tlz_ad_cor_fil_ini"
			VALUE
			0x73228
			DATA_RECORD_SWORD
			65535
			Id_0x00
			-32768
			32767
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tlz_ad_cor_n_max
			"Cxx_tlz_ad_cor_n_max"
			VALUE
			0x7316C
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tlz_ad_cor_n_min
			"Cxx_tlz_ad_cor_n_min"
			VALUE
			0x7316E
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tlz_ad_cor_nr_tdc
			"Cxx_tlz_ad_cor_nr_tdc"
			VALUE
			0x73170
			DATA_RECORD_UWORD
			65535
			F_1_p0_53
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tlz_ad_cor_val_ini
			"Cxx_tlz_ad_cor_val_ini"
			VALUE
			0x7322A
			DATA_RECORD_SWORD
			65535
			Id_0x00
			-32768
			32767
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tlz_b_ini
			"Cxx_tlz_b_ini"
			VALUE
			0x73124
			DATA_RECORD_SWORD
			65535
			Id_0x00
			-32768
			32767
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tlz_cor_n_max
			"Cxx_tlz_cor_n_max"
			VALUE
			0x73172
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tlz_fil_rat
			"Cxx_tlz_fil_rat"
			VALUE
			0x7773B
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tlz_fil_rat_lpg
			"Cxx_tlz_fil_rat_lpg"
			VALUE
			0x7773C
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tlz_fil_rst_n_dif_thd
			"Cxx_tlz_fil_rst_n_dif_thd"
			VALUE
			0x78378
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tlz_n_max
			"Cxx_tlz_n_max"
			VALUE
			0x73174
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tlz_n_min
			"Cxx_tlz_n_min"
			VALUE
			0x73176
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tmp_ac_cor_dec_dly
			"Cxx_tmp_ac_cor_dec_dly"
			VALUE
			0x73ACD
			DATA_RECORD_UBYTE
			4080
			F_16_p0_10
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tmp_ac_is_cor_dec
			"Cxx_tmp_ac_is_cor_dec"
			VALUE
			0x73ACE
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tmp_cut_map_thd
			"Cxx_tmp_cut_map_thd"
			VALUE
			0x76F92
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tmp_cut_map_thd_lpg
			"Cxx_tmp_cut_map_thd_lpg"
			VALUE
			0x76F94
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tmp_mdf1_is_cor
			"Cxx_tmp_mdf1_is_cor"
			VALUE
			0x73ACF
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tmp_mdf2_is_cor
			"Cxx_tmp_mdf2_is_cor"
			VALUE
			0x73AD0
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_toil_bch_mod
			"Cxx_toil_bch_mod"
			VALUE
			0x7701A
			DATA_RECORD_UWORD
			40959.375
			F_0v625_m40_25
			-40
			40919.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_toil_is_n_ofs
			"Cxx_toil_is_n_ofs"
			VALUE
			0x78BB6
			DATA_RECORD_UBYTE
			4080
			F_16_p0_83
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_toil_tco_cnt
			"Cxx_toil_tco_cnt"
			VALUE
			0x76FF0
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tq_rat_fil_fac_ovn
			"Cxx_tq_rat_fil_fac_ovn"
			VALUE
			0x7952B
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tq_stab_thd
			"Cxx_tq_stab_thd"
			VALUE
			0x7ADEB
			DATA_RECORD_UBYTE
			510
			F_2_p0_198
			0
			510
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tqe
			"Cxx_tqe"
			VALUE
			0x7952C
			DATA_RECORD_UBYTE
			15.9375
			F_0v0625_p0_84
			0
			15.9375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tqr_clu_ac_ofs
			"Cxx_tqr_clu_ac_ofs"
			VALUE
			0x71D01
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tqr_ct_thd_prs
			"Cxx_tqr_ct_thd_prs"
			VALUE
			0x71DE0
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tqr_ct_thd_prs_lpg
			"Cxx_tqr_ct_thd_prs_lpg"
			VALUE
			0x71DE2
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tqr_max
			"Cxx_tqr_max"
			VALUE
			0x71D02
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tqr_max_gear1
			"Cxx_tqr_max_gear1"
			VALUE
			0x71D03
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tqr_max_gear1_lpg
			"Cxx_tqr_max_gear1_lpg"
			VALUE
			0x71D04
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tqr_max_lpg
			"Cxx_tqr_max_lpg"
			VALUE
			0x71D05
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tqr_nr_tdc
			"Cxx_tqr_nr_tdc"
			VALUE
			0x71D06
			DATA_RECORD_UBYTE
			255
			F_1_p0_53
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tqr_nr_tdc_gear1
			"Cxx_tqr_nr_tdc_gear1"
			VALUE
			0x71D07
			DATA_RECORD_UBYTE
			255
			F_1_p0_53
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tqr_rtn_nr_tdc
			"Cxx_tqr_rtn_nr_tdc"
			VALUE
			0x71D08
			DATA_RECORD_UBYTE
			255
			F_1_p0_53
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tqr_rtn_nr_tdc_gear1
			"Cxx_tqr_rtn_nr_tdc_gear1"
			VALUE
			0x71D09
			DATA_RECORD_UBYTE
			255
			F_1_p0_53
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tqr_rtn_nr_tdc_gear2
			"Cxx_tqr_rtn_nr_tdc_gear2"
			VALUE
			0x71D0A
			DATA_RECORD_UBYTE
			255
			F_1_p0_53
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tqr_rtn_nr_tdc_lpg
			"Cxx_tqr_rtn_nr_tdc_lpg"
			VALUE
			0x71D0B
			DATA_RECORD_UBYTE
			255
			F_1_p0_53
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tqr_step_dec
			"Cxx_tqr_step_dec"
			VALUE
			0x71D0C
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tqr_step_dec_gear1
			"Cxx_tqr_step_dec_gear1"
			VALUE
			0x71D0D
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tqr_swi_nr_tdc
			"Cxx_tqr_swi_nr_tdc"
			VALUE
			0x71D0E
			DATA_RECORD_UBYTE
			255
			F_1_p0_53
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tqr_swi_rtn_nr_tdc
			"Cxx_tqr_swi_rtn_nr_tdc"
			VALUE
			0x71D0F
			DATA_RECORD_UBYTE
			255
			F_1_p0_53
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tqr_swi_rtn_nr_tdc1
			"Cxx_tqr_swi_rtn_nr_tdc1"
			VALUE
			0x71D10
			DATA_RECORD_UBYTE
			255
			F_1_p0_53
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_tqr_swi_step_inc
			"Cxx_tqr_swi_step_inc"
			VALUE
			0x71D11
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_265
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_trs_thd
			"Cxx_trs_thd"
			VALUE
			0x783B6
			DATA_RECORD_UBYTE
			2488.8
			F_9v76_p0_45
			0
			2488.8
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_trs_thd_lpg
			"Cxx_trs_thd_lpg"
			VALUE
			0x783B7
			DATA_RECORD_UBYTE
			2488.8
			F_9v76_p0_45
			0
			2488.8
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_trt_cl_sp
			"Cxx_trt_cl_sp"
			VALUE
			0x733A8
			DATA_RECORD_UWORD
			3199.951172
			F_0v048828125_p0_199
			0
			3199.951172
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_trt_clos_frst_srch_sp
			"Cxx_trt_clos_frst_srch_sp"
			VALUE
			0x733AA
			DATA_RECORD_UWORD
			3199.951172
			F_0v048828125_p0_199
			0
			3199.951172
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_trt_high_frst_srch_sp
			"Cxx_trt_high_frst_srch_sp"
			VALUE
			0x733AC
			DATA_RECORD_UWORD
			3199.951172
			F_0v048828125_p0_199
			0
			3199.951172
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_trt_inv_dsb
			"Cxx_trt_inv_dsb"
			VALUE
			0x73652
			DATA_RECORD_UWORD
			2867.8116
			F_0v04376_p0_180
			0
			2867.8116
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_trt_lh_thd
			"Cxx_trt_lh_thd"
			VALUE
			0x733AE
			DATA_RECORD_UWORD
			6399.902344
			F_0v09765625_p0_71
			0
			6399.902344
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_trt_op_sp
			"Cxx_trt_op_sp"
			VALUE
			0x733B0
			DATA_RECORD_UWORD
			3199.951172
			F_0v048828125_p0_199
			0
			3199.951172
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_trt_thd
			"Cxx_trt_thd"
			VALUE
			0x733B2
			DATA_RECORD_UWORD
			6399.902344
			F_0v09765625_p0_71
			0
			6399.902344
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_trz_a
			"Cxx_trz_a"
			VALUE
			0x73178
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_trz_ad_b1_fil_ini
			"Cxx_trz_ad_b1_fil_ini"
			VALUE
			0x73230
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_trz_ad_b1_val_ini
			"Cxx_trz_ad_b1_val_ini"
			VALUE
			0x73232
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_trz_ad_b2_fil_ini
			"Cxx_trz_ad_b2_fil_ini"
			VALUE
			0x73234
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_trz_ad_b2_val_ini
			"Cxx_trz_ad_b2_val_ini"
			VALUE
			0x73236
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_trz_ad_b_fil_fac
			"Cxx_trz_ad_b_fil_fac"
			VALUE
			0x73122
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_trz_ad_b_grd_prs
			"Cxx_trz_ad_b_grd_prs"
			VALUE
			0x73123
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_trz_ad_b_n_max
			"Cxx_trz_ad_b_n_max"
			VALUE
			0x7317A
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_trz_ad_b_n_min
			"Cxx_trz_ad_b_n_min"
			VALUE
			0x7317C
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_trz_ad_b_nr_tdc
			"Cxx_trz_ad_b_nr_tdc"
			VALUE
			0x7317E
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_trz_b_ini
			"Cxx_trz_b_ini"
			VALUE
			0x736E0
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_trz_cor_n_max
			"Cxx_trz_cor_n_max"
			VALUE
			0x73180
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_trz_n_max
			"Cxx_trz_n_max"
			VALUE
			0x73182
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_trz_n_min
			"Cxx_trz_n_min"
			VALUE
			0x73184
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_typ_lpg_thd1
			"Cxx_typ_lpg_thd1"
			VALUE
			0x71EF3
			DATA_RECORD_UBYTE
			99.999984
			F_0v3921568_p0_266
			0
			99.999984
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_typ_lpg_thd2
			"Cxx_typ_lpg_thd2"
			VALUE
			0x71EF4
			DATA_RECORD_UBYTE
			99.999984
			F_0v3921568_p0_266
			0
			99.999984
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_up_v_lamb_thd
			"Cxx_up_v_lamb_thd"
			VALUE
			0x75937
			DATA_RECORD_UBYTE
			2488.8
			F_9v76_p0_45
			0
			2488.8
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_v1_max_thd_vld
			"Cxx_v1_max_thd_vld"
			VALUE
			0x733B4
			DATA_RECORD_UWORD
			6399.49275
			F_0v09765_p0_3
			0
			6399.49275
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_v1_min_thd_vld
			"Cxx_v1_min_thd_vld"
			VALUE
			0x733B6
			DATA_RECORD_UWORD
			6399.49275
			F_0v09765_p0_3
			0
			6399.49275
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_v2_max_thd_vld
			"Cxx_v2_max_thd_vld"
			VALUE
			0x733B8
			DATA_RECORD_UWORD
			6399.49275
			F_0v09765_p0_3
			0
			6399.49275
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_v2_min_thd_vld
			"Cxx_v2_min_thd_vld"
			VALUE
			0x733BA
			DATA_RECORD_UWORD
			6399.49275
			F_0v09765_p0_3
			0
			6399.49275
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vb_dft_val
			"Cxx_vb_dft_val"
			VALUE
			0x71DEB
			DATA_RECORD_UBYTE
			7.96875
			F_0v03125_p8_183
			8
			15.96875
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vers_nr1
			"Cxx_vers_nr1"
			VALUE
			0x73214
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vers_nr2
			"Cxx_vers_nr2"
			VALUE
			0x73215
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_agb_rcpt
			"Cxx_vfnrofm_agb_rcpt"
			VALUE
			0x70C31
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_air
			"Cxx_vfnrofm_air"
			VALUE
			0x70C32
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_bkup_mem
			"Cxx_vfnrofm_bkup_mem"
			VALUE
			0x70C33
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_clu
			"Cxx_vfnrofm_clu"
			VALUE
			0x70C34
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_cp
			"Cxx_vfnrofm_cp"
			VALUE
			0x70C1A
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_crk
			"Cxx_vfnrofm_crk"
			VALUE
			0x70C35
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_crk_nr
			"Cxx_vfnrofm_crk_nr"
			VALUE
			0x70C36
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_eng_whl
			"Cxx_vfnrofm_eng_whl"
			VALUE
			0x70C37
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_fsys
			"Cxx_vfnrofm_fsys"
			VALUE
			0x70C38
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_fsys_lpg
			"Cxx_vfnrofm_fsys_lpg"
			VALUE
			0x70C39
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_gas_pump
			"Cxx_vfnrofm_gas_pump"
			VALUE
			0x70C1B
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_igc_1
			"Cxx_vfnrofm_igc_1"
			VALUE
			0x70C1C
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_igc_2
			"Cxx_vfnrofm_igc_2"
			VALUE
			0x70C1D
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_igc_3
			"Cxx_vfnrofm_igc_3"
			VALUE
			0x70C1E
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_igc_4
			"Cxx_vfnrofm_igc_4"
			VALUE
			0x70C1F
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_inj1
			"Cxx_vfnrofm_inj1"
			VALUE
			0x70C20
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_inj2
			"Cxx_vfnrofm_inj2"
			VALUE
			0x70C21
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_inj3
			"Cxx_vfnrofm_inj3"
			VALUE
			0x70C22
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_inj4
			"Cxx_vfnrofm_inj4"
			VALUE
			0x70C23
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_inj_ecu
			"Cxx_vfnrofm_inj_ecu"
			VALUE
			0x70C3A
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_knk
			"Cxx_vfnrofm_knk"
			VALUE
			0x70C3B
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_lbdw
			"Cxx_vfnrofm_lbdw"
			VALUE
			0x70C24
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_lbdw_hot
			"Cxx_vfnrofm_lbdw_hot"
			VALUE
			0x70C25
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_lbup
			"Cxx_vfnrofm_lbup"
			VALUE
			0x70C26
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_lbup_hot
			"Cxx_vfnrofm_lbup_hot"
			VALUE
			0x70C27
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_lpg_rcpt
			"Cxx_vfnrofm_lpg_rcpt"
			VALUE
			0x70C3C
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_map
			"Cxx_vfnrofm_map"
			VALUE
			0x70C3D
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_min_gas_lvl
			"Cxx_vfnrofm_min_gas_lvl"
			VALUE
			0x70C3E
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_mis_cata
			"Cxx_vfnrofm_mis_cata"
			VALUE
			0x70C3F
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_mis_cata_1
			"Cxx_vfnrofm_mis_cata_1"
			VALUE
			0x70C40
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_mis_cata_1_lpg
			"Cxx_vfnrofm_mis_cata_1_lpg"
			VALUE
			0x70C41
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_mis_cata_2
			"Cxx_vfnrofm_mis_cata_2"
			VALUE
			0x70C42
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_mis_cata_2_lpg
			"Cxx_vfnrofm_mis_cata_2_lpg"
			VALUE
			0x70C43
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_mis_cata_3
			"Cxx_vfnrofm_mis_cata_3"
			VALUE
			0x70C44
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_mis_cata_3_lpg
			"Cxx_vfnrofm_mis_cata_3_lpg"
			VALUE
			0x70C45
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_mis_cata_4
			"Cxx_vfnrofm_mis_cata_4"
			VALUE
			0x70C46
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_mis_cata_4_lpg
			"Cxx_vfnrofm_mis_cata_4_lpg"
			VALUE
			0x70C47
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_mis_cata_gas
			"Cxx_vfnrofm_mis_cata_gas"
			VALUE
			0x70C48
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_mis_cata_lpg
			"Cxx_vfnrofm_mis_cata_lpg"
			VALUE
			0x70C49
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_mis_polu
			"Cxx_vfnrofm_mis_polu"
			VALUE
			0x70C4A
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_mis_polu_1
			"Cxx_vfnrofm_mis_polu_1"
			VALUE
			0x70C4B
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_mis_polu_1_lpg
			"Cxx_vfnrofm_mis_polu_1_lpg"
			VALUE
			0x70C4C
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_mis_polu_2
			"Cxx_vfnrofm_mis_polu_2"
			VALUE
			0x70C4D
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_mis_polu_2_lpg
			"Cxx_vfnrofm_mis_polu_2_lpg"
			VALUE
			0x70C4E
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_mis_polu_3
			"Cxx_vfnrofm_mis_polu_3"
			VALUE
			0x70C4F
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_mis_polu_3_lpg
			"Cxx_vfnrofm_mis_polu_3_lpg"
			VALUE
			0x70C50
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_mis_polu_4
			"Cxx_vfnrofm_mis_polu_4"
			VALUE
			0x70C51
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_mis_polu_4_lpg
			"Cxx_vfnrofm_mis_polu_4_lpg"
			VALUE
			0x70C52
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_mis_polu_gas
			"Cxx_vfnrofm_mis_polu_gas"
			VALUE
			0x70C53
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_mis_polu_lpg
			"Cxx_vfnrofm_mis_polu_lpg"
			VALUE
			0x70C54
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_obd_cata
			"Cxx_vfnrofm_obd_cata"
			VALUE
			0x70C55
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_obd_lamb
			"Cxx_vfnrofm_obd_lamb"
			VALUE
			0x70C56
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_obd_sa
			"Cxx_vfnrofm_obd_sa"
			VALUE
			0x70C57
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_pow_lbdw
			"Cxx_vfnrofm_pow_lbdw"
			VALUE
			0x70C58
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_pow_lbup
			"Cxx_vfnrofm_pow_lbup"
			VALUE
			0x70C59
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_rams_pdl
			"Cxx_vfnrofm_rams_pdl"
			VALUE
			0x70C5A
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_sa
			"Cxx_vfnrofm_sa"
			VALUE
			0x70C28
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_sa_ev
			"Cxx_vfnrofm_sa_ev"
			VALUE
			0x70C29
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_spg
			"Cxx_vfnrofm_spg"
			VALUE
			0x70C5B
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_spg_sys
			"Cxx_vfnrofm_spg_sys"
			VALUE
			0x70C5C
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_tco
			"Cxx_vfnrofm_tco"
			VALUE
			0x70C2A
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_tia
			"Cxx_vfnrofm_tia"
			VALUE
			0x70C2B
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_tlz_ad_b
			"Cxx_vfnrofm_tlz_ad_b"
			VALUE
			0x70C5D
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_vs
			"Cxx_vfnrofm_vs"
			VALUE
			0x70C2C
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_vta_intake
			"Cxx_vfnrofm_vta_intake"
			VALUE
			0x70C2D
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_vvt_int_ev
			"Cxx_vfnrofm_vvt_int_ev"
			VALUE
			0x70C2E
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_vvt_int_old_off
			"Cxx_vfnrofm_vvt_int_old_off"
			VALUE
			0x70C5E
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_vvt_intake
			"Cxx_vfnrofm_vvt_intake"
			VALUE
			0x70C2F
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_vvtc_toth_3
			"Cxx_vfnrofm_vvtc_toth_3"
			VALUE
			0x70C5F
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrofm_wgc
			"Cxx_vfnrofm_wgc"
			VALUE
			0x70C30
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_agb_rcpt
			"Cxx_vfnronm_agb_rcpt"
			VALUE
			0x70BEB
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_air
			"Cxx_vfnronm_air"
			VALUE
			0x70BEC
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_bkup_mem
			"Cxx_vfnronm_bkup_mem"
			VALUE
			0x70BED
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_clu
			"Cxx_vfnronm_clu"
			VALUE
			0x70BEE
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_cp
			"Cxx_vfnronm_cp"
			VALUE
			0x70BD4
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_crk
			"Cxx_vfnronm_crk"
			VALUE
			0x70BEF
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_crk_nr
			"Cxx_vfnronm_crk_nr"
			VALUE
			0x70BF0
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_eng_whl
			"Cxx_vfnronm_eng_whl"
			VALUE
			0x70BF1
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_fsys
			"Cxx_vfnronm_fsys"
			VALUE
			0x70BF2
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_fsys_lpg
			"Cxx_vfnronm_fsys_lpg"
			VALUE
			0x70BF3
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_gas_pump
			"Cxx_vfnronm_gas_pump"
			VALUE
			0x70BD5
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_igc_1
			"Cxx_vfnronm_igc_1"
			VALUE
			0x70BD6
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_igc_2
			"Cxx_vfnronm_igc_2"
			VALUE
			0x70BD7
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_igc_3
			"Cxx_vfnronm_igc_3"
			VALUE
			0x70BD8
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_igc_4
			"Cxx_vfnronm_igc_4"
			VALUE
			0x70BD9
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_inj1
			"Cxx_vfnronm_inj1"
			VALUE
			0x70BDA
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_inj2
			"Cxx_vfnronm_inj2"
			VALUE
			0x70BDB
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_inj3
			"Cxx_vfnronm_inj3"
			VALUE
			0x70BDC
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_inj4
			"Cxx_vfnronm_inj4"
			VALUE
			0x70BDD
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_inj_ecu
			"Cxx_vfnronm_inj_ecu"
			VALUE
			0x70BF4
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_knk
			"Cxx_vfnronm_knk"
			VALUE
			0x70BF5
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_lbdw
			"Cxx_vfnronm_lbdw"
			VALUE
			0x70BDE
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_lbdw_hot
			"Cxx_vfnronm_lbdw_hot"
			VALUE
			0x70BDF
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_lbup
			"Cxx_vfnronm_lbup"
			VALUE
			0x70BE0
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_lbup_hot
			"Cxx_vfnronm_lbup_hot"
			VALUE
			0x70BE1
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_lpg_rcpt
			"Cxx_vfnronm_lpg_rcpt"
			VALUE
			0x70BF6
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_map
			"Cxx_vfnronm_map"
			VALUE
			0x70BF7
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_min_gas_lvl
			"Cxx_vfnronm_min_gas_lvl"
			VALUE
			0x70BF8
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_mis_cata
			"Cxx_vfnronm_mis_cata"
			VALUE
			0x70BF9
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_mis_cata_1
			"Cxx_vfnronm_mis_cata_1"
			VALUE
			0x70BFA
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_mis_cata_1_lpg
			"Cxx_vfnronm_mis_cata_1_lpg"
			VALUE
			0x70BFB
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_mis_cata_2
			"Cxx_vfnronm_mis_cata_2"
			VALUE
			0x70BFC
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_mis_cata_2_lpg
			"Cxx_vfnronm_mis_cata_2_lpg"
			VALUE
			0x70BFD
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_mis_cata_3
			"Cxx_vfnronm_mis_cata_3"
			VALUE
			0x70BFE
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_mis_cata_3_lpg
			"Cxx_vfnronm_mis_cata_3_lpg"
			VALUE
			0x70BFF
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_mis_cata_4
			"Cxx_vfnronm_mis_cata_4"
			VALUE
			0x70C00
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_mis_cata_4_lpg
			"Cxx_vfnronm_mis_cata_4_lpg"
			VALUE
			0x70C01
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_mis_cata_gas
			"Cxx_vfnronm_mis_cata_gas"
			VALUE
			0x70C02
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_mis_cata_lpg
			"Cxx_vfnronm_mis_cata_lpg"
			VALUE
			0x70C03
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_mis_polu
			"Cxx_vfnronm_mis_polu"
			VALUE
			0x70C04
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_mis_polu_1
			"Cxx_vfnronm_mis_polu_1"
			VALUE
			0x70C05
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_mis_polu_1_lpg
			"Cxx_vfnronm_mis_polu_1_lpg"
			VALUE
			0x70C06
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_mis_polu_2
			"Cxx_vfnronm_mis_polu_2"
			VALUE
			0x70C07
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_mis_polu_2_lpg
			"Cxx_vfnronm_mis_polu_2_lpg"
			VALUE
			0x70C08
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_mis_polu_3
			"Cxx_vfnronm_mis_polu_3"
			VALUE
			0x70C09
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_mis_polu_3_lpg
			"Cxx_vfnronm_mis_polu_3_lpg"
			VALUE
			0x70C0A
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_mis_polu_4
			"Cxx_vfnronm_mis_polu_4"
			VALUE
			0x70C0B
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_mis_polu_4_lpg
			"Cxx_vfnronm_mis_polu_4_lpg"
			VALUE
			0x70C0C
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_mis_polu_gas
			"Cxx_vfnronm_mis_polu_gas"
			VALUE
			0x70C0D
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_mis_polu_lpg
			"Cxx_vfnronm_mis_polu_lpg"
			VALUE
			0x70C0E
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_obd_cata
			"Cxx_vfnronm_obd_cata"
			VALUE
			0x70C0F
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_obd_lamb
			"Cxx_vfnronm_obd_lamb"
			VALUE
			0x70C10
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_obd_sa
			"Cxx_vfnronm_obd_sa"
			VALUE
			0x70C11
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_pow_lbdw
			"Cxx_vfnronm_pow_lbdw"
			VALUE
			0x70C12
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_pow_lbup
			"Cxx_vfnronm_pow_lbup"
			VALUE
			0x70C13
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_rams_pdl
			"Cxx_vfnronm_rams_pdl"
			VALUE
			0x70C14
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_sa
			"Cxx_vfnronm_sa"
			VALUE
			0x70BE2
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_sa_ev
			"Cxx_vfnronm_sa_ev"
			VALUE
			0x70BE3
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_spg
			"Cxx_vfnronm_spg"
			VALUE
			0x70C15
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_spg_sys
			"Cxx_vfnronm_spg_sys"
			VALUE
			0x70C16
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_tco
			"Cxx_vfnronm_tco"
			VALUE
			0x70BE4
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_tia
			"Cxx_vfnronm_tia"
			VALUE
			0x70BE5
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_tlz_ad_b
			"Cxx_vfnronm_tlz_ad_b"
			VALUE
			0x70C17
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_vs
			"Cxx_vfnronm_vs"
			VALUE
			0x70BE6
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_vta_intake
			"Cxx_vfnronm_vta_intake"
			VALUE
			0x70BE7
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_vvt_int_ev
			"Cxx_vfnronm_vvt_int_ev"
			VALUE
			0x70BE8
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_vvt_int_old_off
			"Cxx_vfnronm_vvt_int_old_off"
			VALUE
			0x70C18
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_vvt_intake
			"Cxx_vfnronm_vvt_intake"
			VALUE
			0x70BE9
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_vvtc_toth_3
			"Cxx_vfnronm_vvtc_toth_3"
			VALUE
			0x70C19
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnronm_wgc
			"Cxx_vfnronm_wgc"
			VALUE
			0x70BEA
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_agb_rcpt
			"Cxx_vfnrw_agb_rcpt"
			VALUE
			0x70C77
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_air
			"Cxx_vfnrw_air"
			VALUE
			0x70C78
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_bkup_mem
			"Cxx_vfnrw_bkup_mem"
			VALUE
			0x70C79
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_clu
			"Cxx_vfnrw_clu"
			VALUE
			0x70C7A
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_cp
			"Cxx_vfnrw_cp"
			VALUE
			0x70C60
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_crk
			"Cxx_vfnrw_crk"
			VALUE
			0x70C7B
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_crk_nr
			"Cxx_vfnrw_crk_nr"
			VALUE
			0x70C7C
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_eng_whl
			"Cxx_vfnrw_eng_whl"
			VALUE
			0x70C7D
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_fsys
			"Cxx_vfnrw_fsys"
			VALUE
			0x70C7E
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_fsys_lpg
			"Cxx_vfnrw_fsys_lpg"
			VALUE
			0x70C7F
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_gas_pump
			"Cxx_vfnrw_gas_pump"
			VALUE
			0x70C61
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_igc_1
			"Cxx_vfnrw_igc_1"
			VALUE
			0x70C62
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_igc_2
			"Cxx_vfnrw_igc_2"
			VALUE
			0x70C63
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_igc_3
			"Cxx_vfnrw_igc_3"
			VALUE
			0x70C64
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_igc_4
			"Cxx_vfnrw_igc_4"
			VALUE
			0x70C65
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_inj1
			"Cxx_vfnrw_inj1"
			VALUE
			0x70C66
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_inj2
			"Cxx_vfnrw_inj2"
			VALUE
			0x70C67
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_inj3
			"Cxx_vfnrw_inj3"
			VALUE
			0x70C68
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_inj4
			"Cxx_vfnrw_inj4"
			VALUE
			0x70C69
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_inj_ecu
			"Cxx_vfnrw_inj_ecu"
			VALUE
			0x70C80
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_knk
			"Cxx_vfnrw_knk"
			VALUE
			0x70C81
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_lbdw
			"Cxx_vfnrw_lbdw"
			VALUE
			0x70C6A
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_lbdw_hot
			"Cxx_vfnrw_lbdw_hot"
			VALUE
			0x70C6B
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_lbup
			"Cxx_vfnrw_lbup"
			VALUE
			0x70C6C
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_lbup_hot
			"Cxx_vfnrw_lbup_hot"
			VALUE
			0x70C6D
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_lpg_rcpt
			"Cxx_vfnrw_lpg_rcpt"
			VALUE
			0x70C82
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_map
			"Cxx_vfnrw_map"
			VALUE
			0x70C83
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_min_gas_lvl
			"Cxx_vfnrw_min_gas_lvl"
			VALUE
			0x70C84
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_mis_cata
			"Cxx_vfnrw_mis_cata"
			VALUE
			0x70C85
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_mis_cata_1
			"Cxx_vfnrw_mis_cata_1"
			VALUE
			0x70C86
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_mis_cata_1_lpg
			"Cxx_vfnrw_mis_cata_1_lpg"
			VALUE
			0x70C87
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_mis_cata_2
			"Cxx_vfnrw_mis_cata_2"
			VALUE
			0x70C88
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_mis_cata_2_lpg
			"Cxx_vfnrw_mis_cata_2_lpg"
			VALUE
			0x70C89
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_mis_cata_3
			"Cxx_vfnrw_mis_cata_3"
			VALUE
			0x70C8A
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_mis_cata_3_lpg
			"Cxx_vfnrw_mis_cata_3_lpg"
			VALUE
			0x70C8B
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_mis_cata_4
			"Cxx_vfnrw_mis_cata_4"
			VALUE
			0x70C8C
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_mis_cata_4_lpg
			"Cxx_vfnrw_mis_cata_4_lpg"
			VALUE
			0x70C8D
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_mis_cata_gas
			"Cxx_vfnrw_mis_cata_gas"
			VALUE
			0x70C8E
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_mis_cata_lpg
			"Cxx_vfnrw_mis_cata_lpg"
			VALUE
			0x70C8F
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_mis_polu
			"Cxx_vfnrw_mis_polu"
			VALUE
			0x70C90
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_mis_polu_1
			"Cxx_vfnrw_mis_polu_1"
			VALUE
			0x70C91
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_mis_polu_1_lpg
			"Cxx_vfnrw_mis_polu_1_lpg"
			VALUE
			0x70C92
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_mis_polu_2
			"Cxx_vfnrw_mis_polu_2"
			VALUE
			0x70C93
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_mis_polu_2_lpg
			"Cxx_vfnrw_mis_polu_2_lpg"
			VALUE
			0x70C94
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_mis_polu_3
			"Cxx_vfnrw_mis_polu_3"
			VALUE
			0x70C95
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_mis_polu_3_lpg
			"Cxx_vfnrw_mis_polu_3_lpg"
			VALUE
			0x70C96
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_mis_polu_4
			"Cxx_vfnrw_mis_polu_4"
			VALUE
			0x70C97
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_mis_polu_4_lpg
			"Cxx_vfnrw_mis_polu_4_lpg"
			VALUE
			0x70C98
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_mis_polu_gas
			"Cxx_vfnrw_mis_polu_gas"
			VALUE
			0x70C99
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_mis_polu_lpg
			"Cxx_vfnrw_mis_polu_lpg"
			VALUE
			0x70C9A
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_obd_cata
			"Cxx_vfnrw_obd_cata"
			VALUE
			0x70C9B
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_obd_lamb
			"Cxx_vfnrw_obd_lamb"
			VALUE
			0x70C9C
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_obd_sa
			"Cxx_vfnrw_obd_sa"
			VALUE
			0x70C9D
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_pow_lbdw
			"Cxx_vfnrw_pow_lbdw"
			VALUE
			0x70C9E
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_pow_lbup
			"Cxx_vfnrw_pow_lbup"
			VALUE
			0x70C9F
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_rams_pdl
			"Cxx_vfnrw_rams_pdl"
			VALUE
			0x70CA0
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_sa
			"Cxx_vfnrw_sa"
			VALUE
			0x70C6E
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_sa_ev
			"Cxx_vfnrw_sa_ev"
			VALUE
			0x70C6F
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_spg
			"Cxx_vfnrw_spg"
			VALUE
			0x70CA1
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_spg_sys
			"Cxx_vfnrw_spg_sys"
			VALUE
			0x70CA2
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_tco
			"Cxx_vfnrw_tco"
			VALUE
			0x70C70
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_tia
			"Cxx_vfnrw_tia"
			VALUE
			0x70C71
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_tlz_ad_b
			"Cxx_vfnrw_tlz_ad_b"
			VALUE
			0x70CA3
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_vs
			"Cxx_vfnrw_vs"
			VALUE
			0x70C72
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_vta_intake
			"Cxx_vfnrw_vta_intake"
			VALUE
			0x70C73
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_vvt_int_ev
			"Cxx_vfnrw_vvt_int_ev"
			VALUE
			0x70C74
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_vvt_int_old_off
			"Cxx_vfnrw_vvt_int_old_off"
			VALUE
			0x70CA4
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_vvt_intake
			"Cxx_vfnrw_vvt_intake"
			VALUE
			0x70C75
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_vvtc_toth_3
			"Cxx_vfnrw_vvtc_toth_3"
			VALUE
			0x70CA5
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vfnrw_wgc
			"Cxx_vfnrw_wgc"
			VALUE
			0x70C76
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vh_run_ini_is_i_ofs
			"Cxx_vh_run_ini_is_i_ofs"
			VALUE
			0x73C12
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vh_run_max_is_i_ofs
			"Cxx_vh_run_max_is_i_ofs"
			VALUE
			0x73C14
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vh_run_min_is_i_ofs
			"Cxx_vh_run_min_is_i_ofs"
			VALUE
			0x73AE4
			DATA_RECORD_SWORD
			65535
			Id_0x00
			-32768
			32767
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vh_run_pwst_is_cor2
			"Cxx_vh_run_pwst_is_cor2"
			VALUE
			0x73AD1
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vh_run_pwst_is_cor3
			"Cxx_vh_run_pwst_is_cor3"
			VALUE
			0x73AD2
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vh_run_tmp_pwst_cor
			"Cxx_vh_run_tmp_pwst_cor"
			VALUE
			0x73AD3
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vh_stop_ini_is_i_ofs
			"Cxx_vh_stop_ini_is_i_ofs"
			VALUE
			0x73C16
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vh_stop_pwst_is_cor2
			"Cxx_vh_stop_pwst_is_cor2"
			VALUE
			0x73AD4
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vh_stop_pwst_is_cor3
			"Cxx_vh_stop_pwst_is_cor3"
			VALUE
			0x73AD5
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vh_stop_tmp_pwst_cor
			"Cxx_vh_stop_tmp_pwst_cor"
			VALUE
			0x73AD6
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vh_wht
			"Cxx_vh_wht"
			VALUE
			0x78F2C
			DATA_RECORD_UBYTE
			2550
			F_10_p450_267
			450
			3000
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vs_dsb
			"Cxx_vs_dsb"
			VALUE
			0x7362B
			DATA_RECORD_UBYTE
			255
			F_1_p0_58
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vs_fail_dsb
			"Cxx_vs_fail_dsb"
			VALUE
			0x7902B
			DATA_RECORD_UBYTE
			255
			F_1_p0_54
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vs_n_rat_fil_fac
			"Cxx_vs_n_rat_fil_fac"
			VALUE
			0x78F2D
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vs_n_rat_fil_fac_1
			"Cxx_vs_n_rat_fil_fac_1"
			VALUE
			0x78D4C
			DATA_RECORD_UWORD
			0.999998565
			F_0v000015259_p0_216
			0
			0.999998565
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vs_n_rat_fil_fac_2
			"Cxx_vs_n_rat_fil_fac_2"
			VALUE
			0x78D4E
			DATA_RECORD_UWORD
			0.999998565
			F_0v000015259_p0_216
			0
			0.999998565
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vs_n_rat_fil_fac_3
			"Cxx_vs_n_rat_fil_fac_3"
			VALUE
			0x78D50
			DATA_RECORD_UWORD
			0.999998565
			F_0v000015259_p0_216
			0
			0.999998565
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vs_n_rat_max
			"Cxx_vs_n_rat_max"
			VALUE
			0x78F2E
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_268
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vs_n_rat_min
			"Cxx_vs_n_rat_min"
			VALUE
			0x78F2F
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_268
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vs_sum_cor_fac
			"Cxx_vs_sum_cor_fac"
			VALUE
			0x79040
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vs_t_sens_fail_det
			"Cxx_vs_t_sens_fail_det"
			VALUE
			0x7902C
			DATA_RECORD_UBYTE
			32.64
			F_0v128_p0_75
			0
			32.64
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vs_thd_sens_fail_det
			"Cxx_vs_thd_sens_fail_det"
			VALUE
			0x7902D
			DATA_RECORD_UBYTE
			255
			F_1_p0_58
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vs_thd_vs_sens_vld
			"Cxx_vs_thd_vs_sens_vld"
			VALUE
			0x7902E
			DATA_RECORD_UBYTE
			255
			F_1_p0_58
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vvt_cmd_min_tco
			"Cxx_vvt_cmd_min_tco"
			VALUE
			0x71D12
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vvt_cmd_min_vb
			"Cxx_vvt_cmd_min_vb"
			VALUE
			0x71DE4
			DATA_RECORD_UWORD
			8.191875
			F_0v000125_p8_7
			8
			16.191875
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vvt_conf
			"Cxx_vvt_conf"
			VALUE
			0x735E0
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vvt_fill_efv_cam_ofs
			"Cxx_vvt_fill_efv_cam_ofs"
			VALUE
			0x75938
			DATA_RECORD_UBYTE
			95.625
			F_0v375_m32_269
			-32
			63.625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vvt_off_thd
			"Cxx_vvt_off_thd"
			VALUE
			0x71D13
			DATA_RECORD_UBYTE
			255
			F_1_p0_53
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vvt_on_thd
			"Cxx_vvt_on_thd"
			VALUE
			0x71D14
			DATA_RECORD_UBYTE
			255
			F_1_p0_53
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vvt_req_off_tdc
			"Cxx_vvt_req_off_tdc"
			VALUE
			0x71D15
			DATA_RECORD_UBYTE
			255
			F_1_p0_53
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vvt_req_on_tdc
			"Cxx_vvt_req_on_tdc"
			VALUE
			0x71D16
			DATA_RECORD_UBYTE
			255
			F_1_p0_53
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vvtc_act_ena_n_hys
			"Cxx_vvtc_act_ena_n_hys"
			VALUE
			0x73608
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vvtc_act_ena_n_thd
			"Cxx_vvtc_act_ena_n_thd"
			VALUE
			0x7360A
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vvtc_act_temp_h_hys
			"Cxx_vvtc_act_temp_h_hys"
			VALUE
			0x735E1
			DATA_RECORD_UBYTE
			159.375
			F_0v625_p0_143
			0
			159.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vvtc_angl_tdc_fac
			"Cxx_vvtc_angl_tdc_fac"
			VALUE
			0x78666
			DATA_RECORD_SWORD
			999984.7412
			F_15v2587890625_p0_68
			-500000
			499984.7412
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vvtc_dsb_ena_fil_inc
			"Cxx_vvtc_dsb_ena_fil_inc"
			VALUE
			0x735E2
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vvtc_h_trt
			"Cxx_vvtc_h_trt"
			VALUE
			0x71D17
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vvtc_in_sp_fil_fac
			"Cxx_vvtc_in_sp_fil_fac"
			VALUE
			0x7B0CE
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vvtc_min_iga_cor
			"Cxx_vvtc_min_iga_cor"
			VALUE
			0x71D18
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_vvtc_pwm_bch
			"Cxx_vvtc_pwm_bch"
			VALUE
			0x7B0FC
			DATA_RECORD_UWORD
			6399.902344
			F_0v09765625_p0_71
			0
			6399.902344
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_wet_acel_bch_cor_fac
			"Cxx_wet_acel_bch_cor_fac"
			VALUE
			0x75939
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_wet_acel_bch_fil_fac
			"Cxx_wet_acel_bch_fil_fac"
			VALUE
			0x7593A
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_wet_bch_vol_fac
			"Cxx_wet_bch_vol_fac"
			VALUE
			0x7593B
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_wet_decl_bch_cor_fac
			"Cxx_wet_decl_bch_cor_fac"
			VALUE
			0x7593C
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_wet_decl_bch_fil_fac
			"Cxx_wet_decl_bch_fil_fac"
			VALUE
			0x7593D
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_wet_ini_acel_ofs_t
			"Cxx_wet_ini_acel_ofs_t"
			VALUE
			0x7593E
			DATA_RECORD_UBYTE
			65280
			F_256_p0_142
			0
			65280
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_wet_ini_acel_sta_t
			"Cxx_wet_ini_acel_sta_t"
			VALUE
			0x7593F
			DATA_RECORD_UBYTE
			65280
			F_256_p0_142
			0
			65280
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_wet_min_air_stab_thd
			"Cxx_wet_min_air_stab_thd"
			VALUE
			0x76F96
			DATA_RECORD_UWORD
			30801.45
			F_0v47_p0_270
			0
			30801.45
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_wet_tb_cor_fac
			"Cxx_wet_tb_cor_fac"
			VALUE
			0x75940
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_wet_tdc_ctr_rat
			"Cxx_wet_tdc_ctr_rat"
			VALUE
			0x75941
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_wet_ti_cut_nr
			"Cxx_wet_ti_cut_nr"
			VALUE
			0x75942
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_wet_ti_cut_tdc_nr
			"Cxx_wet_ti_cut_tdc_nr"
			VALUE
			0x76F98
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_whl_mov_thd
			"Cxx_whl_mov_thd"
			VALUE
			0x73654
			DATA_RECORD_UWORD
			143390.58
			F_2v188_p0_202
			0
			143390.58
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_whl_rad
			"Cxx_whl_rad"
			VALUE
			0x78F30
			DATA_RECORD_UBYTE
			0.99609375
			F_0v00390625_p0_271
			0
			0.99609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_whl_spd_dsb
			"Cxx_whl_spd_dsb"
			VALUE
			0x7362C
			DATA_RECORD_UBYTE
			2231.76
			F_8v752_p0_109
			0
			2231.76
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_whl_spd_nul
			"Cxx_whl_spd_nul"
			VALUE
			0x7362D
			DATA_RECORD_UBYTE
			2231.76
			F_8v752_p0_109
			0
			2231.76
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_whl_spd_rls
			"Cxx_whl_spd_rls"
			VALUE
			0x73656
			DATA_RECORD_UWORD
			143390.58
			F_2v188_p0_202
			0
			143390.58
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_wpmp_cmd_tco_thd_hys
			"Cxx_wpmp_cmd_tco_thd_hys"
			VALUE
			0x7848D
			DATA_RECORD_UBYTE
			159.375
			F_0v625_p0_143
			0
			159.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_wpmp_cmd_tco_thd_mini
			"Cxx_wpmp_cmd_tco_thd_mini"
			VALUE
			0x7848E
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_wpmp_cmd_vb_thd_hys
			"Cxx_wpmp_cmd_vb_thd_hys"
			VALUE
			0x7848F
			DATA_RECORD_UBYTE
			8.16
			F_0v032_p0_272
			0
			8.16
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_wpmp_cmd_vb_thd_maxi
			"Cxx_wpmp_cmd_vb_thd_maxi"
			VALUE
			0x78490
			DATA_RECORD_UBYTE
			8.16
			F_0v032_p8_130
			8
			16.16
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_wpmp_max_t
			"Cxx_wpmp_max_t"
			VALUE
			0x78491
			DATA_RECORD_UBYTE
			4177.92
			F_16v384_p0_161
			0
			4177.92
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_wpmp_max_tco_t
			"Cxx_wpmp_max_tco_t"
			VALUE
			0x78492
			DATA_RECORD_UBYTE
			4177.92
			F_16v384_p0_161
			0
			4177.92
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_wpmp_tco_hys
			"Cxx_wpmp_tco_hys"
			VALUE
			0x78493
			DATA_RECORD_UBYTE
			159.375
			F_0v625_p0_143
			0
			159.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_wpmp_tco_thd
			"Cxx_wpmp_tco_thd"
			VALUE
			0x78494
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_wup_dstb_h_map_lpg
			"Cxx_wup_dstb_h_map_lpg"
			VALUE
			0x70FBC
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_wup_dstb_h_n_lpg
			"Cxx_wup_dstb_h_n_lpg"
			VALUE
			0x70E1A
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_wup_dstb_l_map_lpg
			"Cxx_wup_dstb_l_map_lpg"
			VALUE
			0x70FBE
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_zon_3_act_trt
			"Cxx_zon_3_act_trt"
			VALUE
			0x73658
			DATA_RECORD_UWORD
			2867.8116
			F_0v04376_p0_180
			0
			2867.8116
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_zon_3_act_trt_out
			"Cxx_zon_3_act_trt_out"
			VALUE
			0x7365A
			DATA_RECORD_UWORD
			2867.8116
			F_0v04376_p0_180
			0
			2867.8116
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_zon_3_dsb_trt
			"Cxx_zon_3_dsb_trt"
			VALUE
			0x7365C
			DATA_RECORD_UWORD
			2867.8116
			F_0v04376_p0_180
			0
			2867.8116
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_zon_3_dsb_trt_out
			"Cxx_zon_3_dsb_trt_out"
			VALUE
			0x7365E
			DATA_RECORD_UWORD
			2867.8116
			F_0v04376_p0_180
			0
			2867.8116
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_zon_dif_min_hys
			"Cxx_zon_dif_min_hys"
			VALUE
			0x75943
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dcntrzvl
			"Nbre_tentative_reset"
			VALUE
			0x70D16
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dec_panne_bob_a_c_2cc0
			"Dec_panne_bob_a_c_2cc0"
			VALUE
			0x71DF3
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dec_panne_bob_a_c_cc1
			"Dec_panne_bob_a_c_cc1"
			VALUE
			0x71DF4
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dec_panne_bob_b_d_2cc0
			"Dec_panne_bob_b_d_2cc0"
			VALUE
			0x71DF5
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dec_panne_bob_b_d_cc1
			"Dec_panne_bob_b_d_cc1"
			VALUE
			0x71DF6
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Decababs
			"Decabs_abs"
			VALUE
			0x71EF7
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Decabbva
			"Decabs_bva"
			VALUE
			0x71EF9
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Decabs_acc
			"Decabs_acc"
			VALUE
			0x71EF8
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Decabs_clm
			"Decabs_clm"
			VALUE
			0x71EFA
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Decabs_gpl
			"Decabs_gpl"
			VALUE
			0x71EFB
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Decabtdb
			"Decabs_tdb"
			VALUE
			0x71EFC
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Decabuch
			"Decabs_uch"
			VALUE
			0x71EFD
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Decbof
			"Dec_busoff"
			VALUE
			0x71EF5
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Decm
			"Decrement_compteurs_can"
			VALUE
			0x71EFE
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Decmute
			"Dec_mute"
			VALUE
			0x71EF6
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Decthres
			"Seuil_dec_compteurs_can"
			VALUE
			0x71F23
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Delai_coupure_cmd_gpl
			"Delai_coupure_cmd_gpl"
			VALUE
			0x783B8
			DATA_RECORD_UBYTE
			1020
			F_4_p0_128
			0
			1020
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Delai_coupure_relais
			"Delai_coupure_relais"
			VALUE
			0x78D59
			DATA_RECORD_UBYTE
			2040
			F_8_p0_56
			0
			2040
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_0_checksum_faux
			"Dft_thr_0_checksum_faux"
			VALUE
			0x78FDD
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x40
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_0_chk_springs
			"Dft_thr_0_chk_springs"
			VALUE
			0x79007
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x8
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_0_map
			"Dft_thr_0_map"
			VALUE
			0x78FDC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x40
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_0_map_chr
			"Dft_thr_0_map_chr"
			VALUE
			0x78FDC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x8
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_0_mcut_sens1
			"Dft_thr_0_mcut_sens1"
			VALUE
			0x79007
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x80
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_0_pdl_sens1_oc
			"Dft_thr_0_pdl_sens1_oc"
			VALUE
			0x78FDD
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_0_pdl_sens1_vb_sc
			"Dft_thr_0_pdl_sens1_vb_sc"
			VALUE
			0x78FDD
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x2
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_0_pdl_sens2_oc
			"Dft_thr_0_pdl_sens2_oc"
			VALUE
			0x78FDD
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x4
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_0_pdl_sens2_vb_sc
			"Dft_thr_0_pdl_sens2_vb_sc"
			VALUE
			0x78FDD
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x8
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_0_pdl_sens_chr
			"Dft_thr_0_pdl_sens_chr"
			VALUE
			0x78FDF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x4
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_0_pws_pdl2
			"Dft_thr_0_pws_pdl2"
			VALUE
			0x78FDF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x10
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_0_pws_thr_pdl1
			"Dft_thr_0_pws_thr_pdl1"
			VALUE
			0x78FDF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x8
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_0_rams_map_tq
			"Dft_thr_0_rams_map_tq"
			VALUE
			0x79007
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x20
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_0_rams_pdl
			"Dft_thr_0_rams_pdl"
			VALUE
			0x79007
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_0_rams_tq_ctl
			"Dft_thr_0_rams_tq_ctl"
			VALUE
			0x79007
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x4
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_0_rams_tq_req
			"Dft_thr_0_rams_tq_req"
			VALUE
			0x79007
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x10
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_0_rmc_algopp
			"Dft_thr_0_rmc_algopp"
			VALUE
			0x78FDD
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x80
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_0_rmc_clockpp
			"Dft_thr_0_rmc_clockpp"
			VALUE
			0x78FDC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_0_rmc_comspipp
			"Dft_thr_0_rmc_comspipp"
			VALUE
			0x78FDF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x20
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_0_rmc_inhwp
			"Dft_thr_0_rmc_inhwp"
			VALUE
			0x78FDD
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x20
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_0_rmc_monitpp
			"Dft_thr_0_rmc_monitpp"
			VALUE
			0x78FDF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x40
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_0_rmc_papmpp
			"Dft_thr_0_rmc_papmpp"
			VALUE
			0x78FDE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x2
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_0_rmc_pedmpp
			"Dft_thr_0_rmc_pedmpp"
			VALUE
			0x78FDE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_0_rmc_timeoutpp
			"Dft_thr_0_rmc_timeoutpp"
			VALUE
			0x78FDF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x80
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_0_sens_pdl
			"Dft_thr_0_sens_pdl"
			VALUE
			0x79006
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x4
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_0_sens_thr
			"Dft_thr_0_sens_thr"
			VALUE
			0x79006
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x2
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_0_servcoh_papdw
			"Dft_thr_0_servcoh_papdw"
			VALUE
			0x78FDC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x4
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_0_servcoh_papup
			"Dft_thr_0_servcoh_papup"
			VALUE
			0x78FDC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x2
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_0_spg
			"Dft_thr_0_spg"
			VALUE
			0x78FDC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x10
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_0_spg_sys
			"Dft_thr_0_spg_sys"
			VALUE
			0x78FDC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x20
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_0_svkl_lih
			"Dft_thr_0_svkl_lih"
			VALUE
			0x78FDD
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x10
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_0_svkl_oc
			"Dft_thr_0_svkl_oc"
			VALUE
			0x79006
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_0_svkl_sge
			"Dft_thr_0_svkl_sge"
			VALUE
			0x79007
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x40
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_0_thr_cmd_cpt
			"Dft_thr_0_thr_cmd_cpt"
			VALUE
			0x78FDE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x8
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_0_thr_cmd_vb_sc
			"Dft_thr_0_thr_cmd_vb_sc"
			VALUE
			0x78FDE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x4
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_0_thr_sens1_oc
			"Dft_thr_0_thr_sens1_oc"
			VALUE
			0x78FDE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x10
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_0_thr_sens1_vb_sc
			"Dft_thr_0_thr_sens1_vb_sc"
			VALUE
			0x78FDE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x20
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_0_thr_sens2_scg
			"Dft_thr_0_thr_sens2_scg"
			VALUE
			0x78FDE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x40
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_0_thr_sens2_vb_sc
			"Dft_thr_0_thr_sens2_vb_sc"
			VALUE
			0x78FDE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x80
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_0_thr_sens_chr
			"Dft_thr_0_thr_sens_chr"
			VALUE
			0x78FDF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x2
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_0_tia
			"Dft_thr_0_tia"
			VALUE
			0x79007
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x2
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_0_vb_low
			"Dft_thr_0_vb_low"
			VALUE
			0x78FDF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_0_wgc
			"Dft_thr_0_wgc"
			VALUE
			0x78FDC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x80
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_1_checksum_faux
			"Dft_thr_1_checksum_faux"
			VALUE
			0x78FE1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x40
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_1_chk_springs
			"Dft_thr_1_chk_springs"
			VALUE
			0x79009
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x8
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_1_map
			"Dft_thr_1_map"
			VALUE
			0x78FE0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x40
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_1_map_chr
			"Dft_thr_1_map_chr"
			VALUE
			0x78FE0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x8
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_1_mcut_sens1
			"Dft_thr_1_mcut_sens1"
			VALUE
			0x79009
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x80
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_1_pdl_sens1_oc
			"Dft_thr_1_pdl_sens1_oc"
			VALUE
			0x78FE1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_1_pdl_sens1_vb_sc
			"Dft_thr_1_pdl_sens1_vb_sc"
			VALUE
			0x78FE1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x2
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_1_pdl_sens2_oc
			"Dft_thr_1_pdl_sens2_oc"
			VALUE
			0x78FE1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x4
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_1_pdl_sens2_vb_sc
			"Dft_thr_1_pdl_sens2_vb_sc"
			VALUE
			0x78FE1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x8
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_1_pdl_sens_chr
			"Dft_thr_1_pdl_sens_chr"
			VALUE
			0x78FE3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x4
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_1_pws_pdl2
			"Dft_thr_1_pws_pdl2"
			VALUE
			0x78FE3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x10
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_1_pws_thr_pdl1
			"Dft_thr_1_pws_thr_pdl1"
			VALUE
			0x78FE3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x8
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_1_rams_map_tq
			"Dft_thr_1_rams_map_tq"
			VALUE
			0x79009
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x20
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_1_rams_pdl
			"Dft_thr_1_rams_pdl"
			VALUE
			0x79009
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_1_rams_tq_ctl
			"Dft_thr_1_rams_tq_ctl"
			VALUE
			0x79009
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x4
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_1_rams_tq_req
			"Dft_thr_1_rams_tq_req"
			VALUE
			0x79009
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x10
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_1_rmc_algopp
			"Dft_thr_1_rmc_algopp"
			VALUE
			0x78FE1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x80
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_1_rmc_clockpp
			"Dft_thr_1_rmc_clockpp"
			VALUE
			0x78FE0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_1_rmc_comspipp
			"Dft_thr_1_rmc_comspipp"
			VALUE
			0x78FE3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x20
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_1_rmc_inhwp
			"Dft_thr_1_rmc_inhwp"
			VALUE
			0x78FE1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x20
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_1_rmc_monitpp
			"Dft_thr_1_rmc_monitpp"
			VALUE
			0x78FE3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x40
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_1_rmc_papmpp
			"Dft_thr_1_rmc_papmpp"
			VALUE
			0x78FE2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x2
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_1_rmc_pedmpp
			"Dft_thr_1_rmc_pedmpp"
			VALUE
			0x78FE2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_1_rmc_timeoutpp
			"Dft_thr_1_rmc_timeoutpp"
			VALUE
			0x78FE3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x80
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_1_sens_pdl
			"Dft_thr_1_sens_pdl"
			VALUE
			0x79008
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x4
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_1_sens_thr
			"Dft_thr_1_sens_thr"
			VALUE
			0x79008
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x2
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_1_servcoh_papdw
			"Dft_thr_1_servcoh_papdw"
			VALUE
			0x78FE0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x4
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_1_servcoh_papup
			"Dft_thr_1_servcoh_papup"
			VALUE
			0x78FE0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x2
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_1_spg
			"Dft_thr_1_spg"
			VALUE
			0x78FE0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x10
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_1_spg_sys
			"Dft_thr_1_spg_sys"
			VALUE
			0x78FE0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x20
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_1_svkl_lih
			"Dft_thr_1_svkl_lih"
			VALUE
			0x78FE1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x10
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_1_svkl_oc
			"Dft_thr_1_svkl_oc"
			VALUE
			0x79008
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_1_svkl_sge
			"Dft_thr_1_svkl_sge"
			VALUE
			0x79009
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x40
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_1_thr_cmd_cpt
			"Dft_thr_1_thr_cmd_cpt"
			VALUE
			0x78FE2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x8
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_1_thr_cmd_vb_sc
			"Dft_thr_1_thr_cmd_vb_sc"
			VALUE
			0x78FE2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x4
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_1_thr_sens1_oc
			"Dft_thr_1_thr_sens1_oc"
			VALUE
			0x78FE2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x10
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_1_thr_sens1_vb_sc
			"Dft_thr_1_thr_sens1_vb_sc"
			VALUE
			0x78FE2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x20
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_1_thr_sens2_scg
			"Dft_thr_1_thr_sens2_scg"
			VALUE
			0x78FE2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x40
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_1_thr_sens2_vb_sc
			"Dft_thr_1_thr_sens2_vb_sc"
			VALUE
			0x78FE2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x80
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_1_thr_sens_chr
			"Dft_thr_1_thr_sens_chr"
			VALUE
			0x78FE3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x2
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_1_tia
			"Dft_thr_1_tia"
			VALUE
			0x79009
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x2
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_1_vb_low
			"Dft_thr_1_vb_low"
			VALUE
			0x78FE3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_1_wgc
			"Dft_thr_1_wgc"
			VALUE
			0x78FE0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x80
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_2_checksum_faux
			"Dft_thr_2_checksum_faux"
			VALUE
			0x78FE5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x40
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_2_chk_springs
			"Dft_thr_2_chk_springs"
			VALUE
			0x7900B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x8
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_2_map
			"Dft_thr_2_map"
			VALUE
			0x78FE4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x40
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_2_map_chr
			"Dft_thr_2_map_chr"
			VALUE
			0x78FE4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x8
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_2_mcut_sens1
			"Dft_thr_2_mcut_sens1"
			VALUE
			0x7900B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x80
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_2_pdl_sens1_oc
			"Dft_thr_2_pdl_sens1_oc"
			VALUE
			0x78FE5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_2_pdl_sens1_vb_sc
			"Dft_thr_2_pdl_sens1_vb_sc"
			VALUE
			0x78FE5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x2
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_2_pdl_sens2_oc
			"Dft_thr_2_pdl_sens2_oc"
			VALUE
			0x78FE5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x4
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_2_pdl_sens2_vb_sc
			"Dft_thr_2_pdl_sens2_vb_sc"
			VALUE
			0x78FE5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x8
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_2_pdl_sens_chr
			"Dft_thr_2_pdl_sens_chr"
			VALUE
			0x78FE7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x4
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_2_pws_pdl2
			"Dft_thr_2_pws_pdl2"
			VALUE
			0x78FE7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x10
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_2_pws_thr_pdl1
			"Dft_thr_2_pws_thr_pdl1"
			VALUE
			0x78FE7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x8
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_2_rams_map_tq
			"Dft_thr_2_rams_map_tq"
			VALUE
			0x7900B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x20
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_2_rams_pdl
			"Dft_thr_2_rams_pdl"
			VALUE
			0x7900B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_2_rams_tq_ctl
			"Dft_thr_2_rams_tq_ctl"
			VALUE
			0x7900B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x4
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_2_rams_tq_req
			"Dft_thr_2_rams_tq_req"
			VALUE
			0x7900B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x10
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_2_rmc_algopp
			"Dft_thr_2_rmc_algopp"
			VALUE
			0x78FE5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x80
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_2_rmc_clockpp
			"Dft_thr_2_rmc_clockpp"
			VALUE
			0x78FE4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_2_rmc_comspipp
			"Dft_thr_2_rmc_comspipp"
			VALUE
			0x78FE7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x20
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_2_rmc_inhwp
			"Dft_thr_2_rmc_inhwp"
			VALUE
			0x78FE5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x20
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_2_rmc_monitpp
			"Dft_thr_2_rmc_monitpp"
			VALUE
			0x78FE7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x40
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_2_rmc_papmpp
			"Dft_thr_2_rmc_papmpp"
			VALUE
			0x78FE6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x2
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_2_rmc_pedmpp
			"Dft_thr_2_rmc_pedmpp"
			VALUE
			0x78FE6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_2_rmc_timeoutpp
			"Dft_thr_2_rmc_timeoutpp"
			VALUE
			0x78FE7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x80
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_2_sens_pdl
			"Dft_thr_2_sens_pdl"
			VALUE
			0x7900A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x4
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_2_sens_thr
			"Dft_thr_2_sens_thr"
			VALUE
			0x7900A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x2
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_2_servcoh_papdw
			"Dft_thr_2_servcoh_papdw"
			VALUE
			0x78FE4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x4
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_2_servcoh_papup
			"Dft_thr_2_servcoh_papup"
			VALUE
			0x78FE4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x2
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_2_spg
			"Dft_thr_2_spg"
			VALUE
			0x78FE4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x10
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_2_spg_sys
			"Dft_thr_2_spg_sys"
			VALUE
			0x78FE4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x20
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_2_svkl_lih
			"Dft_thr_2_svkl_lih"
			VALUE
			0x78FE5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x10
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_2_svkl_oc
			"Dft_thr_2_svkl_oc"
			VALUE
			0x7900A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_2_svkl_sge
			"Dft_thr_2_svkl_sge"
			VALUE
			0x7900B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x40
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_2_thr_cmd_cpt
			"Dft_thr_2_thr_cmd_cpt"
			VALUE
			0x78FE6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x8
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_2_thr_cmd_vb_sc
			"Dft_thr_2_thr_cmd_vb_sc"
			VALUE
			0x78FE6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x4
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_2_thr_sens1_oc
			"Dft_thr_2_thr_sens1_oc"
			VALUE
			0x78FE6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x10
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_2_thr_sens1_vb_sc
			"Dft_thr_2_thr_sens1_vb_sc"
			VALUE
			0x78FE6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x20
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_2_thr_sens2_scg
			"Dft_thr_2_thr_sens2_scg"
			VALUE
			0x78FE6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x40
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_2_thr_sens2_vb_sc
			"Dft_thr_2_thr_sens2_vb_sc"
			VALUE
			0x78FE6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x80
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_2_thr_sens_chr
			"Dft_thr_2_thr_sens_chr"
			VALUE
			0x78FE7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x2
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_2_tia
			"Dft_thr_2_tia"
			VALUE
			0x7900B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x2
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_2_vb_low
			"Dft_thr_2_vb_low"
			VALUE
			0x78FE7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_2_wgc
			"Dft_thr_2_wgc"
			VALUE
			0x78FE4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x80
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_3_checksum_faux
			"Dft_thr_3_checksum_faux"
			VALUE
			0x78FE9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x40
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_3_chk_springs
			"Dft_thr_3_chk_springs"
			VALUE
			0x7900D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x8
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_3_map
			"Dft_thr_3_map"
			VALUE
			0x78FE8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x40
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_3_map_chr
			"Dft_thr_3_map_chr"
			VALUE
			0x78FE8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x8
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_3_mcut_sens1
			"Dft_thr_3_mcut_sens1"
			VALUE
			0x7900D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x80
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_3_pdl_sens1_oc
			"Dft_thr_3_pdl_sens1_oc"
			VALUE
			0x78FE9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_3_pdl_sens1_vb_sc
			"Dft_thr_3_pdl_sens1_vb_sc"
			VALUE
			0x78FE9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x2
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_3_pdl_sens2_oc
			"Dft_thr_3_pdl_sens2_oc"
			VALUE
			0x78FE9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x4
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_3_pdl_sens2_vb_sc
			"Dft_thr_3_pdl_sens2_vb_sc"
			VALUE
			0x78FE9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x8
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_3_pdl_sens_chr
			"Dft_thr_3_pdl_sens_chr"
			VALUE
			0x78FEB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x4
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_3_pws_pdl2
			"Dft_thr_3_pws_pdl2"
			VALUE
			0x78FEB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x10
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_3_pws_thr_pdl1
			"Dft_thr_3_pws_thr_pdl1"
			VALUE
			0x78FEB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x8
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_3_rams_map_tq
			"Dft_thr_3_rams_map_tq"
			VALUE
			0x7900D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x20
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_3_rams_pdl
			"Dft_thr_3_rams_pdl"
			VALUE
			0x7900D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_3_rams_tq_ctl
			"Dft_thr_3_rams_tq_ctl"
			VALUE
			0x7900D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x4
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_3_rams_tq_req
			"Dft_thr_3_rams_tq_req"
			VALUE
			0x7900D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x10
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_3_rmc_algopp
			"Dft_thr_3_rmc_algopp"
			VALUE
			0x78FE9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x80
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_3_rmc_clockpp
			"Dft_thr_3_rmc_clockpp"
			VALUE
			0x78FE8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_3_rmc_comspipp
			"Dft_thr_3_rmc_comspipp"
			VALUE
			0x78FEB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x20
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_3_rmc_inhwp
			"Dft_thr_3_rmc_inhwp"
			VALUE
			0x78FE9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x20
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_3_rmc_monitpp
			"Dft_thr_3_rmc_monitpp"
			VALUE
			0x78FEB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x40
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_3_rmc_papmpp
			"Dft_thr_3_rmc_papmpp"
			VALUE
			0x78FEA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x2
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_3_rmc_pedmpp
			"Dft_thr_3_rmc_pedmpp"
			VALUE
			0x78FEA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_3_rmc_timeoutpp
			"Dft_thr_3_rmc_timeoutpp"
			VALUE
			0x78FEB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x80
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_3_sens_pdl
			"Dft_thr_3_sens_pdl"
			VALUE
			0x7900C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x4
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_3_sens_thr
			"Dft_thr_3_sens_thr"
			VALUE
			0x7900C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x2
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_3_servcoh_papdw
			"Dft_thr_3_servcoh_papdw"
			VALUE
			0x78FE8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x4
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_3_servcoh_papup
			"Dft_thr_3_servcoh_papup"
			VALUE
			0x78FE8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x2
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_3_spg
			"Dft_thr_3_spg"
			VALUE
			0x78FE8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x10
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_3_spg_sys
			"Dft_thr_3_spg_sys"
			VALUE
			0x78FE8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x20
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_3_svkl_lih
			"Dft_thr_3_svkl_lih"
			VALUE
			0x78FE9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x10
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_3_svkl_oc
			"Dft_thr_3_svkl_oc"
			VALUE
			0x7900C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_3_svkl_sge
			"Dft_thr_3_svkl_sge"
			VALUE
			0x7900D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x40
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_3_thr_cmd_cpt
			"Dft_thr_3_thr_cmd_cpt"
			VALUE
			0x78FEA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x8
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_3_thr_cmd_vb_sc
			"Dft_thr_3_thr_cmd_vb_sc"
			VALUE
			0x78FEA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x4
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_3_thr_sens1_oc
			"Dft_thr_3_thr_sens1_oc"
			VALUE
			0x78FEA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x10
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_3_thr_sens1_vb_sc
			"Dft_thr_3_thr_sens1_vb_sc"
			VALUE
			0x78FEA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x20
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_3_thr_sens2_scg
			"Dft_thr_3_thr_sens2_scg"
			VALUE
			0x78FEA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x40
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_3_thr_sens2_vb_sc
			"Dft_thr_3_thr_sens2_vb_sc"
			VALUE
			0x78FEA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x80
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_3_thr_sens_chr
			"Dft_thr_3_thr_sens_chr"
			VALUE
			0x78FEB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x2
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_3_tia
			"Dft_thr_3_tia"
			VALUE
			0x7900D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x2
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_3_vb_low
			"Dft_thr_3_vb_low"
			VALUE
			0x78FEB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_3_wgc
			"Dft_thr_3_wgc"
			VALUE
			0x78FE8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x80
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_4_checksum_faux
			"Dft_thr_4_checksum_faux"
			VALUE
			0x78FED
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x40
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_4_chk_springs
			"Dft_thr_4_chk_springs"
			VALUE
			0x7900F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x8
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_4_map
			"Dft_thr_4_map"
			VALUE
			0x78FEC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x40
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_4_map_chr
			"Dft_thr_4_map_chr"
			VALUE
			0x78FEC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x8
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_4_mcut_sens1
			"Dft_thr_4_mcut_sens1"
			VALUE
			0x7900F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x80
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_4_pdl_sens1_oc
			"Dft_thr_4_pdl_sens1_oc"
			VALUE
			0x78FED
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_4_pdl_sens1_vb_sc
			"Dft_thr_4_pdl_sens1_vb_sc"
			VALUE
			0x78FED
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x2
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_4_pdl_sens2_oc
			"Dft_thr_4_pdl_sens2_oc"
			VALUE
			0x78FED
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x4
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_4_pdl_sens2_vb_sc
			"Dft_thr_4_pdl_sens2_vb_sc"
			VALUE
			0x78FED
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x8
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_4_pdl_sens_chr
			"Dft_thr_4_pdl_sens_chr"
			VALUE
			0x78FEF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x4
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_4_pws_pdl2
			"Dft_thr_4_pws_pdl2"
			VALUE
			0x78FEF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x10
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_4_pws_thr_pdl1
			"Dft_thr_4_pws_thr_pdl1"
			VALUE
			0x78FEF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x8
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_4_rams_map_tq
			"Dft_thr_4_rams_map_tq"
			VALUE
			0x7900F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x20
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_4_rams_pdl
			"Dft_thr_4_rams_pdl"
			VALUE
			0x7900F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_4_rams_tq_ctl
			"Dft_thr_4_rams_tq_ctl"
			VALUE
			0x7900F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x4
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_4_rams_tq_req
			"Dft_thr_4_rams_tq_req"
			VALUE
			0x7900F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x10
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_4_rmc_algopp
			"Dft_thr_4_rmc_algopp"
			VALUE
			0x78FED
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x80
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_4_rmc_clockpp
			"Dft_thr_4_rmc_clockpp"
			VALUE
			0x78FEC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_4_rmc_comspipp
			"Dft_thr_4_rmc_comspipp"
			VALUE
			0x78FEF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x20
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_4_rmc_inhwp
			"Dft_thr_4_rmc_inhwp"
			VALUE
			0x78FED
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x20
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_4_rmc_monitpp
			"Dft_thr_4_rmc_monitpp"
			VALUE
			0x78FEF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x40
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_4_rmc_papmpp
			"Dft_thr_4_rmc_papmpp"
			VALUE
			0x78FEE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x2
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_4_rmc_pedmpp
			"Dft_thr_4_rmc_pedmpp"
			VALUE
			0x78FEE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_4_rmc_timeoutpp
			"Dft_thr_4_rmc_timeoutpp"
			VALUE
			0x78FEF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x80
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_4_sens_pdl
			"Dft_thr_4_sens_pdl"
			VALUE
			0x7900E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x4
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_4_sens_thr
			"Dft_thr_4_sens_thr"
			VALUE
			0x7900E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x2
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_4_servcoh_papdw
			"Dft_thr_4_servcoh_papdw"
			VALUE
			0x78FEC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x4
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_4_servcoh_papup
			"Dft_thr_4_servcoh_papup"
			VALUE
			0x78FEC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x2
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_4_spg
			"Dft_thr_4_spg"
			VALUE
			0x78FEC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x10
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_4_spg_sys
			"Dft_thr_4_spg_sys"
			VALUE
			0x78FEC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x20
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_4_svkl_lih
			"Dft_thr_4_svkl_lih"
			VALUE
			0x78FED
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x10
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_4_svkl_oc
			"Dft_thr_4_svkl_oc"
			VALUE
			0x7900E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_4_svkl_sge
			"Dft_thr_4_svkl_sge"
			VALUE
			0x7900F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x40
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_4_thr_cmd_cpt
			"Dft_thr_4_thr_cmd_cpt"
			VALUE
			0x78FEE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x8
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_4_thr_cmd_vb_sc
			"Dft_thr_4_thr_cmd_vb_sc"
			VALUE
			0x78FEE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x4
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_4_thr_sens1_oc
			"Dft_thr_4_thr_sens1_oc"
			VALUE
			0x78FEE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x10
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_4_thr_sens1_vb_sc
			"Dft_thr_4_thr_sens1_vb_sc"
			VALUE
			0x78FEE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x20
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_4_thr_sens2_scg
			"Dft_thr_4_thr_sens2_scg"
			VALUE
			0x78FEE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x40
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_4_thr_sens2_vb_sc
			"Dft_thr_4_thr_sens2_vb_sc"
			VALUE
			0x78FEE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x80
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_4_thr_sens_chr
			"Dft_thr_4_thr_sens_chr"
			VALUE
			0x78FEF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x2
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_4_tia
			"Dft_thr_4_tia"
			VALUE
			0x7900F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x2
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_4_vb_low
			"Dft_thr_4_vb_low"
			VALUE
			0x78FEF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_4_wgc
			"Dft_thr_4_wgc"
			VALUE
			0x78FEC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x80
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_5_checksum_faux
			"Dft_thr_5_checksum_faux"
			VALUE
			0x78FF1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x40
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_5_chk_springs
			"Dft_thr_5_chk_springs"
			VALUE
			0x79011
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x8
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_5_map
			"Dft_thr_5_map"
			VALUE
			0x78FF0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x40
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_5_map_chr
			"Dft_thr_5_map_chr"
			VALUE
			0x78FF0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x8
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_5_mcut_sens1
			"Dft_thr_5_mcut_sens1"
			VALUE
			0x79011
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x80
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_5_pdl_sens1_oc
			"Dft_thr_5_pdl_sens1_oc"
			VALUE
			0x78FF1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_5_pdl_sens1_vb_sc
			"Dft_thr_5_pdl_sens1_vb_sc"
			VALUE
			0x78FF1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x2
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_5_pdl_sens2_oc
			"Dft_thr_5_pdl_sens2_oc"
			VALUE
			0x78FF1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x4
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_5_pdl_sens2_vb_sc
			"Dft_thr_5_pdl_sens2_vb_sc"
			VALUE
			0x78FF1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x8
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_5_pdl_sens_chr
			"Dft_thr_5_pdl_sens_chr"
			VALUE
			0x78FF3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x4
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_5_pws_pdl2
			"Dft_thr_5_pws_pdl2"
			VALUE
			0x78FF3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x10
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_5_pws_thr_pdl1
			"Dft_thr_5_pws_thr_pdl1"
			VALUE
			0x78FF3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x8
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_5_rams_map_tq
			"Dft_thr_5_rams_map_tq"
			VALUE
			0x79011
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x20
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_5_rams_pdl
			"Dft_thr_5_rams_pdl"
			VALUE
			0x79011
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_5_rams_tq_ctl
			"Dft_thr_5_rams_tq_ctl"
			VALUE
			0x79011
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x4
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_5_rams_tq_req
			"Dft_thr_5_rams_tq_req"
			VALUE
			0x79011
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x10
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_5_rmc_algopp
			"Dft_thr_5_rmc_algopp"
			VALUE
			0x78FF1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x80
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_5_rmc_clockpp
			"Dft_thr_5_rmc_clockpp"
			VALUE
			0x78FF0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_5_rmc_comspipp
			"Dft_thr_5_rmc_comspipp"
			VALUE
			0x78FF3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x20
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_5_rmc_inhwp
			"Dft_thr_5_rmc_inhwp"
			VALUE
			0x78FF1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x20
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_5_rmc_monitpp
			"Dft_thr_5_rmc_monitpp"
			VALUE
			0x78FF3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x40
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_5_rmc_papmpp
			"Dft_thr_5_rmc_papmpp"
			VALUE
			0x78FF2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x2
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_5_rmc_pedmpp
			"Dft_thr_5_rmc_pedmpp"
			VALUE
			0x78FF2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_5_rmc_timeoutpp
			"Dft_thr_5_rmc_timeoutpp"
			VALUE
			0x78FF3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x80
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_5_sens_pdl
			"Dft_thr_5_sens_pdl"
			VALUE
			0x79010
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x4
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_5_sens_thr
			"Dft_thr_5_sens_thr"
			VALUE
			0x79010
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x2
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_5_servcoh_papdw
			"Dft_thr_5_servcoh_papdw"
			VALUE
			0x78FF0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x4
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_5_servcoh_papup
			"Dft_thr_5_servcoh_papup"
			VALUE
			0x78FF0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x2
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_5_spg
			"Dft_thr_5_spg"
			VALUE
			0x78FF0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x10
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_5_spg_sys
			"Dft_thr_5_spg_sys"
			VALUE
			0x78FF0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x20
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_5_svkl_lih
			"Dft_thr_5_svkl_lih"
			VALUE
			0x78FF1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x10
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_5_svkl_oc
			"Dft_thr_5_svkl_oc"
			VALUE
			0x79010
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_5_svkl_sge
			"Dft_thr_5_svkl_sge"
			VALUE
			0x79011
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x40
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_5_thr_cmd_cpt
			"Dft_thr_5_thr_cmd_cpt"
			VALUE
			0x78FF2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x8
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_5_thr_cmd_vb_sc
			"Dft_thr_5_thr_cmd_vb_sc"
			VALUE
			0x78FF2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x4
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_5_thr_sens1_oc
			"Dft_thr_5_thr_sens1_oc"
			VALUE
			0x78FF2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x10
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_5_thr_sens1_vb_sc
			"Dft_thr_5_thr_sens1_vb_sc"
			VALUE
			0x78FF2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x20
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_5_thr_sens2_scg
			"Dft_thr_5_thr_sens2_scg"
			VALUE
			0x78FF2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x40
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_5_thr_sens2_vb_sc
			"Dft_thr_5_thr_sens2_vb_sc"
			VALUE
			0x78FF2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x80
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_5_thr_sens_chr
			"Dft_thr_5_thr_sens_chr"
			VALUE
			0x78FF3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x2
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_5_tia
			"Dft_thr_5_tia"
			VALUE
			0x79011
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x2
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_5_vb_low
			"Dft_thr_5_vb_low"
			VALUE
			0x78FF3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_thr_5_wgc
			"Dft_thr_5_wgc"
			VALUE
			0x78FF0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x80
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_vvt_0_crk
			"Dft_vvt_0_crk"
			VALUE
			0x79002
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x4
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_vvt_0_crk_nr
			"Dft_vvt_0_crk_nr"
			VALUE
			0x79002
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x8
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_vvt_0_vta_intake_pmh
			"Dft_vvt_0_vta_intake_pmh"
			VALUE
			0x79002
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x2
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_vvt_0_vta_intake_shift
			"Dft_vvt_0_vta_intake_shift"
			VALUE
			0x79003
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_vvt_0_vvt_int_ev_cc0
			"Dft_vvt_0_vvt_int_ev_cc0"
			VALUE
			0x79003
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x80
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_vvt_0_vvt_int_ev_cc1
			"Dft_vvt_0_vvt_int_ev_cc1"
			VALUE
			0x79003
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x40
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_vvt_0_vvt_int_ev_co
			"Dft_vvt_0_vvt_int_ev_co"
			VALUE
			0x79002
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_vvt_0_vvt_intake_blk
			"Dft_vvt_0_vvt_intake_blk"
			VALUE
			0x79003
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x2
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_vvt_0_vvt_intake_bound
			"Dft_vvt_0_vvt_intake_bound"
			VALUE
			0x79003
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x10
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_vvt_0_vvt_intake_dyn
			"Dft_vvt_0_vvt_intake_dyn"
			VALUE
			0x79003
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x8
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_vvt_0_vvt_intake_int
			"Dft_vvt_0_vvt_intake_int"
			VALUE
			0x79003
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x4
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_vvt_0_vvt_intake_old_off
			"Dft_vvt_0_vvt_intake_old_off"
			VALUE
			0x79003
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x20
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_vvt_1_crk
			"Dft_vvt_1_crk"
			VALUE
			0x79004
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x4
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_vvt_1_crk_nr
			"Dft_vvt_1_crk_nr"
			VALUE
			0x79004
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x8
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_vvt_1_vta_intake_pmh
			"Dft_vvt_1_vta_intake_pmh"
			VALUE
			0x79004
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x2
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_vvt_1_vta_intake_shift
			"Dft_vvt_1_vta_intake_shift"
			VALUE
			0x79005
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_vvt_1_vvt_int_ev_cc0
			"Dft_vvt_1_vvt_int_ev_cc0"
			VALUE
			0x79005
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x80
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_vvt_1_vvt_int_ev_cc1
			"Dft_vvt_1_vvt_int_ev_cc1"
			VALUE
			0x79005
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x40
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_vvt_1_vvt_int_ev_co
			"Dft_vvt_1_vvt_int_ev_co"
			VALUE
			0x79004
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_vvt_1_vvt_intake_blk
			"Dft_vvt_1_vvt_intake_blk"
			VALUE
			0x79005
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x2
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_vvt_1_vvt_intake_bound
			"Dft_vvt_1_vvt_intake_bound"
			VALUE
			0x79005
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x10
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_vvt_1_vvt_intake_dyn
			"Dft_vvt_1_vvt_intake_dyn"
			VALUE
			0x79005
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x8
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_vvt_1_vvt_intake_int
			"Dft_vvt_1_vvt_intake_int"
			VALUE
			0x79005
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x4
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Dft_vvt_1_vvt_intake_old_off
			"Dft_vvt_1_vvt_intake_old_off"
			VALUE
			0x79005
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x20
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Diag_tpc_active_delay_
			"Diag_tpc_active_delay"
			VALUE
			0x7325E
			DATA_RECORD_UBYTE
			510
			F_2_p0_249
			0
			510
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Eep_inhib_nb_ecritures
			"Eep_inhib_nb_ecritures"
			VALUE
			0x736D2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Fcallcyc
			"Nb_cycle_all_diag_stat_fin_chain"
			VALUE
			0x79057
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Fcallof
			"Duree_of_all_diag_stat_fin_chain"
			VALUE
			0x79055
			DATA_RECORD_UBYTE
			2040
			F_8_p0_56
			0
			2040
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Fcallon
			"Duree_on_all_diag_stat_fin_chain"
			VALUE
			0x79092
			DATA_RECORD_UWORD
			209.712
			F_0v0032_p0_8
			0
			209.712
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Fcinjcyc
			"Nb_cycle_inj_diag_stat_fin_chain"
			VALUE
			0x79058
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Fcinjoff
			"Duree_of_inj_diag_stat_fin_chain"
			VALUE
			0x79056
			DATA_RECORD_UBYTE
			2040
			F_8_p0_56
			0
			2040
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Fcinjon
			"Duree_on_inj_diag_stat_fin_chain"
			VALUE
			0x79094
			DATA_RECORD_UWORD
			209.712
			F_0v0032_p0_8
			0
			209.712
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Fftibm
			"Filtrage_temps_inj_banc"
			VALUE
			0x75944
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Floffcor
			"Flag_offset_cor_avance_banc"
			VALUE
			0x71D19
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Icd_adapt_factor_twin_phys_max
			"Icd_adapt_factor_twin_phys_max"
			VALUE
			0x71E3E
			DATA_RECORD_UWORD
			167.7696
			F_0v00256_p0_280
			0
			167.7696
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Icd_adapt_factor_twin_phys_min
			"Icd_adapt_factor_twin_phys_min"
			VALUE
			0x71E40
			DATA_RECORD_UWORD
			167.7696
			F_0v00256_p0_280
			0
			167.7696
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Icd_adapt_factor_twin_phys_step
			"Icd_adapt_factor_twin_phys_step"
			VALUE
			0x71E42
			DATA_RECORD_UWORD
			167.7696
			F_0v00256_p0_280
			0
			167.7696
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Icd_adapt_offset_twin_phys_step
			"Icd_adapt_offset_twin_phys_step"
			VALUE
			0x71E44
			DATA_RECORD_UWORD
			319995.1172
			F_4v8828125_p0_11
			0
			319995.1172
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Icd_boost_delay
			"Icd_boost_delay"
			VALUE
			0x71DF7
			DATA_RECORD_UBYTE
			8160
			F_32_p0_122
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Icd_boost_load_thresh_high
			"Icd_boost_load_thresh_high"
			VALUE
			0x71E46
			DATA_RECORD_UWORD
			6399.88596
			F_0v097656_p0_5
			0
			6399.88596
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Icd_boost_load_thresh_low
			"Icd_boost_load_thresh_low"
			VALUE
			0x71E48
			DATA_RECORD_UWORD
			6399.88596
			F_0v097656_p0_5
			0
			6399.88596
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Icd_boost_manu_inh
			"Icd_boost_manu_inh"
			VALUE
			0x71DF8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Icd_boost_offset_map
			"Icd_boost_offset_map"
			CURVE
			0x71DF9
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				8
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Icd_reg_bkpt
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Icd_boost_transient_thresh
			"Icd_boost_transient_thresh"
			VALUE
			0x71E4A
			DATA_RECORD_UWORD
			6399.88596
			F_0v097656_p0_5
			0
			6399.88596
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Icd_dwell_limitation_delay_
			"Icd_dwell_limitation_delay"
			VALUE
			0x71E4C
			DATA_RECORD_UWORD
			209.712
			F_0v0032_p0_8
			0
			209.712
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Icd_energy_ratio_nom_
			"Icd_energy_ratio_nom"
			VALUE
			0x71E01
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Icd_limit_adapt_tdwell
			"Icd_limit_adapt_tdwell"
			VALUE
			0x71E4E
			DATA_RECORD_UWORD
			209.712
			F_0v0032_p0_8
			0
			209.712
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Icd_max_energy_twin_phys
			"Icd_max_energy_twin_phys"
			VALUE
			0x71E02
			DATA_RECORD_UBYTE
			1.245117188
			F_0v0048828125_p0_281
			0
			1.245117188
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Icd_pos_slope_1
			"Icd_pos_slope_1"
			VALUE
			0x71E03
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Icd_pos_slope_2
			"Icd_pos_slope_2"
			VALUE
			0x71E04
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Icd_ratio_energy_map
			"Icd_ratio_energy_map"
			MAP
			0x71E05
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				8
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Icd_reg_bkpt
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_map
				F_3v7_p103_37
				5
				103
				242582.5
				MAX_GRAD 100.0
				AXIS_PTS_REF Icd_map_bkpt
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Icd_water_temp_thresh
			"Icd_water_temp_thresh"
			VALUE
			0x71E2D
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ictdba2
			"Identificateur_trame_tdb_2"
			VALUE
			0x720E0
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Idabsbr
			"Identificateur_trame_abs"
			VALUE
			0x720D0
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Idabsct
			"Identificateur_trame_freins_esp"
			VALUE
			0x720DC
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Idaccba
			"Identificateur_trame_acc_base"
			VALUE
			0x720D2
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Idbvabl
			"Identificateur_trame_bva_lente"
			VALUE
			0x720D8
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Idbvabr
			"Identificateur_trame_bva"
			VALUE
			0x720D6
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Idclimb
			"Identificateur_trame_clim_base"
			VALUE
			0x720DA
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Idgplba
			"Identificateur_trame_gpl_base"
			VALUE
			0x720DE
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Idinjbl
			"Frame_id_inj_base_lente"
			VALUE
			0x720C2
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Idinjbr
			"Frame_id_inj_base_rapide"
			VALUE
			0x720C4
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Idinjhg
			"Frame_id_inj_hdg"
			VALUE
			0x720C8
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Idinjpas
			"Frame_id_requete_obd_passerelle"
			VALUE
			0x720CC
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Idinjpl
			"Frame_id_inj_gplgnv"
			VALUE
			0x720C6
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Idinjvl
			"Frame_id_inj_verlog"
			VALUE
			0x720CA
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Idpasbas
			"Identificateur_recu_can_obd"
			VALUE
			0x720CE
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Idrbagcr
			"Identificateur_trame_airbagcrash"
			VALUE
			0x720D4
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Idtdb
			"Identificateur_trame_tdb_base"
			VALUE
			0x720E2
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Iduch
			"Identificateur_trame_uch"
			VALUE
			0x720E4
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Inc_panne_bob_a_c_2cc0
			"Inc_panne_bob_a_c_2cc0"
			VALUE
			0x71E2E
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Inc_panne_bob_a_c_cc1
			"Inc_panne_bob_a_c_cc1"
			VALUE
			0x71E2F
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Inc_panne_bob_b_d_2cc0
			"Inc_panne_bob_b_d_2cc0"
			VALUE
			0x71E30
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Inc_panne_bob_b_d_cc1
			"Inc_panne_bob_b_d_cc1"
			VALUE
			0x71E31
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Incababs
			"Incabs_abs"
			VALUE
			0x71F02
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Incabacc
			"Incabs_acc"
			VALUE
			0x71F03
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Incabbva
			"Incabs_bva"
			VALUE
			0x71F04
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Incabclm
			"Incabs_clm"
			VALUE
			0x71F05
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Incabs_gpl
			"Incabs_gpl"
			VALUE
			0x71F06
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Incabtdb
			"Incabs_tdb"
			VALUE
			0x71F07
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Incabuch
			"Incabs_uch"
			VALUE
			0x71F08
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Incbof
			"Inc_busoff"
			VALUE
			0x71F00
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Incmute
			"Inc_mute"
			VALUE
			0x71F01
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Inhibe_coup_post_inj_fin_cy_
			"Inhibe_coup_post_inj_fin_cy"
			VALUE
			0x76F9D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Inhibe_reactualisation
			"Inhibe_reactualisation"
			VALUE
			0x76F9E
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Inhicorb
			"Inhibition_cor_banc"
			VALUE
			0x71D1A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Inj_banc_mot
			"Inj_banc_moteur"
			VALUE
			0x75945
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Kcvcpi_learn_zero_offsets
			"Kcvcpi_learn_zero_offsets"
			VALUE
			0x7B0FE
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Kevcpi_u_voltage_comp
			"Kevcpi_u_voltage_comp"
			VALUE
			0x7B0CF
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Kfvcpi_initial_current_int
			"Kfvcpi_initial_current_int"
			VALUE
			0x7B100
			DATA_RECORD_UWORD
			6399.902344
			F_0v09765625_p0_71
			0
			6399.902344
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Kfvcpi_initial_int_step_size
			"Kfvcpi_initial_int_step_size"
			VALUE
			0x7B102
			DATA_RECORD_UWORD
			6399.902344
			F_0v09765625_p0_71
			0
			6399.902344
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Kfvcpi_k_offset_filter
			"Kfvcpi_k_offset_filter"
			VALUE
			0x7B0D0
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Kfvcpi_noise_learn_count
			"Kfvcpi_noise_learn_count"
			VALUE
			0x7B104
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Kfvcpi_phi_maximum_cam_advance
			"Kfvcpi_phi_maximum_cam_advance"
			VALUE
			0x7B106
			DATA_RECORD_UWORD
			6143.90625
			F_0v09375_p0_282
			0
			6143.90625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Kfvcpi_phi_peak_to_peak_noise
			"Kfvcpi_phi_peak_to_peak_noise"
			VALUE
			0x7B0D1
			DATA_RECORD_UBYTE
			23.90625
			F_0v09375_p0_282
			0
			23.90625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Kfvcpi_set_edge_count
			"Kfvcpi_set_edge_count"
			VALUE
			0x7B0D2
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Kfvcpi_t_offset_learn_delay
			"Kfvcpi_t_offset_learn_delay"
			VALUE
			0x7B108
			DATA_RECORD_UWORD
			4194.24
			F_0v064_p0_283
			0
			4194.24
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Kfvcpi_t_zero_set_time
			"Kfvcpi_t_zero_set_time"
			VALUE
			0x7B10A
			DATA_RECORD_UWORD
			4194.24
			F_0v064_p0_283
			0
			4194.24
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Kfvcpi_u_reference_voltage
			"Kfvcpi_u_reference_voltage"
			VALUE
			0x7B10C
			DATA_RECORD_UWORD
			65.535
			F_0v001_p0_284
			0
			65.535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Lmbavaba
			"Cons_tension_so2dw_banc"
			VALUE
			0x755AC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Lmbavama
			"Cons_tension_so2dw_man"
			VALUE
			0x755AD
			DATA_RECORD_UBYTE
			2488.8
			F_9v76_p0_45
			0
			2488.8
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Lshd_dw_current_slewrate_neg_
			"Lshd_dw_current_slewrate_neg"
			VALUE
			0x78454
			DATA_RECORD_UWORD
			319.8108
			F_0v00488_p0_285
			0
			319.8108
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Lshd_dw_current_slewrate_pos_
			"Lshd_dw_current_slewrate_pos"
			VALUE
			0x78456
			DATA_RECORD_UWORD
			319.8108
			F_0v00488_p0_285
			0
			319.8108
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Lshd_dw_current_voltage_maxi_
			"Lshd_dw_current_voltage_maxi"
			VALUE
			0x78458
			DATA_RECORD_UWORD
			319.8108
			F_0v00488_p0_285
			0
			319.8108
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Lshd_dw_current_voltage_mini_
			"Lshd_dw_current_voltage_mini"
			VALUE
			0x7845A
			DATA_RECORD_UWORD
			319.8108
			F_0v00488_p0_285
			0
			319.8108
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Lshd_dw_engine_running_delay_
			"Lshd_dw_engine_running_delay"
			VALUE
			0x783B9
			DATA_RECORD_UBYTE
			1044480
			F_4096_p0_286
			0
			1044480
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Lshd_dw_off_diag_delay_
			"Lshd_dw_off_diag_delay"
			VALUE
			0x783BA
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Lshd_up_current_slewrate_neg_
			"Lshd_up_current_slewrate_neg"
			VALUE
			0x7845C
			DATA_RECORD_UWORD
			319.8108
			F_0v00488_p0_285
			0
			319.8108
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Lshd_up_current_slewrate_pos_
			"Lshd_up_current_slewrate_pos"
			VALUE
			0x7845E
			DATA_RECORD_UWORD
			319.8108
			F_0v00488_p0_285
			0
			319.8108
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Lshd_up_current_voltage_maxi_
			"Lshd_up_current_voltage_maxi"
			VALUE
			0x78460
			DATA_RECORD_UWORD
			319.8108
			F_0v00488_p0_285
			0
			319.8108
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Lshd_up_current_voltage_mini_
			"Lshd_up_current_voltage_mini"
			VALUE
			0x78462
			DATA_RECORD_UWORD
			319.8108
			F_0v00488_p0_285
			0
			319.8108
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Lshd_up_engine_running_delay_
			"Lshd_up_engine_running_delay"
			VALUE
			0x783BB
			DATA_RECORD_UBYTE
			1044.48
			F_4v096_p0_12
			0
			1044.48
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Lshd_up_off_diag_delay_
			"Lshd_up_off_diag_delay"
			VALUE
			0x78464
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Mode_deterministe_
			"Mode_deterministe"
			VALUE
			0x71E32
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Navban
			"Seuil_reg_banc_avance"
			VALUE
			0x71D1B
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Nmaxtxko
			"N_txnok_max"
			VALUE
			0x71F21
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ntibanc
			"Ntibanc"
			VALUE
			0x75946
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Nxx_rams_pow_tq_trs_ac
			"Nxx_rams_pow_tq_trs_ac"
			VALUE
			0x7952D
			DATA_RECORD_UBYTE
			12.75
			F_0v05_p0_287
			0
			12.75
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ofban
			"Offset_general_avance_banc"
			VALUE
			0x70FD1
			DATA_RECORD_SBYTE
			95.625
			F_0v375_p0_29
			-48
			47.625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ofdbmyba
			"Offset_dble_boucle_moy_ban"
			VALUE
			0x75947
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ofdbmyma
			"Offset_dble_boucle_moy_man"
			VALUE
			0x75964
			DATA_RECORD_SWORD
			65535
			Id_0x00
			-32768
			32767
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Offset_asic_k
			"Offset_asic_k"
			VALUE
			0x72652
			DATA_RECORD_UWORD
			5119.921875
			F_0v078125_p0_288
			0
			5119.921875
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Offset_avance_banc_
			"Offset_avance_banc"
			CURVE
			0x70FCD
			DATA_RECORD_SBYTE
			95.625
			F_0v375_p0_29
			-48
			47.625
			/begin AXIS_DESCR FIX_AXIS
				NO_INPUT_QUANTITY
				Id_0x00
				4
				0
				3
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 1 4
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ofsthban
			"Offset_sonde_banc"
			VALUE
			0x75948
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ofsthman
			"Offset_sonde_manu"
			VALUE
			0x75966
			DATA_RECORD_SWORD
			65535
			Id_0x00
			-32768
			32767
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Pap_posoff
			"Pap_posoff"
			VALUE
			0x79096
			DATA_RECORD_UWORD
			6399.88596
			F_0v097656_p0_5
			0
			6399.88596
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Pap_poson
			"Pap_poson"
			VALUE
			0x79098
			DATA_RECORD_UWORD
			6399.88596
			F_0v097656_p0_5
			0
			6399.88596
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Pcrcoban
			"Purge_can_en_mode_banc"
			VALUE
			0x787BC
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Periode_mini_signal_vitesse_
			"Periode_mini_signal_vitesse"
			VALUE
			0x7902F
			DATA_RECORD_UBYTE
			13.056
			F_0v0512_p0_290
			0
			13.056
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Periode_signal_vitesse_3kmh
			"Periode_signal_vitesse_3kmh"
			VALUE
			0x79042
			DATA_RECORD_UWORD
			3355.392
			F_0v0512_p0_290
			0
			3355.392
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Periode_vvt_adm_cal
			"Periode_vvt_adm_cal"
			VALUE
			0x7B10E
			DATA_RECORD_UWORD
			209.712
			F_0v0032_p0_8
			0
			209.712
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Periode_wastegate_turbo
			"Periode_wastegate_turbo"
			VALUE
			0x7B0C2
			DATA_RECORD_UWORD
			209.712
			F_0v0032_p0_8
			0
			209.712
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Pgcban
			"Cons_rel_ouv_vanne_egr_ban"
			VALUE
			0x78A68
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Pres_admission_ad_conv_gain
			"Pres_admission_ad_conv_gain"
			VALUE
			0x7874A
			DATA_RECORD_UWORD
			3788.742188
			F_0v0578125_p0_291
			0
			3788.742188
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Pres_admission_ad_conv_offset
			"Pres_admission_ad_conv_offset"
			VALUE
			0x7873C
			DATA_RECORD_SWORD
			60619.875
			F_0v925_p0_245
			-30310.4
			30309.475
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Pres_mastervac_ad_conv_gain
			"Pres_mastervac_ad_conv_gain"
			VALUE
			0x78486
			DATA_RECORD_UWORD
			3788.742188
			F_0v0578125_p0_291
			0
			3788.742188
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Pres_mastervac_ad_conv_offset
			"Pres_mastervac_ad_conv_offset"
			VALUE
			0x78484
			DATA_RECORD_SWORD
			60619.875
			F_0v925_p0_245
			-30310.4
			30309.475
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Pres_mastervac_max
			"Pres_mastervac_max"
			VALUE
			0x78488
			DATA_RECORD_UWORD
			319995.1172
			F_4v8828125_p0_11
			0
			319995.1172
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Pres_mastervac_min
			"Pres_mastervac_min"
			VALUE
			0x7848A
			DATA_RECORD_UWORD
			319995.1172
			F_4v8828125_p0_11
			0
			319995.1172
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Pres_sural_ad_conv_gain
			"Pres_sural_ad_conv_gain"
			VALUE
			0x7B0C4
			DATA_RECORD_UWORD
			3788.742188
			F_0v0578125_p0_291
			0
			3788.742188
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Pres_sural_ad_conv_offset
			"Pres_sural_ad_conv_offset"
			VALUE
			0x7ADF2
			DATA_RECORD_SWORD
			60619.875
			F_0v925_p0_245
			-30310.4
			30309.475
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Rco_max_purge_
			"Rco_max_purge"
			VALUE
			0x787BD
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Rco_min_purge_
			"Rco_min_purge"
			VALUE
			0x787BE
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Rcoban
			"Rco_banc_moteur"
			VALUE
			0x73AD8
			DATA_RECORD_UBYTE
			99.45
			F_0v39_p0_292
			0
			99.45
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Recurrence_misfire_deterministe_
			"Recurrence_misfire_deterministe"
			VALUE
			0x71E33
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Refmesag
			"Version_messagerie_can"
			VALUE
			0x73238
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Regime_dwell_demarrage_hyst_bas_
			"Regime_dwell_demarrage_hyst_bas"
			VALUE
			0x71E34
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Regime_dwell_demarrage_hyst_haut
			"Regime_dwell_demarrage_hyst_haut"
			VALUE
			0x71E35
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Regime_min_durees_dents_
			"Regime_min_durees_dents"
			VALUE
			0x73186
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Rgmnvsc
			"Regime_moteur_mini_vsc"
			VALUE
			0x720E6
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Rmc_pedal_pos_defaut_thresh
			"Rmc_pedal_pos_defaut_thresh"
			VALUE
			0x78FF9
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Rmc_throttle_pos_defaut_thresh
			"Rmc_throttle_pos_defaut_thresh"
			VALUE
			0x78FFA
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Rrcobanc
			"Phase_rco_banc"
			VALUE
			0x73AD7
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Sdf_limp_home_position_thresh_
			"Sdf_limp_home_position_thresh"
			VALUE
			0x79012
			DATA_RECORD_UWORD
			6399.88596
			F_0v097656_p0_5
			0
			6399.88596
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Sens_rco_vvt_adm
			"Sens_rco_vvt_adm"
			VALUE
			0x7B0D3
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Serievl
