			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_pow_lbdw_mfo
			"Cbx_schd_pow_lbdw_mfo"
			VALUE
			0x707EB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_pow_lbdw_pf
			"Cbx_schd_pow_lbdw_pf"
			VALUE
			0x703FE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_pow_lbdw_vf
			"Cbx_schd_pow_lbdw_vf"
			VALUE
			0x70601
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_pow_lbup_mfo
			"Cbx_schd_pow_lbup_mfo"
			VALUE
			0x707EC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_pow_lbup_pf
			"Cbx_schd_pow_lbup_pf"
			VALUE
			0x703FF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_pow_lbup_vf
			"Cbx_schd_pow_lbup_vf"
			VALUE
			0x70602
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_ptc_pf
			"Cbx_schd_ptc_pf"
			VALUE
			0x70400
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_ptc_rov_pf
			"Cbx_schd_ptc_rov_pf"
			VALUE
			0x70401
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_pws_pf
			"Cbx_schd_pws_pf"
			VALUE
			0x70402
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_rams_pdl_mfo
			"Cbx_schd_rams_pdl_mfo"
			VALUE
			0x707ED
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_rams_pdl_pf
			"Cbx_schd_rams_pdl_pf"
			VALUE
			0x70404
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_rams_pdl_vf
			"Cbx_schd_rams_pdl_vf"
			VALUE
			0x70603
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_rams_pf
			"Cbx_schd_rams_pf"
			VALUE
			0x70403
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_reserve_3_pf
			"Cbx_schd_reserve_3_pf"
			VALUE
			0x70405
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_rmc_pf
			"Cbx_schd_rmc_pf"
			VALUE
			0x70406
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_sa_ev_mfo
			"Cbx_schd_sa_ev_mfo"
			VALUE
			0x706A2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_sa_ev_pf
			"Cbx_schd_sa_ev_pf"
			VALUE
			0x70408
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_sa_ev_vf
			"Cbx_schd_sa_ev_vf"
			VALUE
			0x705D2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_sa_mfo
			"Cbx_schd_sa_mfo"
			VALUE
			0x706A1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_sa_pf
			"Cbx_schd_sa_pf"
			VALUE
			0x70407
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_sa_vf
			"Cbx_schd_sa_vf"
			VALUE
			0x705D1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_spg_mfo
			"Cbx_schd_spg_mfo"
			VALUE
			0x707EE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_spg_pf
			"Cbx_schd_spg_pf"
			VALUE
			0x70409
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_spg_sys_mfo
			"Cbx_schd_spg_sys_mfo"
			VALUE
			0x707EF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_spg_sys_pf
			"Cbx_schd_spg_sys_pf"
			VALUE
			0x7040A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_spg_sys_vf
			"Cbx_schd_spg_sys_vf"
			VALUE
			0x70605
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_spg_vf
			"Cbx_schd_spg_vf"
			VALUE
			0x70604
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_spi_cc_pf
			"Cbx_schd_spi_cc_pf"
			VALUE
			0x7040B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_svkl_pf
			"Cbx_schd_svkl_pf"
			VALUE
			0x7040C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_swlk_pf
			"Cbx_schd_swlk_pf"
			VALUE
			0x7040D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_tco_mfo
			"Cbx_schd_tco_mfo"
			VALUE
			0x706A3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_tco_pf
			"Cbx_schd_tco_pf"
			VALUE
			0x7040E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_tco_vf
			"Cbx_schd_tco_vf"
			VALUE
			0x705D3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_thpl_pf
			"Cbx_schd_thpl_pf"
			VALUE
			0x7040F
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_thr_cmd_pf
			"Cbx_schd_thr_cmd_pf"
			VALUE
			0x70411
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_thr_pf
			"Cbx_schd_thr_pf"
			VALUE
			0x70410
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_tia_mfo
			"Cbx_schd_tia_mfo"
			VALUE
			0x706A4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_tia_pf
			"Cbx_schd_tia_pf"
			VALUE
			0x70412
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_tia_vf
			"Cbx_schd_tia_vf"
			VALUE
			0x705D4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_tjy_ctl_pf
			"Cbx_schd_tjy_ctl_pf"
			VALUE
			0x70413
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_tlz_ad_b_mfo
			"Cbx_schd_tlz_ad_b_mfo"
			VALUE
			0x707F0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_tlz_ad_b_pf
			"Cbx_schd_tlz_ad_b_pf"
			VALUE
			0x70414
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_tlz_ad_b_vf
			"Cbx_schd_tlz_ad_b_vf"
			VALUE
			0x70606
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_vb_pf
			"Cbx_schd_vb_pf"
			VALUE
			0x70415
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_vs_mfo
			"Cbx_schd_vs_mfo"
			VALUE
			0x706A5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_vs_pf
			"Cbx_schd_vs_pf"
			VALUE
			0x70416
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_vs_vf
			"Cbx_schd_vs_vf"
			VALUE
			0x705D5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_vta_intake_mfo
			"Cbx_schd_vta_intake_mfo"
			VALUE
			0x706A6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_vta_intake_pf
			"Cbx_schd_vta_intake_pf"
			VALUE
			0x70417
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_vta_intake_vf
			"Cbx_schd_vta_intake_vf"
			VALUE
			0x705D6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_vvt_int_ev_mfo
			"Cbx_schd_vvt_int_ev_mfo"
			VALUE
			0x706A7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_vvt_int_ev_pf
			"Cbx_schd_vvt_int_ev_pf"
			VALUE
			0x70419
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_vvt_int_ev_vf
			"Cbx_schd_vvt_int_ev_vf"
			VALUE
			0x705D7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_vvt_int_old_off_mfo
			"Cbx_schd_vvt_int_old_off_mfo"
			VALUE
			0x707F1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_vvt_int_old_off_vf
			"Cbx_schd_vvt_int_old_off_vf"
			VALUE
			0x70607
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_vvt_int_pf
			"Cbx_schd_vvt_int_pf"
			VALUE
			0x70418
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_vvt_intake_mfo
			"Cbx_schd_vvt_intake_mfo"
			VALUE
			0x706A8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_vvt_intake_pf
			"Cbx_schd_vvt_intake_pf"
			VALUE
			0x7041A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_vvt_intake_vf
			"Cbx_schd_vvt_intake_vf"
			VALUE
			0x705D8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_vvtc_toth_3_mfo
			"Cbx_schd_vvtc_toth_3_mfo"
			VALUE
			0x707F2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_vvtc_toth_3_pf
			"Cbx_schd_vvtc_toth_3_pf"
			VALUE
			0x7041B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_vvtc_toth_3_vf
			"Cbx_schd_vvtc_toth_3_vf"
			VALUE
			0x70608
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_wat_temp_pf
			"Cbx_schd_wat_temp_pf"
			VALUE
			0x7041C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_wgc_mfo
			"Cbx_schd_wgc_mfo"
			VALUE
			0x706A9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_wgc_pf
			"Cbx_schd_wgc_pf"
			VALUE
			0x7041D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_wgc_vf
			"Cbx_schd_wgc_vf"
			VALUE
			0x705D9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_schd_wpmp_pf
			"Cbx_schd_wpmp_pf"
			VALUE
			0x7041E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sfg_bch
			"Cbx_sfg_bch"
			VALUE
			0x74877
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_shift_diag_ena_typ
			"Cbx_shift_diag_ena_typ"
			VALUE
			0x73241
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_shift_mcut_diag_manu_inh
			"Cbx_shift_mcut_diag_manu_inh"
			VALUE
			0x73242
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_shift_pdl_chr_diag_manu_inh
			"Cbx_shift_pdl_chr_diag_manu_inh"
			VALUE
			0x73243
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_shift_svkl_diag_manu_inh
			"Cbx_shift_svkl_diag_manu_inh"
			VALUE
			0x73244
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_shift_thr_chr_diag_manu_inh
			"Cbx_shift_thr_chr_diag_manu_inh"
			VALUE
			0x73245
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_spg_bch_mod
			"Cbx_spg_bch_mod"
			VALUE
			0x7AC49
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_spg_i_ini_req
			"Cbx_spg_i_ini_req"
			VALUE
			0x731AD
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_spg_tq_off_mod
			"Cbx_spg_tq_off_mod"
			VALUE
			0x7AC4A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_swlk_dsb
			"Cbx_swlk_dsb"
			VALUE
			0x70D14
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_sys_wf_conf
			"Cbx_sys_wf_conf"
			VALUE
			0x78D6C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_thpl_conf
			"Cbx_thpl_conf"
			VALUE
			0x790A0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_thr_ar_cor_dsb
			"Cbx_thr_ar_cor_dsb"
			VALUE
			0x76FA8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_thr_ar_h_lim_dsb
			"Cbx_thr_ar_h_lim_dsb"
			VALUE
			0x76FA9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_thr_ar_l_lim_dsb
			"Cbx_thr_ar_l_lim_dsb"
			VALUE
			0x76FAA
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_thr_bch
			"Cbx_thr_bch"
			VALUE
			0x790FB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_thr_bch_auto
			"Cbx_thr_bch_auto"
			VALUE
			0x73246
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_thr_dft_ini_req
			"Cbx_thr_dft_ini_req"
			VALUE
			0x731AE
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_thr_dyn_bch
			"Cbx_thr_dyn_bch"
			VALUE
			0x790FC
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_thr_mcut_ena
			"Cbx_thr_mcut_ena"
			VALUE
			0x73247
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_thr_sge_ena
			"Cbx_thr_sge_ena"
			VALUE
			0x73248
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_thr_typ_select
			"Cbx_thr_typ_select"
			VALUE
			0x73249
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_thr_vdo_pwm_select
			"Cbx_thr_vdo_pwm_select"
			VALUE
			0x7324A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_ti_cl2_conf
			"Cbx_ti_cl2_conf"
			VALUE
			0x74878
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_tlz_ad_b1_fil_req
			"Cbx_tlz_ad_b1_fil_req"
			VALUE
			0x731AF
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_tlz_ad_b2_fil_req
			"Cbx_tlz_ad_b2_fil_req"
			VALUE
			0x731B0
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_tlz_ad_cor_conf
			"Cbx_tlz_ad_cor_conf"
			VALUE
			0x7311D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_tlz_ad_cor_fil_req
			"Cbx_tlz_ad_cor_fil_req"
			VALUE
			0x731B1
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_tlz_ad_cor_val_req
			"Cbx_tlz_ad_cor_val_req"
			VALUE
			0x731B2
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_toil_bch_mod
			"Cbx_toil_bch_mod"
			VALUE
			0x76FB8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_tot_dft_ini_req
			"Cbx_tot_dft_ini_req"
			VALUE
			0x731B3
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_tot_dyn_iga_cor_dsb
			"Cbx_tot_dyn_iga_cor_dsb"
			VALUE
			0x76FAB
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_tq_abst_agb_aj_dsb
			"Cbx_tq_abst_agb_aj_dsb"
			VALUE
			0x790FD
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_tq_dft_ini_req
			"Cbx_tq_dft_ini_req"
			VALUE
			0x731B4
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_tq_ini_req
			"Cbx_tq_ini_req"
			VALUE
			0x731B5
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_trt_fil_dsb
			"Cbx_trt_fil_dsb"
			VALUE
			0x7360E
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_trz_ad_b1_fil_req
			"Cbx_trz_ad_b1_fil_req"
			VALUE
			0x731B6
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_trz_ad_b1_val_req
			"Cbx_trz_ad_b1_val_req"
			VALUE
			0x731B7
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_trz_ad_b2_fil_req
			"Cbx_trz_ad_b2_fil_req"
			VALUE
			0x731B8
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_trz_ad_b2_val_req
			"Cbx_trz_ad_b2_val_req"
			VALUE
			0x731B9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_tsta_conf
			"Cbx_tsta_conf"
			VALUE
			0x7909C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_up_thr_prs_sens
			"Cbx_up_thr_prs_sens"
			VALUE
			0x7AC4B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_vs_mux
			"Cbx_vs_mux"
			VALUE
			0x79018
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_vvtc_pwm_bch
			"Cbx_vvtc_pwm_bch"
			VALUE
			0x7B0C9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_wet_bch_mod
			"Cbx_wet_bch_mod"
			VALUE
			0x74879
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_wet_prs_eal_swi_mod
			"Cbx_wet_prs_eal_swi_mod"
			VALUE
			0x7487A
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_wet_stat_cor_bch_mod
			"Cbx_wet_stat_cor_bch_mod"
			VALUE
			0x7487B
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_wet_tb_cor_bch_mod
			"Cbx_wet_tb_cor_bch_mod"
			VALUE
			0x7487C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_wet_ti_cut_bch_mod
			"Cbx_wet_ti_cut_bch_mod"
			VALUE
			0x7487D
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_wpmp_conf
			"Cbx_wpmp_conf"
			VALUE
			0x7848C
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_wup_fil_tq_dsb
			"Cbx_wup_fil_tq_dsb"
			VALUE
			0x70FD9
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cbx_wup_stop_ac
			"Cbx_wup_stop_ac"
			VALUE
			0x70E18
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cfgphaac
			"Config_log_memophasage"
			VALUE
			0x731BA
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cfgpsobd
			"Config_passerelle_active"
			VALUE
			0x72128
			DATA_RECORD_UBYTE
			1
			Bool_ON_OFF
			0
			1
			BIT_MASK 0x1
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Chauf_gpl_current_slewrate_neg
			"Chauf_gpl_current_slewrate_neg"
			VALUE
			0x783BC
			DATA_RECORD_UWORD
			319995.1172
			F_4v8828125_p0_11
			0
			319995.1172
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Chauf_gpl_current_slewrate_pos
			"Chauf_gpl_current_slewrate_pos"
			VALUE
			0x783BE
			DATA_RECORD_UWORD
			319995.1172
			F_4v8828125_p0_11
			0
			319995.1172
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Chauf_gpl_current_voltage_maxi
			"Chauf_gpl_current_voltage_maxi"
			VALUE
			0x783C0
			DATA_RECORD_UWORD
			319995.1172
			F_4v8828125_p0_11
			0
			319995.1172
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Chauf_gpl_current_voltage_mini
			"Chauf_gpl_current_voltage_mini"
			VALUE
			0x783C2
			DATA_RECORD_UWORD
			319995.1172
			F_4v8828125_p0_11
			0
			319995.1172
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Chauf_gpl_plus_slewrate_neg
			"Chauf_gpl_plus_slewrate_neg"
			VALUE
			0x783C4
			DATA_RECORD_UWORD
			319995.1172
			F_4v8828125_p0_11
			0
			319995.1172
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Chauf_gpl_plus_slewrate_pos
			"Chauf_gpl_plus_slewrate_pos"
			VALUE
			0x783C6
			DATA_RECORD_UWORD
			319995.1172
			F_4v8828125_p0_11
			0
			319995.1172
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Chauf_gpl_running_delay
			"Chauf_gpl_running_delay"
			VALUE
			0x78383
			DATA_RECORD_UBYTE
			1044.48
			F_4v096_p0_12
			0
			1044.48
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_acel_aj_fil_fac_form
			"Cmp_acel_aj_fil_fac_form"
			MAP
			0x79572
			DATA_RECORD_UWORD
			1023.984375
			F_0v015625_p0_13
			0
			1023.984375
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				9
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n_aj
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_tq_rat_sp
				F_0v390625_p0_4
				9
				0
				99.609375
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_tq_rat_sp
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_agb_sli_tq
			"Cmp_agb_sli_tq"
			MAP
			0x71F42
			DATA_RECORD_UWORD
			511.9921875
			F_0v0078125_p0_15
			0
			511.9921875
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				8
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_agb_sli_tq_eng_n
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_agb_sli
				F_0v78125_p0_16
				16
				0
				199.21875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_agb_sli
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_alt_n_fac1
			"Cmp_alt_n_fac1"
			MAP
			0x790FE
			DATA_RECORD_UBYTE
			4.98046875
			F_0v01953125_p0_17
			0
			4.98046875
			/begin AXIS_DESCR COM_AXIS
				Vxx_alt_n
				F_1_p0_14
				13
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_alt_n
			/end AXIS_DESCR
			/begin AXIS_DESCR FIX_AXIS
				Vxx_alt_typ
				Id_0x00
				4
				1
				4
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 1 1 4
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_alt_n_fac2
			"Cmp_alt_n_fac2"
			MAP
			0x79132
			DATA_RECORD_UBYTE
			7.96875
			F_0v03125_m5_18
			-5
			2.96875
			/begin AXIS_DESCR COM_AXIS
				Vxx_alt_n
				F_1_p0_14
				13
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_alt_n
			/end AXIS_DESCR
			/begin AXIS_DESCR FIX_AXIS
				Vxx_alt_typ
				Id_0x00
				4
				1
				4
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 1 1 4
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_alt_n_lim
			"Cmp_alt_n_lim"
			MAP
			0x79166
			DATA_RECORD_UBYTE
			19.921875
			F_0v078125_p0_19
			0
			19.921875
			/begin AXIS_DESCR COM_AXIS
				Vxx_alt_n
				F_1_p0_14
				13
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_alt_n
			/end AXIS_DESCR
			/begin AXIS_DESCR FIX_AXIS
				Vxx_alt_typ
				Id_0x00
				4
				1
				4
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 1 1 4
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_alti_n_max_tqi_cor
			"Cmp_alti_n_max_tqi_cor"
			MAP
			0x7919A
			DATA_RECORD_UBYTE
			0.99609375
			F_0v00390625_p0v5_20
			0.5
			1.49609375
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				9
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n3
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_alti
				F_3v7_p0_21
				5
				0
				943.5
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_eng_alti
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_decl_aj_fil_fac_form
			"Cmp_decl_aj_fil_fac_form"
			MAP
			0x79614
			DATA_RECORD_UWORD
			1023.984375
			F_0v015625_p0_13
			0
			1023.984375
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				9
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n_aj
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_tq_rat_sp
				F_0v390625_p0_4
				9
				0
				99.609375
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_tq_rat_sp
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_det_thd_tlz_dif
			"Cmp_det_thd_tlz_dif"
			MAP
			0x77740
			DATA_RECORD_UWORD
			6553.5
			F_0v1_p0_22
			0
			6553.5
			/begin AXIS_DESCR COM_AXIS
				Vxx_eal_tdc_2
				F_0v0061035156_p0_23
				17
				0
				399.9938965
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_dft_comb_eal
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_prev2_n
				F_1_p0_14
				17
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_mis_n_17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_det_thd_tlz_dif_agb
			"Cmp_det_thd_tlz_dif_agb"
			MAP
			0x77982
			DATA_RECORD_UWORD
			6553.5
			F_0v1_p0_22
			0
			6553.5
			/begin AXIS_DESCR COM_AXIS
				Vxx_eal_tdc_2
				F_0v0061035156_p0_23
				17
				0
				399.9938965
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_dft_comb_eal
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_prev2_n
				F_1_p0_14
				17
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_mis_n_17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_det_thd_tlz_dif_lpg
			"Cmp_det_thd_tlz_dif_lpg"
			MAP
			0x77BC4
			DATA_RECORD_UWORD
			6553.5
			F_0v1_p0_22
			0
			6553.5
			/begin AXIS_DESCR COM_AXIS
				Vxx_eal_tdc_2
				F_0v0061035156_p0_23
				17
				0
				399.9938965
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_dft_comb_eal
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_prev2_n
				F_1_p0_14
				17
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_mis_n_17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_eal_n_lpg_cor_otl_iga
			"Cmp_eal_n_lpg_cor_otl_iga"
			MAP
			0x73C20
			DATA_RECORD_UBYTE
			95.625
			F_0v375_m23v625_6
			-23.625
			72
			/begin AXIS_DESCR COM_AXIS
				Vxx_eal
				F_0v0061035156_p0_23
				16
				0
				399.9938965
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_eal1
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				20
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n1
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_eal_n_min_iga_cor
			"Cmp_eal_n_min_iga_cor"
			MAP
			0x73D60
			DATA_RECORD_UBYTE
			95.625
			F_0v375_m23v625_6
			-23.625
			72
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				9
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n2
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_eal
				F_0v0061035156_p0_23
				9
				0
				399.9938965
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_eal2
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_eal_n_min_iga_cor_lpg
			"Cmp_eal_n_min_iga_cor_lpg"
			MAP
			0x73DB1
			DATA_RECORD_UBYTE
			95.625
			F_0v375_m23v625_6
			-23.625
			72
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				9
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n2
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_eal
				F_0v0061035156_p0_23
				9
				0
				399.9938965
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_eal2
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_eal_n_vvtc_off_otl_iga
			"Cmp_eal_n_vvtc_off_otl_iga"
			MAP
			0x73E02
			DATA_RECORD_UBYTE
			95.625
			F_0v375_m23v625_6
			-23.625
			72
			/begin AXIS_DESCR COM_AXIS
				Vxx_eal
				F_0v0061035156_p0_23
				16
				0
				399.9938965
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_eal1
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				20
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n1
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_eal_n_vvtc_on_otl_iga
			"Cmp_eal_n_vvtc_on_otl_iga"
			MAP
			0x73F42
			DATA_RECORD_UBYTE
			95.625
			F_0v375_m23v625_6
			-23.625
			72
			/begin AXIS_DESCR COM_AXIS
				Vxx_eal
				F_0v0061035156_p0_23
				16
				0
				399.9938965
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_eal1
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				20
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n1
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_eal_n_vvtc_otl_iga
			"Cmp_eal_n_vvtc_otl_iga"
			MAP
			0x74082
			DATA_RECORD_UBYTE
			95.625
			F_0v375_m23v625_6
			-23.625
			72
			/begin AXIS_DESCR COM_AXIS
				Vxx_eal
				F_0v0061035156_p0_23
				16
				0
				399.9938965
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_eal1
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				20
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n1
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_eal_tco_cart_iga_cor
			"Cmp_eal_tco_cart_iga_cor"
			MAP
			0x70FDA
			DATA_RECORD_UBYTE
			95.625
			F_0v375_m48_24
			-48
			47.625
			/begin AXIS_DESCR COM_AXIS
				Vxx_eal
				F_0v0061035156_p0_23
				16
				0
				399.9938965
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_eal1
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_tco
				F_0v625_m40_25
				16
				-40
				119.375
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_tco
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_ex_prs_dif_fac
			"Cmp_ex_prs_dif_fac"
			MAP
			0x7AC4C
			DATA_RECORD_UBYTE
			483072
			F_1894v4_p0_26
			0
			483072
			/begin AXIS_DESCR COM_AXIS
				Vxx_cor_pump_maf
				F_0v0000152588_p0_27
				9
				0
				0.9999847412
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_pump_maf
			/end AXIS_DESCR
			/begin AXIS_DESCR FIX_AXIS
				Vxx_spg_pwm_sp
				F_0v390625_p0_4
				9
				0
				100
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_gear_cge_tq_min_ofs
			"Cmp_gear_cge_tq_min_ofs"
			MAP
			0x710DA
			DATA_RECORD_UBYTE
			127.5
			F_0v5_p0_28
			0
			127.5
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				9
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n_gear_cge
			/end AXIS_DESCR
			/begin AXIS_DESCR FIX_AXIS
				Vxx_gear_mem
				Id_0x00
				8
				0
				7
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 1 8
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_iga_tco_cor
			"Cmp_iga_tco_cor"
			MAP
			0x741C2
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
			/begin AXIS_DESCR COM_AXIS
				Vxx_tco
				F_0v625_m40_25
				16
				-40
				119.375
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_tco
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_eal
				F_0v0061035156_p0_23
				9
				0
				399.9938965
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_eal2
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_iga_tco_cor_lpg
			"Cmp_iga_tco_cor_lpg"
			MAP
			0x74252
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
			/begin AXIS_DESCR COM_AXIS
				Vxx_tco
				F_0v625_m40_25
				16
				-40
				119.375
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_tco
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_eal
				F_0v0061035156_p0_23
				9
				0
				399.9938965
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_eal2
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_iga_tq_min
			"Cmp_iga_tq_min"
			MAP
			0x742E2
			DATA_RECORD_UBYTE
			95.625
			F_0v375_m23v625_6
			-23.625
			72
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				9
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n2
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_eal
				F_0v0061035156_p0_23
				9
				0
				399.9938965
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_eal2
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_iga_tq_min_lpg
			"Cmp_iga_tq_min_lpg"
			MAP
			0x74333
			DATA_RECORD_UBYTE
			95.625
			F_0v375_m23v625_6
			-23.625
			72
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				9
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n2
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_eal
				F_0v0061035156_p0_23
				9
				0
				399.9938965
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_eal2
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_min_iga
			"Cmp_min_iga"
			MAP
			0x74384
			DATA_RECORD_UBYTE
			95.625
			F_0v375_m23v625_6
			-23.625
			72
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				9
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n2
			/end AXIS_DESCR
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tia
				F_0v625_m40_25
				17
				-40
				120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 16 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_mis_cata_degr
			"Cmp_mis_cata_degr"
			MAP
			0x7702A
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_eal_tdc_2
				F_0v0061035156_p0_23
				17
				0
				399.9938965
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_dft_comb_eal
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_prev2_n
				F_1_p0_14
				17
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_mis_n_17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_mis_cata_degr_1
			"Cmp_mis_cata_degr_1"
			MAP
			0x7714B
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_eal_tdc_2
				F_0v0061035156_p0_23
				17
				0
				399.9938965
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_dft_comb_eal
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_prev2_n
				F_1_p0_14
				17
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_mis_n_17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_mis_iga_dif
			"Cmp_mis_iga_dif"
			MAP
			0x7726C
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
			/begin AXIS_DESCR COM_AXIS
				Vxx_eal_tdc_2
				F_0v0061035156_p0_23
				17
				0
				399.9938965
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_dft_comb_eal
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				20
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_mis_tlz_cor_cyl_0
			"Cmp_mis_tlz_cor_cyl_0"
			MAP
			0x77E06
			DATA_RECORD_UWORD
			6553.5
			F_0v1_m3276v7_31
			-3276.7
			3276.8
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				9
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_mis_tlz_cor_n
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_eal_tdc_2
				F_0v0061035156_p0_23
				9
				0
				399.9938965
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_mis_tlz_cor_eal
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_mis_tlz_cor_cyl_0_lpg
			"Cmp_mis_tlz_cor_cyl_0_lpg"
			MAP
			0x77EA8
			DATA_RECORD_UWORD
			6553.5
			F_0v1_m3276v7_31
			-3276.7
			3276.8
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				9
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_mis_tlz_cor_n_lpg
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_eal_tdc_2
				F_0v0061035156_p0_23
				9
				0
				399.9938965
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_mis_tlz_cor_eal_lpg
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_mis_tlz_cor_cyl_1
			"Cmp_mis_tlz_cor_cyl_1"
			MAP
			0x77F4A
			DATA_RECORD_UWORD
			6553.5
			F_0v1_m3276v7_31
			-3276.7
			3276.8
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				9
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_mis_tlz_cor_n
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_eal_tdc_2
				F_0v0061035156_p0_23
				9
				0
				399.9938965
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_mis_tlz_cor_eal
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_mis_tlz_cor_cyl_1_lpg
			"Cmp_mis_tlz_cor_cyl_1_lpg"
			MAP
			0x77FEC
			DATA_RECORD_UWORD
			6553.5
			F_0v1_m3276v7_31
			-3276.7
			3276.8
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				9
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_mis_tlz_cor_n_lpg
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_eal_tdc_2
				F_0v0061035156_p0_23
				9
				0
				399.9938965
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_mis_tlz_cor_eal_lpg
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_mis_tlz_cor_cyl_2
			"Cmp_mis_tlz_cor_cyl_2"
			MAP
			0x7808E
			DATA_RECORD_UWORD
			6553.5
			F_0v1_m3276v7_31
			-3276.7
			3276.8
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				9
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_mis_tlz_cor_n
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_eal_tdc_2
				F_0v0061035156_p0_23
				9
				0
				399.9938965
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_mis_tlz_cor_eal
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_mis_tlz_cor_cyl_2_lpg
			"Cmp_mis_tlz_cor_cyl_2_lpg"
			MAP
			0x78130
			DATA_RECORD_UWORD
			6553.5
			F_0v1_m3276v7_31
			-3276.7
			3276.8
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				9
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_mis_tlz_cor_n_lpg
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_eal_tdc_2
				F_0v0061035156_p0_23
				9
				0
				399.9938965
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_mis_tlz_cor_eal_lpg
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_mis_tq_dif_1_2_dz_1
			"Cmp_mis_tq_dif_1_2_dz_1"
			MAP
			0x773C0
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_eal_tdc_2
				F_0v0061035156_p0_23
				5
				0
				399.9938965
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_dft_comb_eal2_lpg
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_prev2_n
				F_1_p0_14
				5
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_dft_comb_n2_lpg
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_mis_tq_dif_1_4_dz_1
			"Cmp_mis_tq_dif_1_4_dz_1"
			MAP
			0x773D9
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_eal_tdc_2
				F_0v0061035156_p0_23
				5
				0
				399.9938965
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_dft_comb_eal2_lpg
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_prev2_n
				F_1_p0_14
				5
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_dft_comb_n2_lpg
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_mis_tq_dif_fac_1_2
			"Cmp_mis_tq_dif_fac_1_2"
			MAP
			0x773F2
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_eal_tdc_2
				F_0v0061035156_p0_23
				5
				0
				399.9938965
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_dft_comb_eal2
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_prev2_n
				F_1_p0_14
				5
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_dft_comb_n2
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_mis_tq_dif_fac_1_2_1
			"Cmp_mis_tq_dif_fac_1_2_1"
			MAP
			0x7740B
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_eal_tdc_2
				F_0v0061035156_p0_23
				5
				0
				399.9938965
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_dft_comb_eal2_lpg
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_prev2_n
				F_1_p0_14
				5
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_dft_comb_n2_lpg
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_mis_tq_dif_fac_1_2_dz
			"Cmp_mis_tq_dif_fac_1_2_dz"
			MAP
			0x77424
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_eal_tdc_2
				F_0v0061035156_p0_23
				5
				0
				399.9938965
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_dft_comb_eal2
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_prev2_n
				F_1_p0_14
				5
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_dft_comb_n2
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_mis_tq_dif_fac_1_4
			"Cmp_mis_tq_dif_fac_1_4"
			MAP
			0x7743D
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_eal_tdc_2
				F_0v0061035156_p0_23
				5
				0
				399.9938965
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_dft_comb_eal2
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_prev2_n
				F_1_p0_14
				5
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_dft_comb_n2
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_mis_tq_dif_fac_1_4_1
			"Cmp_mis_tq_dif_fac_1_4_1"
			MAP
			0x77456
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_eal_tdc_2
				F_0v0061035156_p0_23
				5
				0
				399.9938965
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_dft_comb_eal2_lpg
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_prev2_n
				F_1_p0_14
				5
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_dft_comb_n2_lpg
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_mis_tq_dif_fac_1_4_dz
			"Cmp_mis_tq_dif_fac_1_4_dz"
			MAP
			0x7746F
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_eal_tdc_2
				F_0v0061035156_p0_23
				5
				0
				399.9938965
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_dft_comb_eal2
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_prev2_n
				F_1_p0_14
				5
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_dft_comb_n2
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_mis_tq_dif_fac_intm
			"Cmp_mis_tq_dif_fac_intm"
			MAP
			0x77488
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_eal_tdc_2
				F_0v0061035156_p0_23
				5
				0
				399.9938965
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_dft_comb_eal2
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_prev2_n
				F_1_p0_14
				5
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_dft_comb_n2
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_mis_tq_dif_fac_intm_1
			"Cmp_mis_tq_dif_fac_intm_1"
			MAP
			0x774A1
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_eal_tdc_2
				F_0v0061035156_p0_23
				5
				0
				399.9938965
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_dft_comb_eal2_lpg
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_prev2_n
				F_1_p0_14
				5
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_dft_comb_n2_lpg
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_mis_tq_dif_intm_dz
			"Cmp_mis_tq_dif_intm_dz"
			MAP
			0x774BA
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_eal_tdc_2
				F_0v0061035156_p0_23
				5
				0
				399.9938965
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_dft_comb_eal2
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_prev2_n
				F_1_p0_14
				5
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_dft_comb_n2
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_mis_tq_dif_intm_dz_1
			"Cmp_mis_tq_dif_intm_dz_1"
			MAP
			0x774D3
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_eal_tdc_2
				F_0v0061035156_p0_23
				5
				0
				399.9938965
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_dft_comb_eal2_lpg
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_prev2_n
				F_1_p0_14
				5
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_dft_comb_n2_lpg
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_n_eal_fl_rich_sp
			"Cmp_n_eal_fl_rich_sp"
			MAP
			0x75968
			DATA_RECORD_UWORD
			170.664281
			F_0v00260417_p0v667_32
			0.667
			171.331281
			/begin AXIS_DESCR COM_AXIS
				Vxx_eal
				F_0v0061035156_p0_23
				11
				0
				399.9938965
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_eal_fl
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				20
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_n_eal_fl_rich_sp_lpg
			"Cmp_n_eal_fl_rich_sp_lpg"
			MAP
			0x75B20
			DATA_RECORD_UWORD
			170.664281
			F_0v00260417_p0v667_32
			0.667
			171.331281
			/begin AXIS_DESCR COM_AXIS
				Vxx_eal
				F_0v0061035156_p0_23
				11
				0
				399.9938965
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_eal_fl
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				20
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_n_eal_fl_thd
			"Cmp_n_eal_fl_thd"
			MAP
			0x75CD8
			DATA_RECORD_UWORD
			399.9938965
			F_0v0061035156_p0_23
			0
			399.9938965
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				20
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_tco
				F_0v625_m40_25
				13
				-40
				119.375
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_tco_cl_off
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_n_eal_fl_thd_lpg
			"Cmp_n_eal_fl_thd_lpg"
			MAP
			0x75EE0
			DATA_RECORD_UWORD
			399.9938965
			F_0v0061035156_p0_23
			0
			399.9938965
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				20
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_tco
				F_0v625_m40_25
				13
				-40
				119.375
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_tco_cl_off
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_n_eal_lpg_cor_iga
			"Cmp_n_eal_lpg_cor_iga"
			MAP
			0x71122
			DATA_RECORD_UBYTE
			95.625
			F_0v375_m23v625_6
			-23.625
			72
			/begin AXIS_DESCR COM_AXIS
				Vxx_eal
				F_0v0061035156_p0_23
				16
				0
				399.9938965
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_eal1
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				20
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n1
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_n_eal_max_iga_ofs
			"Cmp_n_eal_max_iga_ofs"
			MAP
			0x7441D
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_33
			0
			95.625
			/begin AXIS_DESCR COM_AXIS
				Vxx_eal
				F_0v0061035156_p0_23
				16
				0
				399.9938965
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_eal1
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				20
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n1
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_n_eal_otl_tqi_fac
			"Cmp_n_eal_otl_tqi_fac"
			MAP
			0x796B6
			DATA_RECORD_UWORD
			25599.60938
			F_0v390625_p0_4
			0
			25599.60938
			/begin AXIS_DESCR COM_AXIS
				Vxx_eal
				F_0v0061035156_p0_23
				16
				0
				399.9938965
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_eal1
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				9
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n2
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_n_eal_otl_tqi_fac_lpg
			"Cmp_n_eal_otl_tqi_fac_lpg"
			MAP
			0x797D6
			DATA_RECORD_UWORD
			25599.60938
			F_0v390625_p0_4
			0
			25599.60938
			/begin AXIS_DESCR COM_AXIS
				Vxx_eal
				F_0v0061035156_p0_23
				16
				0
				399.9938965
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_eal1
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				9
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n2
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_n_eal_tia_fil_fac
			"Cmp_n_eal_tia_fil_fac"
			MAP
			0x7487E
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_eal
				F_0v0061035156_p0_23
				9
				0
				399.9938965
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_eal2
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				9
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n2
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_n_eal_vvtc_iga
			"Cmp_n_eal_vvtc_iga"
			MAP
			0x71262
			DATA_RECORD_UBYTE
			95.625
			F_0v375_m23v625_34
			-23.625
			72
			/begin AXIS_DESCR COM_AXIS
				Vxx_eal
				F_0v0061035156_p0_23
				16
				0
				399.9938965
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_eal1
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				20
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n1
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_n_eal_vvtc_off_iga
			"Cmp_n_eal_vvtc_off_iga"
			MAP
			0x713A2
			DATA_RECORD_UBYTE
			95.625
			F_0v375_m23v625_6
			-23.625
			72
			/begin AXIS_DESCR COM_AXIS
				Vxx_eal
				F_0v0061035156_p0_23
				16
				0
				399.9938965
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_eal1
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				20
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n1
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_n_eal_vvtc_on_iga
			"Cmp_n_eal_vvtc_on_iga"
			MAP
			0x714E2
			DATA_RECORD_UBYTE
			95.625
			F_0v375_m23v625_6
			-23.625
			72
			/begin AXIS_DESCR COM_AXIS
				Vxx_eal
				F_0v0061035156_p0_23
				16
				0
				399.9938965
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_eal1
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				20
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n1
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_n_gear_gear_cge_l_tq
			"Cmp_n_gear_gear_cge_l_tq"
			MAP
			0x798F6
			DATA_RECORD_UWORD
			511.9921875
			F_0v0078125_m100_35
			-100
			411.9921875
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				9
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n_gear_cge
			/end AXIS_DESCR
			/begin AXIS_DESCR FIX_AXIS
				Vxx_gear_mem
				Id_0x00
				8
				0
				7
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 1 8
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_n_gear_lim_tq
			"Cmp_n_gear_lim_tq"
			MAP
			0x791C7
			DATA_RECORD_UBYTE
			510
			F_2_m100_36
			-100
			410
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				20
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n
			/end AXIS_DESCR
			/begin AXIS_DESCR FIX_AXIS
				Vxx_gear
				Id_0x00
				8
				0
				7
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 1 8
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_n_map_bch_appl_iga
			"Cmp_n_map_bch_appl_iga"
			MAP
			0x7455D
			DATA_RECORD_UBYTE
			95.625
			F_0v375_m23v625_6
			-23.625
			72
			/begin AXIS_DESCR COM_AXIS
				Vxx_map
				F_3v7_p103_37
				17
				103
				242582.5
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_map
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				20
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n1
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_n_map_fill_efv
			"Cmp_n_map_fill_efv"
			MAP
			0x748CF
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_map
				F_3v7_p103_37
				17
				103
				242582.5
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_map
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				20
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n1
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_n_map_fill_efv_lpg
			"Cmp_n_map_fill_efv_lpg"
			MAP
			0x74A23
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_map
				F_3v7_p103_37
				17
				103
				242582.5
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_map
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				20
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n1
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_n_map_fill_efv_vvt
			"Cmp_n_map_fill_efv_vvt"
			MAP
			0x74B77
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_map
				F_3v7_p103_37
				17
				103
				242582.5
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_map
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				20
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n1
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_n_map_fl_rich_sp
			"Cmp_n_map_fl_rich_sp"
			MAP
			0x760E8
			DATA_RECORD_UWORD
			170.664281
			F_0v00260417_p0v667_32
			0.667
			171.331281
			/begin AXIS_DESCR COM_AXIS
				Vxx_map
				F_3v7_p103_37
				11
				103
				242582.5
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_map_fl
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				20
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_n_map_ol_rich_sp
			"Cmp_n_map_ol_rich_sp"
			MAP
			0x762A0
			DATA_RECORD_UWORD
			170.664281
			F_0v00260417_p0v66667_38
			0.66667
			171.330951
			/begin AXIS_DESCR COM_AXIS
				Vxx_map
				F_3v7_p103_37
				5
				103
				242582.5
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_map_ol
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				5
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n_ol
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_n_map_ol_rich_sp_lpg
			"Cmp_n_map_ol_rich_sp_lpg"
			MAP
			0x762D2
			DATA_RECORD_UWORD
			170.664281
			F_0v00260417_p0v66667_38
			0.66667
			171.330951
			/begin AXIS_DESCR COM_AXIS
				Vxx_map
				F_3v7_p103_37
				5
				103
				242582.5
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_map_ol
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				5
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n_ol
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_n_pdl_fac_frm_pdl
			"Cmp_n_pdl_fac_frm_pdl"
			MAP
			0x78D6D
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				20
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n1
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_driv_slow_eng_tq
				F_0v0078125_m100_35
				17
				-100
				411.9921875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_eng_tq
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_n_prs_aj_fast_tq_fac
			"Cmp_n_prs_aj_fast_tq_fac"
			MAP
			0x71622
			DATA_RECORD_UBYTE
			15.9375
			F_0v0625_p0_39
			0
			15.9375
			/begin AXIS_DESCR COM_AXIS
				Vxx_map
				F_3v7_p103_37
				17
				103
				242582.5
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_map
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				20
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_n_prs_eai_ti_cor
			"Cmp_n_prs_eai_ti_cor"
			MAP
			0x74CCB
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_eal
				F_0v0061035156_p0_23
				9
				0
				399.9938965
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_eal_eai
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				9
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n_eai
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_n_prs_fl_thd
			"Cmp_n_prs_fl_thd"
			MAP
			0x76304
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				20
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_tco
				F_0v625_m40_25
				13
				-40
				119.375
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_tco_cl_off
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_n_prs_knk_cyl14_fac
			"Cmp_n_prs_knk_cyl14_fac"
			MAP
			0x7224A
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_map
				F_3v7_p103_37
				17
				103
				242582.5
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_map
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				20
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_n_prs_knk_cyl23_fac
			"Cmp_n_prs_knk_cyl23_fac"
			MAP
			0x7239E
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_map
				F_3v7_p103_37
				17
				103
				242582.5
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_map
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				20
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_n_prs_lean_ti_cor
			"Cmp_n_prs_lean_ti_cor"
			MAP
			0x74D1C
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_map
				F_3v7_p103_37
				17
				103
				242582.5
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_map
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				20
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_n_prs_tco_ti_fac2
			"Cmp_n_prs_tco_ti_fac2"
			MAP
			0x74E70
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_map
				F_3v7_p103_37
				17
				103
				242582.5
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_map
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				20
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_n_prs_vvt
			"Cmp_n_prs_vvt"
			MAP
			0x71776
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_map_rat
				F_0v390625_p0_4
				9
				0
				100
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				9
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_vvt_n
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_n_toil
			"Cmp_n_toil"
			MAP
			0x76FB9
			DATA_RECORD_UBYTE
			255
			F_1_m40_40
			-40
			215
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				6
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n4
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_eal
				F_0v0061035156_p0_23
				6
				0
				399.9938965
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_eal3
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_n_tq_cart_h_iga_cor
			"Cmp_n_tq_cart_h_iga_cor"
			MAP
			0x717C7
			DATA_RECORD_UBYTE
			95.625
			F_0v375_m48_41
			-48
			47.625
			/begin AXIS_DESCR COM_AXIS
				Vxx_cata_wup_rel_tq
				F_0v390625_p0_4
				9
				0
				99.609375
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_rel_tq_wup
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				9
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n_wup
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_n_tq_cart_iga_cor1
			"Cmp_n_tq_cart_iga_cor1"
			MAP
			0x71818
			DATA_RECORD_UBYTE
			95.625
			F_0v375_m48_41
			-48
			47.625
			/begin AXIS_DESCR COM_AXIS
				Vxx_cata_wup_rel_tq
				F_0v390625_p0_4
				9
				0
				99.609375
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_rel_tq_wup
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				9
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n_wup
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_n_tq_cart_l_iga_cor
			"Cmp_n_tq_cart_l_iga_cor"
			MAP
			0x71869
			DATA_RECORD_UBYTE
			95.625
			F_0v375_m48_41
			-48
			47.625
			/begin AXIS_DESCR COM_AXIS
				Vxx_cata_wup_rel_tq
				F_0v390625_p0_4
				9
				0
				99.609375
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_rel_tq_wup
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				9
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n_wup
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_n_tq_lpg_wup_iga_cor
			"Cmp_n_tq_lpg_wup_iga_cor"
			MAP
			0x718BA
			DATA_RECORD_UBYTE
			95.625
			F_0v375_m48_41
			-48
			47.625
			/begin AXIS_DESCR COM_AXIS
				Vxx_cata_wup_rel_tq
				F_0v390625_p0_4
				9
				0
				99.609375
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_rel_tq_wup
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				9
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n_wup
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_n_tq_lpg_wup_iga_cor1
			"Cmp_n_tq_lpg_wup_iga_cor1"
			MAP
			0x7190B
			DATA_RECORD_UBYTE
			95.625
			F_0v375_m48_41
			-48
			47.625
			/begin AXIS_DESCR COM_AXIS
				Vxx_cata_wup_rel_tq
				F_0v390625_p0_4
				9
				0
				99.609375
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_rel_tq_wup
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				9
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n_wup
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_n_tq_vvtc_hot_in_angl
			"Cmp_n_tq_vvtc_hot_in_angl"
			MAP
			0x7351F
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_33
			0
			95.625
			/begin AXIS_DESCR COM_AXIS
				Vxx_tq_rat_sp
				F_0v390625_p0_4
				9
				0
				99.609375
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_tq
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				20
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_vvt_n2
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_otl_iga_tco_cor
			"Cmp_otl_iga_tco_cor"
			MAP
			0x746B1
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
			/begin AXIS_DESCR COM_AXIS
				Vxx_eal
				F_0v0061035156_p0_23
				16
				0
				399.9938965
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_eal1
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_tco
				F_0v625_m40_25
				16
				-40
				119.375
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_tco
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_pdl_n_driv_abv_tqe
			"Cmp_pdl_n_driv_abv_tqe"
			MAP
			0x79986
			DATA_RECORD_UWORD
			511.9921875
			F_0v0078125_m100_35
			-100
			411.9921875
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				20
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n
			/end AXIS_DESCR
			/begin AXIS_DESCR FIX_AXIS
				Vxx_fmt_pdl_psn_rat
				F_0v001526_p0_42
				17
				0
				100.007936
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 4096 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_prs_dif_ti_cor
			"Cmp_prs_dif_ti_cor"
			MAP
			0x7650C
			DATA_RECORD_UWORD
			203.1585
			F_0v0031_m101v5808_43
			-101.5808
			101.5777
			/begin AXIS_DESCR COM_AXIS
				Vxx_prs_dif
				F_3v7_m2841v6_44
				17
				-2841.6
				239637.9
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_prs_dif
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				20
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n1
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_prs_n_lamb_v
			"Cmp_prs_n_lamb_v"
			MAP
			0x74FC4
			DATA_RECORD_UBYTE
			2488.8
			F_9v76_p0_45
			0
			2488.8
			/begin AXIS_DESCR FIX_AXIS
				Vxx_n32
				F_32_p0_46
				9
				800
				4896
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 25 16 9
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_map
				F_3v7_p103_37
				17
				103
				242582.5
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_map
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_prs_n_lamb_v_lpg
			"Cmp_prs_n_lamb_v_lpg"
			MAP
			0x7505D
			DATA_RECORD_UBYTE
			2488.8
			F_9v76_p0_45
			0
			2488.8
			/begin AXIS_DESCR FIX_AXIS
				Vxx_n32
				F_32_p0_46
				9
				800
				4896
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 25 16 9
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_map
				F_3v7_p103_37
				17
				103
				242582.5
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_map
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_prs_n_lean_cylr
			"Cmp_prs_n_lean_cylr"
			MAP
			0x750F6
			DATA_RECORD_UBYTE
			198.9
			F_0v78_m100_47
			-100
			98.9
			/begin AXIS_DESCR FIX_AXIS
				Vxx_n32
				F_32_p0_46
				9
				0
				8192
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_map2
				F_3v7_p103_37
				17
				103
				242582.5
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_map
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_prs_n_pwm_cp
			"Cmp_prs_n_pwm_cp"
			MAP
			0x787C0
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
			/begin AXIS_DESCR COM_AXIS
				Vxx_map
				F_3v7_p103_37
				17
				103
				242582.5
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_map
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				20
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_prs_n_rich_cylr
			"Cmp_prs_n_rich_cylr"
			MAP
			0x7518F
			DATA_RECORD_UBYTE
			198.9
			F_0v78_m100_47
			-100
			98.9
			/begin AXIS_DESCR FIX_AXIS
				Vxx_n32
				F_32_p0_46
				9
				0
				8192
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_map2
				F_3v7_p103_37
				17
				103
				242582.5
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_map
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_rams_frn_tq_loss
			"Cmp_rams_frn_tq_loss"
			MAP
			0x79267
			DATA_RECORD_UBYTE
			127.5
			F_0v5_p0_28
			0
			127.5
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				20
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n1
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_tco
				F_0v625_m40_25
				16
				-40
				119.375
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_tco
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_rams_lpg_esti_tqe
			"Cmp_rams_lpg_esti_tqe"
			MAP
			0x79C2E
			DATA_RECORD_UWORD
			511.9921875
			F_0v0078125_m100_35
			-100
			411.9921875
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				20
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n1
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_map
				F_3v7_p103_37
				17
				103
				242582.5
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_map
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_rams_map_n_esti_tqe
			"Cmp_rams_map_n_esti_tqe"
			MAP
			0x79ED6
			DATA_RECORD_UWORD
			511.9921875
			F_0v0078125_m100_35
			-100
			411.9921875
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				20
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n1
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_map
				F_3v7_p103_37
				17
				103
				242582.5
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_map
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_rams_pdl_n_abv_tqe
			"Cmp_rams_pdl_n_abv_tqe"
			MAP
			0x7A17E
			DATA_RECORD_UWORD
			511.9921875
			F_0v0078125_m100_35
			-100
			411.9921875
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				20
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n1
			/end AXIS_DESCR
			/begin AXIS_DESCR FIX_AXIS
				Vxx_rams_fmt_pdl_psn_rat
				F_0v0015258_p0_48
				17
				0
				99.9948288
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 4096 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_rams_pump_tq_loss
			"Cmp_rams_pump_tq_loss"
			MAP
			0x7A426
			DATA_RECORD_UWORD
			511.9921875
			F_0v0078125_m100_35
			-100
			411.9921875
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				20
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n1
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_map
				F_3v7_p103_37
				17
				103
				242582.5
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_map
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_spg_alti_cor
			"Cmp_spg_alti_cor"
			MAP
			0x7AC9D
			DATA_RECORD_UBYTE
			943.5
			F_3v7_p0_21
			0
			943.5
			/begin AXIS_DESCR COM_AXIS
				Vxx_alti
				F_3v7_p0_21
				5
				0
				943.5
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_alti
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_tq_stat_ref
				F_0v0078125_m100_35
				9
				-100
				411.9921875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_tq_stat_ref
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_spg_ol_pwm
			"Cmp_spg_ol_pwm"
			MAP
			0x7ACCA
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				9
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n3
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				NO_INPUT_QUANTITY
				F_7v4_p750_49
				9
				750
				2637
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_spg_ol_map_sp
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_spg_ol_pwm_thr_n
			"Cmp_spg_ol_pwm_thr_n"
			MAP
			0x7AD1B
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
			/begin AXIS_DESCR COM_AXIS
				Vxx_fil_thr_psn_sp
				F_0v097656_p0_5
				9
				0
				6399.88596
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_thr_psn
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				9
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n3
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_thr_ar_n_grd
			"Cmp_thr_ar_n_grd"
			MAP
			0x784CE
			DATA_RECORD_UWORD
			199.9970916
			F_0v00305176_p0_50
			0
			199.9970916
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				9
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n7
			/end AXIS_DESCR
			/begin AXIS_DESCR FIX_AXIS
				NO_INPUT_QUANTITY
				Id_0x00
				17
				0
				16
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 1 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_tia_iga_cor
			"Cmp_tia_iga_cor"
			MAP
			0x7195C
			DATA_RECORD_UBYTE
			95.625
			F_0v375_m48_24
			-48
			47.625
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				9
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n6
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_tia
				F_0v625_m40_25
				17
				-40
				119.375
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_tia_17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_tq_n_spg_fail_thd
			"Cmp_tq_n_spg_fail_thd"
			MAP
			0x7ADF4
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
			/begin AXIS_DESCR COM_AXIS
				Vxx_tq_stat_ref
				F_0v0078125_m100_35
				9
				-100
				411.9921875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_tq_stat_ref
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				20
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_vvt_fill_efv_cor_fac1
			"Cmp_vvt_fill_efv_cor_fac1"
			MAP
			0x767B4
			DATA_RECORD_UWORD
			114.5715638
			F_0v00174825_p0_51
			0
			114.5715638
			/begin AXIS_DESCR COM_AXIS
				Vxx_map
				F_3v7_p103_37
				17
				103
				242582.5
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_map
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				20
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n1
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_vvt_fill_efv_cor_fac2
			"Cmp_vvt_fill_efv_cor_fac2"
			MAP
			0x76A5C
			DATA_RECORD_UWORD
			2730.1881
			F_0v04166_m1365v1149_52
			-1365.1149
			1365.0732
			/begin AXIS_DESCR COM_AXIS
				Vxx_map
				F_3v7_p103_37
				17
				103
				242582.5
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_map
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				20
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n1
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_wet_eal_fil_fac_tco00
			"Cmp_wet_eal_fil_fac_tco00"
			MAP
			0x75228
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_eal
				F_0v0061035156_p0_23
				9
				0
				399.9938965
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_eal2
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				5
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_wet_n
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_wet_eal_fil_fac_tco20
			"Cmp_wet_eal_fil_fac_tco20"
			MAP
			0x75255
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_eal
				F_0v0061035156_p0_23
				9
				0
				399.9938965
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_eal2
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				5
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_wet_n
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_wet_eal_fil_fac_tco40
			"Cmp_wet_eal_fil_fac_tco40"
			MAP
			0x75282
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_eal
				F_0v0061035156_p0_23
				9
				0
				399.9938965
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_eal2
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				5
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_wet_n
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_wet_eal_fil_fac_tco60
			"Cmp_wet_eal_fil_fac_tco60"
			MAP
			0x752AF
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_eal
				F_0v0061035156_p0_23
				9
				0
				399.9938965
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_eal2
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				5
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_wet_n
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_wet_eal_fil_fac_tco80
			"Cmp_wet_eal_fil_fac_tco80"
			MAP
			0x752DC
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_eal
				F_0v0061035156_p0_23
				9
				0
				399.9938965
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_eal2
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				5
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_wet_n
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_wet_eal_vol_fac_tco00
			"Cmp_wet_eal_vol_fac_tco00"
			MAP
			0x75309
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_eal
				F_0v0061035156_p0_23
				9
				0
				399.9938965
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_eal2
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				5
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_wet_n
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_wet_eal_vol_fac_tco20
			"Cmp_wet_eal_vol_fac_tco20"
			MAP
			0x75336
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_eal
				F_0v0061035156_p0_23
				9
				0
				399.9938965
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_eal2
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				5
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_wet_n
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_wet_eal_vol_fac_tco40
			"Cmp_wet_eal_vol_fac_tco40"
			MAP
			0x75363
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_eal
				F_0v0061035156_p0_23
				9
				0
				399.9938965
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_eal2
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				5
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_wet_n
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_wet_eal_vol_fac_tco60
			"Cmp_wet_eal_vol_fac_tco60"
			MAP
			0x75390
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_eal
				F_0v0061035156_p0_23
				9
				0
				399.9938965
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_eal2
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				5
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_wet_n
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_wet_eal_vol_fac_tco80
			"Cmp_wet_eal_vol_fac_tco80"
			MAP
			0x753BD
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_eal
				F_0v0061035156_p0_23
				9
				0
				399.9938965
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_eal2
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				5
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_wet_n
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_wet_prs_fil_fac_tco00
			"Cmp_wet_prs_fil_fac_tco00"
			MAP
			0x753EA
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_pred_map
				F_3v7_p103_37
				9
				103
				242582.5
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_wet_cor_map
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				5
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_wet_n
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_wet_prs_fil_fac_tco20
			"Cmp_wet_prs_fil_fac_tco20"
			MAP
			0x75417
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_pred_map
				F_3v7_p103_37
				9
				103
				242582.5
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_wet_cor_map
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				5
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_wet_n
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_wet_prs_fil_fac_tco40
			"Cmp_wet_prs_fil_fac_tco40"
			MAP
			0x75444
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_pred_map
				F_3v7_p103_37
				9
				103
				242582.5
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_wet_cor_map
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				5
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_wet_n
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_wet_prs_fil_fac_tco60
			"Cmp_wet_prs_fil_fac_tco60"
			MAP
			0x75471
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_pred_map
				F_3v7_p103_37
				9
				103
				242582.5
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_wet_cor_map
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				5
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_wet_n
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_wet_prs_fil_fac_tco80
			"Cmp_wet_prs_fil_fac_tco80"
			MAP
			0x7549E
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_pred_map
				F_3v7_p103_37
				9
				103
				242582.5
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_wet_cor_map
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				5
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_wet_n
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_wet_prs_vol_fac_tco00
			"Cmp_wet_prs_vol_fac_tco00"
			MAP
			0x754CB
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_pred_map
				F_3v7_p103_37
				9
				103
				242582.5
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_wet_cor_map
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				5
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_wet_n
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_wet_prs_vol_fac_tco20
			"Cmp_wet_prs_vol_fac_tco20"
			MAP
			0x754F8
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_pred_map
				F_3v7_p103_37
				9
				103
				242582.5
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_wet_cor_map
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				5
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_wet_n
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_wet_prs_vol_fac_tco40
			"Cmp_wet_prs_vol_fac_tco40"
			MAP
			0x75525
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_pred_map
				F_3v7_p103_37
				9
				103
				242582.5
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_wet_cor_map
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				5
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_wet_n
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_wet_prs_vol_fac_tco60
			"Cmp_wet_prs_vol_fac_tco60"
			MAP
			0x75552
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_pred_map
				F_3v7_p103_37
				9
				103
				242582.5
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_wet_cor_map
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				5
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_wet_n
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmp_wet_prs_vol_fac_tco80
			"Cmp_wet_prs_vol_fac_tco80"
			MAP
			0x7557F
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_pred_map
				F_3v7_p103_37
				9
				103
				242582.5
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_wet_cor_map
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				5
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_wet_n
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmx_n_iga_tq_min_lih
			"Cmx_n_iga_tq_min_lih"
			MAP
			0x747B1
			DATA_RECORD_UBYTE
			95.625
			F_0v375_m23v625_34
			-23.625
			72
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				9
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n2
			/end AXIS_DESCR
			/begin AXIS_DESCR FIX_AXIS
				Vxx_lih_inj_act_nr
				Id_0x00
				3
				2
				4
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 2 1 3
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cmx_n_iga_tq_min_lih_lpg
			"Cmx_n_iga_tq_min_lih_lpg"
			MAP
			0x747CC
			DATA_RECORD_UBYTE
			95.625
			F_0v375_m23v625_34
			-23.625
			72
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				9
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n2
			/end AXIS_DESCR
			/begin AXIS_DESCR FIX_AXIS
				Vxx_lih_inj_act_nr
				Id_0x00
				3
				2
				4
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 2 1 3
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cnrztvl
			"Seuil_reset_vl"
			VALUE
			0x70D17
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Consigne_rco_vvt_adm_max
			"Consigne_rco_vvt_adm_max"
			VALUE
			0x7B0F8
			DATA_RECORD_UWORD
			6393.658824
			F_0v09756098_p0_55
			0
			6393.658824
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Consigne_rco_vvt_adm_min
			"Consigne_rco_vvt_adm_min"
			VALUE
			0x7B0FA
			DATA_RECORD_UWORD
			6393.658824
			F_0v09756098_p0_55
			0
			6393.658824
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Consigne_rco_wastegate_max
			"Consigne_rco_wastegate_max"
			VALUE
			0x7AD6C
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Consigne_rco_wastegate_min
			"Consigne_rco_wastegate_min"
			VALUE
			0x7AD6D
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Crash2ca
			"Second_octet_coherent_inj"
			VALUE
			0x71F22
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctb_cp_ad_fil
			"Ctb_cp_ad_fil"
			CURVE
			0x78791
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_cor_n
				F_16_p800_57
				9
				800
				4896
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctb_lbup_prs_min
			"Ctb_lbup_prs_min"
			CURVE
			0x7821C
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				10
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_lamb_diag_n
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctb_pred_map_max_prs_rat
			"Ctb_pred_map_max_prs_rat"
			VALUE
			0x78668
			DATA_RECORD_UWORD
			1999969.482
			F_30v517578125_p0_67
			0
			1999969.482
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctb_thr_ar
			"Ctb_thr_ar"
			CURVE
			0x70D4E
			DATA_RECORD_UWORD
			3906.187461
			F_0v0596046_p0_76
			0
			3906.187461
			/begin AXIS_DESCR COM_AXIS
				Vxx_fil_thr_pos_thr_adj
				F_0v097656_p0_5
				17
				0
				6399.88596
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctp_thr_ar_pos
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctd_fil_tq_ovn
			"Ctd_fil_tq_ovn"
			CURVE
			0x793BE
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
			/begin AXIS_DESCR FIX_AXIS
				Vxx_gear
				Id_0x00
				8
				0
				7
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 1 8
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctd_gear
			"Ctd_gear"
			CURVE
			0x78A82
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				NO_INPUT_QUANTITY
				Id_0x00
				7
				0
				6
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 1 7
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctd_gear_aj_fast_tq_fac
			"Ctd_gear_aj_fast_tq_fac"
			CURVE
			0x71A0F
			DATA_RECORD_UBYTE
			3.984375
			F_0v015625_p0_13
			0
			3.984375
			/begin AXIS_DESCR FIX_AXIS
				Vxx_gear
				Id_0x00
				8
				0
				7
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 1 8
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctd_gear_cart_dyn_n_thd
			"Ctd_gear_cart_dyn_n_thd"
			CURVE
			0x71A17
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
			/begin AXIS_DESCR FIX_AXIS
				Vxx_gear
				Id_0x00
				8
				0
				7
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 1 8
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctd_gear_dyn_iga_fil
			"Ctd_gear_dyn_iga_fil"
			CURVE
			0x71A1F
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_gear
				Id_0x00
				8
				0
				7
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 1 8
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctd_gear_inj_stop_n
			"Ctd_gear_inj_stop_n"
			CURVE
			0x78CD8
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
			/begin AXIS_DESCR FIX_AXIS
				Vxx_gear
				Id_0x00
				8
				0
				7
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 1 8
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctd_gear_inj_stop_n_dec
			"Ctd_gear_inj_stop_n_dec"
			CURVE
			0x78CE8
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
			/begin AXIS_DESCR FIX_AXIS
				Vxx_gear
				Id_0x00
				8
				0
				7
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 1 8
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctd_gear_max_n
			"Ctd_gear_max_n"
			CURVE
			0x78CF8
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
			/begin AXIS_DESCR FIX_AXIS
				Vxx_gear
				Id_0x00
				8
				0
				7
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 1 8
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctd_gear_pdl_psn
			"Ctd_gear_pdl_psn"
			CURVE
			0x7324B
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
			/begin AXIS_DESCR FIX_AXIS
				Vxx_gear
				Id_0x00
				8
				0
				7
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 1 8
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctd_gear_red_rat
			"Ctd_gear_red_rat"
			CURVE
			0x78EDA
			DATA_RECORD_UBYTE
			0.996081
			F_0v0039062_p0_79
			0
			0.996081
			/begin AXIS_DESCR FIX_AXIS
				Vxx_cru_sl_gear
				Id_0x00
				8
				0
				7
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 1 8
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctd_hys_n_ovn
			"Ctd_hys_n_ovn"
			CURVE
			0x793C6
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
			/begin AXIS_DESCR FIX_AXIS
				Vxx_gear
				Id_0x00
				8
				0
				7
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 1 8
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctd_lpg_typ_id
			"Ctd_lpg_typ_id"
			CURVE
			0x73753
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
			/begin AXIS_DESCR COM_AXIS
				Vxx_lpg_mv_ad_fac
				F_0v0015258789_m50_64
				3
				-50
				49.99847412
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_lpg_ad_fac
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctd_mis_n_max_thd_1_2
			"Ctd_mis_n_max_thd_1_2"
			CURVE
			0x73132
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tlz_ad_bkp
				Id_0x00
				7
				0
				6
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 1 7
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctd_n_iga_pred_prs_thd
			"Ctd_n_iga_pred_prs_thd"
			CURVE
			0x71D7C
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				20
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctd_n_iga_prs_thd
			"Ctd_n_iga_prs_thd"
			CURVE
			0x71DA4
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				20
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctd_n_max_tqi
			"Ctd_n_max_tqi"
			CURVE
			0x7A7BE
			DATA_RECORD_UWORD
			512.024955
			F_0v007813_p0_81
			0
			512.024955
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				20
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n1
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctd_n_max_tqi_lih
			"Ctd_n_max_tqi_lih"
			CURVE
			0x7A7E6
			DATA_RECORD_UWORD
			511.9921875
			F_0v0078125_p0_15
			0
			511.9921875
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				20
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n1
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctd_n_ovt_tqi_ofs
			"Ctd_n_ovt_tqi_ofs"
			CURVE
			0x7A80E
			DATA_RECORD_UWORD
			511.9921875
			F_0v0078125_p0_15
			0
			511.9921875
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				20
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n1
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctd_n_prs_trs_cor_iga
			"Ctd_n_prs_trs_cor_iga"
			CURVE
			0x71A27
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				20
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctd_ofs_psi_fac
			"Ctd_ofs_psi_fac"
			CURVE
			0x786B2
			DATA_RECORD_UWORD
			999984.7412
			F_15v2587890625_p0_68
			0
			999984.7412
			/begin AXIS_DESCR COM_AXIS
				Vxx_raw_mdl_map_spg_rat
				F_30v517578125_p0_67
				10
				0
				1999969.482
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_pred_map_prs_rat
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctd_slop_psi_fac
			"Ctd_slop_psi_fac"
			CURVE
			0x786C6
			DATA_RECORD_UWORD
			999984.7412
			F_m15v2587890625_p0_82
			-999984.7412
			0
			/begin AXIS_DESCR COM_AXIS
				Vxx_raw_mdl_map_spg_rat
				F_30v517578125_p0_67
				10
				0
				1999969.482
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_pred_map_prs_rat
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctd_t_rat_lbup_rest
			"Ctd_t_rat_lbup_rest"
			CURVE
			0x78384
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
			/begin AXIS_DESCR COM_AXIS
				Vxx_lbup_hot_t
				F_0v128_p0_75
				3
				0
				8388.48
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_t_lbup_hot_rest
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctd_t_rat_lbup_sta
			"Ctd_t_rat_lbup_sta"
			CURVE
			0x78387
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
			/begin AXIS_DESCR COM_AXIS
				Vxx_lbup_hot_t
				F_0v128_p0_75
				3
				0
				8388.48
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_t_lbup_hot_sta
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctd_tco_min_rest_cor
			"Ctd_tco_min_rest_cor"
			CURVE
			0x78A98
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tco
				F_0v625_m40_25
				9
				-20
				60
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 32 16 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctd_ti_ad_fac_cor
			"Ctd_ti_ad_fac_cor"
			CURVE
			0x76D8A
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
			/begin AXIS_DESCR FIX_AXIS
				Vxx_ti_zon_nr
				Id_0x00
				5
				0
				4
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 1 5
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctd_ti_ad_ofs_cor
			"Ctd_ti_ad_ofs_cor"
			CURVE
			0x76D94
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
			/begin AXIS_DESCR FIX_AXIS
				Vxx_ti_zon_nr
				Id_0x00
				5
				0
				4
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 1 5
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctd_ti_b_cor
			"Ctd_ti_b_cor"
			CURVE
			0x755CD
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_ti_zon_nr
				Id_0x00
				5
				0
				4
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 1 5
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctd_tlz_ad_b_ena
			"Ctd_tlz_ad_b_ena"
			VALUE
			0x7311E
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctd_ufld_rest_cor
			"Ctd_ufld_rest_cor"
			CURVE
			0x78AA1
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_rest_ufld_dly
				Id_0x00
				9
				0
				256
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_ac_dri_is_cor
			"Ctp_ac_dri_is_cor"
			CURVE
			0x73882
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_ac_pow
				F_20_p0_63
				9
				0
				5120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_ac_dri_tmp_is_cor
			"Ctp_ac_dri_tmp_is_cor"
			CURVE
			0x7388B
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_ac_pow
				F_20_p0_63
				9
				0
				5120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_ac_is_cor_appl_dly
			"Ctp_ac_is_cor_appl_dly"
			CURVE
			0x73894
			DATA_RECORD_UBYTE
			4080
			F_16_p0_10
			0
			4080
			/begin AXIS_DESCR FIX_AXIS
				Vxx_ac_pow
				F_20_p0_63
				9
				0
				5120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_ac_neut_is_cor
			"Ctp_ac_neut_is_cor"
			CURVE
			0x7389D
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_ac_pow
				F_20_p0_63
				9
				0
				5120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_ac_neut_tmp_is_cor
			"Ctp_ac_neut_tmp_is_cor"
			CURVE
			0x738A6
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_ac_pow
				F_20_p0_63
				9
				0
				5120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_ac_pow_dri_is_iga
			"Ctp_ac_pow_dri_is_iga"
			CURVE
			0x71A3B
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
			/begin AXIS_DESCR FIX_AXIS
				Vxx_ac_pow
				F_20_p0_63
				9
				0
				5120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_ac_pow_is_iga
			"Ctp_ac_pow_is_iga"
			CURVE
			0x71A44
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
			/begin AXIS_DESCR FIX_AXIS
				Vxx_ac_pow
				F_20_p0_63
				9
				0
				5120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_acel_aj_tqe_l_thd
			"Ctp_acel_aj_tqe_l_thd"
			CURVE
			0x7A836
			DATA_RECORD_UWORD
			511.9921875
			F_0v0078125_m100_35
			-100
			411.9921875
			/begin AXIS_DESCR FIX_AXIS
				Vxx_gear
				Id_0x00
				8
				0
				7
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 1 8
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_acel_aj_tqe_up_thd
			"Ctp_acel_aj_tqe_up_thd"
			CURVE
			0x7A846
			DATA_RECORD_UWORD
			511.9921875
			F_0v0078125_m100_35
			-100
			411.9921875
			/begin AXIS_DESCR FIX_AXIS
				Vxx_gear
				Id_0x00
				8
				0
				7
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 1 8
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_acel_n_ti_p_cor
			"Ctp_acel_n_ti_p_cor"
			CURVE
			0x755D2
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_cor_n
				F_16_p800_57
				9
				800
				4896
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_agb_tco_min_is_n
			"Ctp_agb_tco_min_is_n"
			CURVE
			0x78AB7
			DATA_RECORD_UBYTE
			4080
			F_16_p0_83
			0
			4080
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tco
				F_0v625_m40_25
				17
				-40
				120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 16 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_agb_toil_cor
			"Ctp_agb_toil_cor"
			CURVE
			0x71EB3
			DATA_RECORD_UBYTE
			3.984375
			F_0v015625_p0_13
			0
			3.984375
			/begin AXIS_DESCR COM_AXIS
				Vxx_mux_agb_toil
				F_1_m40_40
				8
				-40
				215
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_agb_toil
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_air_pump_sta_tdc_thd
			"Ctp_air_pump_sta_tdc_thd"
			CURVE
			0x7AFB0
			DATA_RECORD_UWORD
			65535
			F_1_p0_53
			0
			65535
			/begin AXIS_DESCR FIX_AXIS
				Vxx_sta_tco
				F_0v625_m40_25
				17
				-40
				120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 16 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_air_pump_stop_tdc_thd
			"Ctp_air_pump_stop_tdc_thd"
			CURVE
			0x7AFD2
			DATA_RECORD_UWORD
			65535
			F_1_p0_53
			0
			65535
			/begin AXIS_DESCR FIX_AXIS
				Vxx_sta_tco
				F_0v625_m40_25
				17
				-40
				120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 16 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_alt_dri_is_cor
			"Ctp_alt_dri_is_cor"
			CURVE
			0x738AF
			DATA_RECORD_UBYTE
			255
			F_1_p0_9
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_fil_alt_pow
				F_20_p0_63
				9
				0
				1310700
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_is_cor_alt_pow
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_alt_neut_is_cor
			"Ctp_alt_neut_is_cor"
			CURVE
			0x738B8
			DATA_RECORD_UBYTE
			255
			F_1_p0_9
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_fil_alt_pow
				F_20_p0_63
				9
				0
				1310700
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_is_cor_alt_pow
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_alti_sta_cor
			"Ctp_alti_sta_cor"
			CURVE
			0x738C1
			DATA_RECORD_UBYTE
			199.21875
			F_0v78125_p0_16
			0
			199.21875
			/begin AXIS_DESCR FIX_AXIS
				Vxx_alti
				F_3v7_p0_21
				9
				0
				473.6
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 16 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_amp_0_amp_rat
			"Ctp_amp_0_amp_rat"
			CURVE
			0x731E8
			DATA_RECORD_UBYTE
			255
			F_1_p0_9
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_alti_255
				F_3v7_p0_21
				7
				0
				943.5
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_amp_0_amp_rat_alti
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_bch_mod_cyc_nr
			"Ctp_bch_mod_cyc_nr"
			CURVE
			0x793CE
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_bch_mod_ctr
				Id_0x00
				16
				0
				15
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 1 16
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_bch_mod_dyn_inc
			"Ctp_bch_mod_dyn_inc"
			CURVE
			0x790C0
			DATA_RECORD_SBYTE
			15.9375
			F_0v0625_p0_84
			-8
			7.9375
			/begin AXIS_DESCR FIX_AXIS
				Vxx_bch_mod_ctr
				Id_0x00
				16
				0
				15
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 1 16
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_bch_mod_dyn_ofs
			"Ctp_bch_mod_dyn_ofs"
			CURVE
			0x79530
			DATA_RECORD_SWORD
			4095.9375
			F_0v0625_p0_84
			-2048
			2047.9375
			/begin AXIS_DESCR FIX_AXIS
				Vxx_bch_mod_ctr
				Id_0x00
				16
				0
				15
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 1 16
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_bch_mod_stat_inc
			"Ctp_bch_mod_stat_inc"
			CURVE
			0x790D0
			DATA_RECORD_SBYTE
			15.9375
			F_0v0625_p0_84
			-8
			7.9375
			/begin AXIS_DESCR FIX_AXIS
				Vxx_bch_mod_ctr
				Id_0x00
				16
				0
				15
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 1 16
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_bch_mod_stat_ofs
			"Ctp_bch_mod_stat_ofs"
			CURVE
			0x79550
			DATA_RECORD_SWORD
			4095.9375
			F_0v0625_p0_84
			-2048
			2047.9375
			/begin AXIS_DESCR FIX_AXIS
				Vxx_bch_mod_ctr
				Id_0x00
				16
				0
				15
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 1 16
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_cata_drag_red_hot_is_cor
			"Ctp_cata_drag_red_hot_is_cor"
			CURVE
			0x738CA
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_cata_wup_ctr
				F_1_p0_53
				17
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_is_cata_wup_ctr
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_cata_drag_red_sta_is_cor
			"Ctp_cata_drag_red_sta_is_cor"
			CURVE
			0x738DB
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_cata_wup_ctr
				F_1_p0_53
				17
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_is_cata_wup_ctr
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_cata_dri_hot_is_cor
			"Ctp_cata_dri_hot_is_cor"
			CURVE
			0x738EC
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_cata_wup_ctr
				F_1_p0_53
				17
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_is_cata_wup_ctr
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_cata_dri_sta_is_cor
			"Ctp_cata_dri_sta_is_cor"
			CURVE
			0x738FD
			DATA_RECORD_UBYTE
			-1
			Id_0x00
			0
			-1
			/begin AXIS_DESCR COM_AXIS
				Vxx_cata_wup_ctr
				F_1_p0_53
				17
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_is_cata_wup_ctr
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_cata_lbdw_max_maf
			"Ctp_cata_lbdw_max_maf"
			CURVE
			0x774EC
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_cata_maf_cata
				Id_0x00
				17
				0
				256
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 16 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_cata_neut_hot_is_cor
			"Ctp_cata_neut_hot_is_cor"
			CURVE
			0x7390E
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_cata_wup_ctr
				F_1_p0_53
				17
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_is_cata_wup_ctr
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_cata_neut_hot_is_cor1
			"Ctp_cata_neut_hot_is_cor1"
			CURVE
			0x7391F
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_cata_wup_ctr
				F_1_p0_53
				17
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_is_cata_wup_ctr
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_cata_neut_sta_is_cor
			"Ctp_cata_neut_sta_is_cor"
			CURVE
			0x73930
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_cata_wup_ctr
				F_1_p0_53
				17
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_is_cata_wup_ctr
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_cata_neut_sta_is_cor1
			"Ctp_cata_neut_sta_is_cor1"
			CURVE
			0x73941
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_cata_wup_ctr
				F_1_p0_53
				17
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_is_cata_wup_ctr
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_cata_ol_per_dly_maf
			"Ctp_cata_ol_per_dly_maf"
			CURVE
			0x774FD
			DATA_RECORD_UBYTE
			2040
			F_8_p0_56
			0
			2040
			/begin AXIS_DESCR FIX_AXIS
				Vxx_cata_maf_cata
				Id_0x00
				17
				0
				256
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 16 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_cata_wup_cold
			"Ctp_cata_wup_cold"
			CURVE
			0x70E1C
			DATA_RECORD_UWORD
			65535
			F_1_p0_53
			0
			65535
			/begin AXIS_DESCR FIX_AXIS
				Vxx_sta_tco
				F_0v625_m40_25
				17
				-20
				60
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 32 8 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_cata_wup_cold_lpg
			"Ctp_cata_wup_cold_lpg"
			CURVE
			0x70E3E
			DATA_RECORD_UWORD
			65535
			F_1_p0_53
			0
			65535
			/begin AXIS_DESCR FIX_AXIS
				Vxx_sta_tco
				F_0v625_m40_25
				17
				-20
				60
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 32 8 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_cata_wup_dstb
			"Ctp_cata_wup_dstb"
			CURVE
			0x70E60
			DATA_RECORD_UWORD
			65535
			F_1_p0_53
			0
			65535
			/begin AXIS_DESCR FIX_AXIS
				Vxx_sta_tco
				F_0v625_m40_25
				17
				-20
				60
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 32 8 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_cata_wup_dstb_lpg
			"Ctp_cata_wup_dstb_lpg"
			CURVE
			0x70E82
			DATA_RECORD_UWORD
			65535
			F_1_p0_53
			0
			65535
			/begin AXIS_DESCR FIX_AXIS
				Vxx_sta_tco
				F_0v625_m40_25
				17
				-20
				60
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 32 8 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_cata_wup_eai
			"Ctp_cata_wup_eai"
			CURVE
			0x70EA4
			DATA_RECORD_UWORD
			65535
			F_1_p0_53
			0
			65535
			/begin AXIS_DESCR FIX_AXIS
				Vxx_sta_tco
				F_0v625_m40_25
				17
				-20
				60
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 32 8 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_cata_wup_eng
			"Ctp_cata_wup_eng"
			CURVE
			0x70EC6
			DATA_RECORD_UWORD
			65535
			F_1_p0_53
			0
			65535
			/begin AXIS_DESCR FIX_AXIS
				Vxx_sta_tco
				F_0v625_m40_25
				17
				-20
				60
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 32 8 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_cata_wup_eng_lpg
			"Ctp_cata_wup_eng_lpg"
			CURVE
			0x70EE8
			DATA_RECORD_UWORD
			65535
			F_1_p0_53
			0
			65535
			/begin AXIS_DESCR FIX_AXIS
				Vxx_sta_tco
				F_0v625_m40_25
				17
				-20
				60
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 32 8 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_cata_wup_lean
			"Ctp_cata_wup_lean"
			CURVE
			0x70F0A
			DATA_RECORD_UWORD
			65535
			F_1_p0_53
			0
			65535
			/begin AXIS_DESCR FIX_AXIS
				Vxx_sta_tco
				F_0v625_m40_25
				17
				-20
				60
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 32 8 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_cata_wup_lean_lpg
			"Ctp_cata_wup_lean_lpg"
			CURVE
			0x70F2C
			DATA_RECORD_UWORD
			65535
			F_1_p0_53
			0
			65535
			/begin AXIS_DESCR FIX_AXIS
				Vxx_sta_tco
				F_0v625_m40_25
				17
				-20
				60
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 32 8 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_cl_is_lean_cylr
			"Ctp_cl_is_lean_cylr"
			CURVE
			0x755DB
			DATA_RECORD_UBYTE
			198.9
			F_0v78_m100_47
			-100
			98.9
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tco
				F_0v625_m40_25
				9
				-40
				120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_cl_is_rich_cylr
			"Ctp_cl_is_rich_cylr"
			CURVE
			0x755E4
			DATA_RECORD_UBYTE
			198.9
			F_0v78_m100_47
			-100
			98.9
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tco
				F_0v625_m40_25
				9
				-40
				120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_cl_lean_sta
			"Ctp_cl_lean_sta"
			CURVE
			0x76D9E
			DATA_RECORD_UWORD
			65535
			F_1_p0_53
			0
			65535
			/begin AXIS_DESCR FIX_AXIS
				Vxx_sta_tco
				F_0v625_m40_25
				9
				-40
				120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_cl_lean_stop
			"Ctp_cl_lean_stop"
			CURVE
			0x76DB0
			DATA_RECORD_UWORD
			65535
			F_1_p0_53
			0
			65535
			/begin AXIS_DESCR FIX_AXIS
				Vxx_sta_tco
				F_0v625_m40_25
				9
				-40
				120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_cold_drag_red_hot_is_cor
			"Ctp_cold_drag_red_hot_is_cor"
			CURVE
			0x73952
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_cata_wup_ctr
				F_1_p0_53
				17
				0
				8192
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 512 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_cold_drag_red_is_iga_cor
			"Ctp_cold_drag_red_is_iga_cor"
			CURVE
			0x71A4D
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
			/begin AXIS_DESCR FIX_AXIS
				Vxx_cata_wup_ctr
				F_1_p0_53
				17
				0
				8192
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 512 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_cold_drag_red_sta_is_cor
			"Ctp_cold_drag_red_sta_is_cor"
			CURVE
			0x73963
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_cata_wup_ctr
				F_1_p0_53
				17
				0
				8192
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 512 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_cold_dri_hot_is_cor
			"Ctp_cold_dri_hot_is_cor"
			CURVE
			0x73974
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_cata_wup_ctr
				F_1_p0_53
				17
				0
				8192
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 512 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_cold_dri_is_iga_cor
			"Ctp_cold_dri_is_iga_cor"
			CURVE
			0x71A5E
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
			/begin AXIS_DESCR FIX_AXIS
				Vxx_cata_wup_ctr
				F_1_p0_53
				17
				0
				8192
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 512 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_cold_dri_sta_is_cor
			"Ctp_cold_dri_sta_is_cor"
			CURVE
			0x73985
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_cata_wup_ctr
				F_1_p0_53
				17
				0
				8192
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 512 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_cold_neut_hot_is_cor
			"Ctp_cold_neut_hot_is_cor"
			CURVE
			0x73996
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_cata_wup_ctr
				F_1_p0_53
				17
				0
				8192
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 512 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_cold_neut_hot_is_cor1
			"Ctp_cold_neut_hot_is_cor1"
			CURVE
			0x739A7
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_cata_wup_ctr
				F_1_p0_53
				17
				0
				8192
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 512 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_cold_neut_is_iga_cor
			"Ctp_cold_neut_is_iga_cor"
			CURVE
			0x71A6F
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
			/begin AXIS_DESCR FIX_AXIS
				Vxx_cata_wup_ctr
				F_1_p0_53
				17
				0
				8192
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 512 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_cold_neut_is_iga_cor1
			"Ctp_cold_neut_is_iga_cor1"
			CURVE
			0x71A80
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
			/begin AXIS_DESCR FIX_AXIS
				Vxx_cata_wup_ctr
				F_1_p0_53
				17
				0
				8192
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 512 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_cold_neut_sta_is_cor
			"Ctp_cold_neut_sta_is_cor"
			CURVE
			0x739B8
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_cata_wup_ctr
				F_1_p0_53
				17
				0
				8192
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 512 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_cold_neut_sta_is_cor1
			"Ctp_cold_neut_sta_is_cor1"
			CURVE
			0x739C9
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_cata_wup_ctr
				F_1_p0_53
				17
				0
				8192
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 512 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_cold_tdc_agb_is_n_ofs
			"Ctp_cold_tdc_agb_is_n_ofs"
			CURVE
			0x78AC8
			DATA_RECORD_UBYTE
			4080
			F_16_p0_83
			0
			4080
			/begin AXIS_DESCR FIX_AXIS
				Vxx_cata_wup_ctr
				F_1_p0_53
				17
				0
				8192
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 512 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_cold_tdc_drag_red_is_n_ofs
			"Ctp_cold_tdc_drag_red_is_n_ofs"
			CURVE
			0x78AD9
			DATA_RECORD_UBYTE
			4080
			F_16_p0_83
			0
			4080
			/begin AXIS_DESCR FIX_AXIS
				Vxx_cata_wup_ctr
				F_1_p0_53
				17
				0
				8192
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 512 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_cold_tdc_pn_is_n_ofs
			"Ctp_cold_tdc_pn_is_n_ofs"
			CURVE
			0x78AEA
			DATA_RECORD_UBYTE
			4080
			F_16_p0_83
			0
			4080
			/begin AXIS_DESCR FIX_AXIS
				Vxx_cata_wup_ctr
				F_1_p0_53
				17
				0
				8192
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 512 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_comp_wup
			"Ctp_comp_wup"
			CURVE
			0x70F4E
			DATA_RECORD_UWORD
			65535
			F_1_p0_53
			0
			65535
			/begin AXIS_DESCR FIX_AXIS
				Vxx_sta_tco
				F_0v625_m40_25
				17
				-40
				120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 16 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_comp_wup_lpg
			"Ctp_comp_wup_lpg"
			CURVE
			0x70F70
			DATA_RECORD_UWORD
			65535
			F_1_p0_53
			0
			65535
			/begin AXIS_DESCR FIX_AXIS
				Vxx_sta_tco
				F_0v625_m40_25
				17
				-40
				120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 16 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_cp_load_fac_cor
			"Ctp_cp_load_fac_cor"
			CURVE
			0x793DE
			DATA_RECORD_UBYTE
			3.984375
			F_0v015625_p0_13
			0
			3.984375
			/begin AXIS_DESCR FIX_AXIS
				Vxx_cp_rich_cor
				Id_0x00
				9
				0
				65536
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 8192 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_cylr_prs_stab_dif
			"Ctp_cylr_prs_stab_dif"
			CURVE
			0x70CE4
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p0_21
			0
			242479.5
			/begin AXIS_DESCR COM_AXIS
				Vxx_map
				F_3v7_p103_37
				17
				103
				242582.5
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_map
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_decl_aj_tqe_l_thd
			"Ctp_decl_aj_tqe_l_thd"
			CURVE
			0x7A856
			DATA_RECORD_UWORD
			511.9921875
			F_0v0078125_m100_35
			-100
			411.9921875
			/begin AXIS_DESCR FIX_AXIS
				Vxx_gear
				Id_0x00
				8
				0
				7
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 1 8
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_decl_aj_tqe_up_thd
			"Ctp_decl_aj_tqe_up_thd"
			CURVE
			0x7A866
			DATA_RECORD_UWORD
			511.9921875
			F_0v0078125_m100_35
			-100
			411.9921875
			/begin AXIS_DESCR FIX_AXIS
				Vxx_gear
				Id_0x00
				8
				0
				7
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 1 8
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_decl_n_ti_p_cor
			"Ctp_decl_n_ti_p_cor"
			CURVE
			0x755ED
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_cor_n
				F_16_p800_57
				9
				800
				4896
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_drag_red_cata_is_iga_cor
			"Ctp_drag_red_cata_is_iga_cor"
			CURVE
			0x71A91
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
			/begin AXIS_DESCR COM_AXIS
				Vxx_cata_wup_ctr
				F_1_p0_53
				17
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_is_cata_wup_ctr
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_drag_tco_min_is_n
			"Ctp_drag_tco_min_is_n"
			CURVE
			0x78AFB
			DATA_RECORD_UBYTE
			4080
			F_16_p0_83
			0
			4080
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tco
				F_0v625_m40_25
				17
				-40
				120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 16 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_dri_cata_is_iga_cor
			"Ctp_dri_cata_is_iga_cor"
			CURVE
			0x71AA2
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
			/begin AXIS_DESCR COM_AXIS
				Vxx_cata_wup_ctr
				F_1_p0_53
				17
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_is_cata_wup_ctr
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_dyn_forc
			"Ctp_dyn_forc"
			CURVE
			0x78EE2
			DATA_RECORD_UBYTE
			6375
			F_25_p0_85
			0
			6375
			/begin AXIS_DESCR FIX_AXIS
				Vxx_cru_sl_vs
				F_0v01_p0_62
				17
				0
				655.36
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 4096 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_eai_rich_cl_ctr
			"Ctp_eai_rich_cl_ctr"
			CURVE
			0x70F92
			DATA_RECORD_UWORD
			65535
			F_1_p0_53
			0
			65535
			/begin AXIS_DESCR FIX_AXIS
				Vxx_sta_tco
				F_0v625_m40_25
				17
				-20
				60
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 32 8 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_eal_fac
			"Ctp_eal_fac"
			CURVE
			0x7A876
			DATA_RECORD_UWORD
			289.350132
			F_0v0044152_p0_86
			0
			289.350132
			/begin AXIS_DESCR COM_AXIS
				Vxx_map
				F_3v7_p103_37
				17
				103
				242582.5
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_map
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_eal_fl_ocl_ofs
			"Ctp_eal_fl_ocl_ofs"
			CURVE
			0x76DC2
			DATA_RECORD_UWORD
			399.9928725
			F_0v0061035_p0_87
			0
			399.9928725
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				20
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_el_csm_n_sp_ofs
			"Ctp_el_csm_n_sp_ofs"
			CURVE
			0x78B0C
			DATA_RECORD_UBYTE
			4080
			F_16_p0_83
			0
			4080
			/begin AXIS_DESCR FIX_AXIS
				Vxx_el_csm_ctr
				Id_0x00
				9
				0
				256
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_ex_gaz_prs_n_temp
			"Ctp_ex_gaz_prs_n_temp"
			MAP
			0x7750E
			DATA_RECORD_UBYTE
			1020
			F_4_m40_88
			-40
			980
			/begin AXIS_DESCR COM_AXIS
				Vxx_map
				F_3v7_p103_37
				17
				103
				242582.5
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_map
			/end AXIS_DESCR
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				20
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_ex_gaz_temp_ofs_maf
			"Ctp_ex_gaz_temp_ofs_maf"
			CURVE
			0x77662
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_maf_t
				Id_0x00
				17
				0
				256
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 16 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_ex_gaz_temp_ofs_maf_l
			"Ctp_ex_gaz_temp_ofs_maf_l"
			CURVE
			0x77673
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_maf_t
				Id_0x00
				17
				0
				256
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 16 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_ex_gaz_temp_ofs_vs
			"Ctp_ex_gaz_temp_ofs_vs"
			CURVE
			0x77684
			DATA_RECORD_UBYTE
			1020
			F_4_p0_89
			0
			1020
			/begin AXIS_DESCR FIX_AXIS
				Vxx_vs
				F_1_p0_58
				9
				0
				256
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_fac_n_dif_drv
			"Ctp_fac_n_dif_drv"
			CURVE
			0x79019
			DATA_RECORD_UBYTE
			0.99609375
			F_0v00390625_p0_90
			0
			0.99609375
			/begin AXIS_DESCR COM_AXIS
				NO_INPUT_QUANTITY
				F_1_p0_60
				5
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_fac_n_dif_drv
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_fast_slop_in
			"Ctp_fast_slop_in"
			CURVE
			0x76DEA
			DATA_RECORD_UWORD
			65535
			F_1_p0_53
			0
			65535
			/begin AXIS_DESCR FIX_AXIS
				Vxx_sta_tco
				F_0v625_m40_25
				17
				-40
				120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 16 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_fast_slop_out
			"Ctp_fast_slop_out"
			CURVE
			0x76E0C
			DATA_RECORD_UWORD
			65535
			F_1_p0_53
			0
			65535
			/begin AXIS_DESCR FIX_AXIS
				Vxx_sta_tco
				F_0v625_m40_25
				17
				-40
				120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 16 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_fast_tq_cold_min_lim
			"Ctp_fast_tq_cold_min_lim"
			VALUE
			0x71AB3
			DATA_RECORD_UBYTE
			127.5
			F_0v5_p0_28
			0
			127.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_fil_fac_mdl_map
			"Ctp_fil_fac_mdl_map"
			CURVE
			0x786DA
			DATA_RECORD_UWORD
			999984.7412
			F_15v2587890625_p0_68
			0
			999984.7412
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				20
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n1
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_frn_tq_loss
			"Ctp_frn_tq_loss"
			CURVE
			0x793E7
			DATA_RECORD_UBYTE
			127.5
			F_0v5_p0_28
			0
			127.5
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				20
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n1
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_frn_tq_loss_tco_fac
			"Ctp_frn_tq_loss_tco_fac"
			CURVE
			0x793FB
			DATA_RECORD_UBYTE
			7.96875
			F_0v03125_p0_91
			0
			7.96875
			/begin AXIS_DESCR COM_AXIS
				Vxx_tco
				F_0v625_m40_25
				16
				-40
				119.375
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_tco
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_fzy_tkof_tqe_grd_fac
			"Ctp_fzy_tkof_tqe_grd_fac"
			CURVE
			0x73660
			DATA_RECORD_UBYTE
			0.99609375
			F_0v00390625_p0_90
			0
			0.99609375
			/begin AXIS_DESCR COM_AXIS
				Vxx_driv_tqe_sp_grd
				F_0v02_m655v35_61
				9
				-655.35
				655.35
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_fzy_tkof_tqe_grd
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_fzy_tkof_vs_fac
			"Ctp_fzy_tkof_vs_fac"
			CURVE
			0x73669
			DATA_RECORD_UBYTE
			0.99609375
			F_0v00390625_p0_90
			0
			0.99609375
			/begin AXIS_DESCR COM_AXIS
				Vxx_vs16
				F_0v01_p0_62
				5
				0
				655.35
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_fzy_tkof_vs
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_fzy_tkof_vs_n_rat_fac
			"Ctp_fzy_tkof_vs_n_rat_fac"
			CURVE
			0x7366E
			DATA_RECORD_UBYTE
			0.99609375
			F_0v00390625_p0_90
			0
			0.99609375
			/begin AXIS_DESCR COM_AXIS
				Vxx_vs_n_rat16
				F_0v0015259_p0_78
				7
				0
				99.9998565
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_tkof_vs_n_rat
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_gas_lpg_trs_cor_dec
			"Ctp_gas_lpg_trs_cor_dec"
			CURVE
			0x73756
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_lpg_temp
				F_1_m40_40
				9
				-40
				215
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_lpg_temp_09
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_gas_lpg_trs_cor_inc
			"Ctp_gas_lpg_trs_cor_inc"
			CURVE
			0x7375F
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_lpg_temp
				F_1_m40_40
				9
				-40
				215
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_lpg_temp_09
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_gas_lpg_trs_cor_ini
			"Ctp_gas_lpg_trs_cor_ini"
			CURVE
			0x73768
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_lpg_temp
				F_1_m40_40
				9
				-40
				215
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_lpg_temp_09
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_gas_trs_cor_stop
			"Ctp_gas_trs_cor_stop"
			CURVE
			0x73771
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_lpg_temp
				F_1_m40_40
				9
				-40
				215
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_lpg_temp_09
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_gear_acel1_aj_fil_fac
			"Ctp_gear_acel1_aj_fil_fac"
			CURVE
			0x7A898
			DATA_RECORD_UWORD
			99.9998565
			F_0v0015259_p0_92
			0
			99.9998565
			/begin AXIS_DESCR FIX_AXIS
				Vxx_gear
				Id_0x00
				8
				0
				7
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 1 8
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_gear_acel3_aj_fil_fac
			"Ctp_gear_acel3_aj_fil_fac"
			CURVE
			0x7A8A8
			DATA_RECORD_UWORD
			99.9998565
			F_0v0015259_p0_92
			0
			99.9998565
			/begin AXIS_DESCR FIX_AXIS
				Vxx_gear
				Id_0x00
				8
				0
				7
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 1 8
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_gear_acel5_aj_fil_fac
			"Ctp_gear_acel5_aj_fil_fac"
			CURVE
			0x7A8B8
			DATA_RECORD_UWORD
			99.9998565
			F_0v0015259_p0_92
			0
			99.9998565
			/begin AXIS_DESCR FIX_AXIS
				Vxx_gear
				Id_0x00
				8
				0
				7
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 1 8
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_gear_decl2_aj_fil_fac
			"Ctp_gear_decl2_aj_fil_fac"
			CURVE
			0x7A8C8
			DATA_RECORD_UWORD
			99.9998565
			F_0v0015259_p0_92
			0
			99.9998565
			/begin AXIS_DESCR FIX_AXIS
				Vxx_gear
				Id_0x00
				8
				0
				7
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 1 8
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_gear_decl4_aj_fil_fac
			"Ctp_gear_decl4_aj_fil_fac"
			CURVE
			0x7A8D8
			DATA_RECORD_UWORD
			99.9998565
			F_0v0015259_p0_92
			0
			99.9998565
			/begin AXIS_DESCR FIX_AXIS
				Vxx_gear
				Id_0x00
				8
				0
				7
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 1 8
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_gear_decl6_aj_fil_fac
			"Ctp_gear_decl6_aj_fil_fac"
			CURVE
			0x7A8E8
			DATA_RECORD_UWORD
			99.9998565
			F_0v0015259_p0_92
			0
			99.9998565
			/begin AXIS_DESCR FIX_AXIS
				Vxx_gear
				Id_0x00
				8
				0
				7
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 1 8
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_h_l_iga_cata_wup
			"Ctp_h_l_iga_cata_wup"
			CURVE
			0x71AB4
			DATA_RECORD_UBYTE
			255
			F_1_p0_9
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_cata_wup_ctr
				F_1_p0_53
				9
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_iga_cata_wup_ctr
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_h_vs_pdl_fac
			"Ctp_h_vs_pdl_fac"
			CURVE
			0x78F7E
			DATA_RECORD_UWORD
			99.993303
			F_0v0015258_p0_48
			0
			99.993303
			/begin AXIS_DESCR COM_AXIS
				Vxx_pdl_psn_rat10
				F_0v09765625_p0_71
				17
				0
				6399.902344
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_rel_pdl_psn
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_iga_efv
			"Ctp_iga_efv"
			CURVE
			0x747F8
			DATA_RECORD_UWORD
			999.93303
			F_0v015258_p0_93
			0
			999.93303
			/begin AXIS_DESCR COM_AXIS
				NO_INPUT_QUANTITY
				F_0v375_p0_33
				33
				0
				95.625
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctp_iga_dif
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_iga_efv_lpg
			"Ctp_iga_efv_lpg"
			CURVE
			0x7A8F8
			DATA_RECORD_UWORD
			999.93303
			F_0v015258_p0_93
			0
			999.93303
			/begin AXIS_DESCR COM_AXIS
				NO_INPUT_QUANTITY
				F_0v375_p0_33
				33
				0
				95.625
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctp_iga_dif
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_iga_prs_fl_thd
			"Ctp_iga_prs_fl_thd"
			CURVE
			0x76E2E
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				20
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_inv_prs_rat
			"Ctp_inv_prs_rat"
			CURVE
			0x7AD85
			DATA_RECORD_UBYTE
			0.2490075
			F_0v0009765_p1_94
			1
			1.2490075
			/begin AXIS_DESCR COM_AXIS
				Vxx_spg_ar_maf_fac
				F_0v9537_p0_73
				9
				0
				62500.7295
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_spg_ar_maf_fac
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_is_aj_clc_n_cor
			"Ctp_is_aj_clc_n_cor"
			CURVE
			0x739DA
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_n32
				F_32_p0_46
				9
				480
				2528
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 15 8 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_is_d_clc_aj_fac
			"Ctp_is_d_clc_aj_fac"
			CURVE
			0x739E3
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_is_d_aj_fac
				Id_0x00
				9
				0
				256
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_is_d_clc_n_drv_fac
			"Ctp_is_d_clc_n_drv_fac"
			CURVE
			0x739EC
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_n_grd
				F_19_p0_95
				9
				-1216
				1216
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST -64 16 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_is_d_clc_tco_fac
			"Ctp_is_d_clc_tco_fac"
			CURVE
			0x739F5
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tco
				F_0v625_m40_25
				9
				-40
				120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_is_decl_clc_cut_n_fac
			"Ctp_is_decl_clc_cut_n_fac"
			CURVE
			0x739FE
			DATA_RECORD_UBYTE
			255
			F_1_p0_9
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Regime_pour_gain_ecart_reg_
				F_32_m256_59
				17
				-256
				2096864
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_decl_n
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_is_decl_clc_n_fac
			"Ctp_is_decl_clc_n_fac"
			CURVE
			0x73A0F
			DATA_RECORD_UBYTE
			255
			F_1_p0_9
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Regime_pour_gain_ecart_reg_
				F_32_m256_59
				17
				-256
				2096864
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_decl_n
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_is_decl_clc_prs_fac
			"Ctp_is_decl_clc_prs_fac"
			CURVE
			0x73A20
			DATA_RECORD_UBYTE
			255
			F_1_p0_9
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_amp_mmv
				F_3v7_p103_37
				17
				103
				242582.5
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_map
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_is_decl_clc_tco_fac
			"Ctp_is_decl_clc_tco_fac"
			CURVE
			0x73A31
			DATA_RECORD_UBYTE
			255
			F_1_p0_9
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tco
				F_0v625_m40_25
				9
				-40
				120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_is_pwm_thr_ar_sp
			"Ctp_is_pwm_thr_ar_sp"
			CURVE
			0x73B4E
			DATA_RECORD_UWORD
			3932.1
			F_0v06_p0_97
			0
			3932.1
			/begin AXIS_DESCR FIX_AXIS
				Vxx_is_pwm
				F_0v0015259_p0_92
				17
				0
				100.0013824
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 4096 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_knk_rel_tq_cor_max
			"Ctp_knk_rel_tq_cor_max"
			CURVE
			0x7942C
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				9
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n2
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_l_vs_pdl_fac
			"Ctp_l_vs_pdl_fac"
			CURVE
			0x78FA0
			DATA_RECORD_UWORD
			99.993303
			F_0v0015258_p0_48
			0
			99.993303
			/begin AXIS_DESCR COM_AXIS
				Vxx_pdl_psn_rat10
				F_0v09765625_p0_71
				17
				0
				6399.902344
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_rel_pdl_psn
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_lbup_ofs_degr_max
			"Ctp_lbup_ofs_degr_max"
			CURVE
			0x7768D
			DATA_RECORD_UBYTE
			255
			F_1_m128_98
			-128
			127
			/begin AXIS_DESCR FIX_AXIS
				Vxx_lbup_per_mv
				F_16_p0_10
				9
				0
				4096
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_lbup_ofs_degr_min
			"Ctp_lbup_ofs_degr_min"
			CURVE
			0x77696
			DATA_RECORD_UBYTE
			255
			F_1_m128_98
			-128
			127
			/begin AXIS_DESCR FIX_AXIS
				Vxx_lbup_per_mv
				F_16_p0_10
				9
				0
				4096
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_lbup_per_max
			"Ctp_lbup_per_max"
			CURVE
			0x7769F
			DATA_RECORD_UBYTE
			4080
			F_16_p0_10
			0
			4080
			/begin AXIS_DESCR FIX_AXIS
				Vxx_maf_fil
				Id_0x00
				17
				0
				32768
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 2048 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_lih_iga_prmt_cor
			"Ctp_lih_iga_prmt_cor"
			CURVE
			0x71ABD
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				20
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_lpg_aftr_sta_ini_dly
			"Ctp_lpg_aftr_sta_ini_dly"
			CURVE
			0x73816
			DATA_RECORD_UWORD
			2097.12
			F_0v032_p0_99
			0
			2097.12
			/begin AXIS_DESCR FIX_AXIS
				Vxx_sta_tco
				F_0v625_m40_25
				17
				-40
				120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 16 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_lpg_gas_trs_cor_dec
			"Ctp_lpg_gas_trs_cor_dec"
			CURVE
			0x7377A
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_lpg_temp
				F_1_m40_40
				9
				-40
				215
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_lpg_temp_09
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_lpg_gas_trs_cor_inc
			"Ctp_lpg_gas_trs_cor_inc"
			CURVE
			0x73783
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_lpg_temp
				F_1_m40_40
				9
				-40
				215
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_lpg_temp_09
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_lpg_gas_trs_cor_ini
			"Ctp_lpg_gas_trs_cor_ini"
			CURVE
			0x7378C
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_lpg_temp
				F_1_m40_40
				9
				-40
				215
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_lpg_temp_09
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_lpg_sta_tco_thd
			"Ctp_lpg_sta_tco_thd"
			CURVE
			0x73795
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
			/begin AXIS_DESCR COM_AXIS
				Vxx_lpg_typ
				F_0v390625_p0_4
				3
				0
				99.609375
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_lpg_typ
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_lpg_sta_tia_thd
			"Ctp_lpg_sta_tia_thd"
			CURVE
			0x73798
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
			/begin AXIS_DESCR COM_AXIS
				Vxx_lpg_typ
				F_0v390625_p0_4
				3
				0
				99.609375
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_lpg_typ
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_lpg_temp_wup_cor_fac
			"Ctp_lpg_temp_wup_cor_fac"
			CURVE
			0x7379B
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_lpg_temp
				F_1_m40_40
				9
				-40
				215
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_lpg_temp_09
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_lpg_temp_wup_cyc_nr
			"Ctp_lpg_temp_wup_cyc_nr"
			CURVE
			0x737A4
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_lpg_temp
				F_1_m40_40
				9
				-40
				215
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_lpg_temp_09
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_lpg_tia_thd
			"Ctp_lpg_tia_thd"
			CURVE
			0x737AD
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
			/begin AXIS_DESCR COM_AXIS
				Vxx_lpg_typ
				F_0v390625_p0_4
				3
				0
				99.609375
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_lpg_typ
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_lpg_trs_cor_stop
			"Ctp_lpg_trs_cor_stop"
			CURVE
			0x737B0
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_lpg_temp
				F_1_m40_40
				9
				-40
				215
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_lpg_temp_09
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_lpg_typ_adac_fmt_fac
			"Ctp_lpg_typ_adac_fmt_fac"
			CURVE
			0x737B9
			DATA_RECORD_UBYTE
			0.99609375
			F_0v00390625_p1_100
			1
			1.99609375
			/begin AXIS_DESCR COM_AXIS
				Vxx_lpg_typ
				F_0v390625_p0_4
				3
				0
				99.609375
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_lpg_typ
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_map_fl_ocl_ofs
			"Ctp_map_fl_ocl_ofs"
			CURVE
			0x76E56
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p0_21
			0
			242479.5
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				20
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_map_tia_iga_cor
			"Ctp_map_tia_iga_cor"
			CURVE
			0x71AD1
			DATA_RECORD_UBYTE
			255
			F_1_p0_9
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_map
				F_3v7_p103_37
				17
				103
				242582.5
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_map
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_max_dif_clc_vs
			"Ctp_max_dif_clc_vs"
			CURVE
			0x7901E
			DATA_RECORD_UBYTE
			255
			F_1_p0_58
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_vs
				F_1_p0_58
				9
				0
				256
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_max_map_inj_cut
			"Ctp_max_map_inj_cut"
			CURVE
			0x7AFF4
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				9
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n2
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_max_map_sp
			"Ctp_max_map_sp"
			CURVE
			0x7B006
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				20
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n1
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_max_mv_cld_ad
			"Ctp_max_mv_cld_ad"
			CURVE
			0x755F6
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_ti_zon_nr
				Id_0x00
				5
				0
				4
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 1 5
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_max_pump_maf
			"Ctp_max_pump_maf"
			CURVE
			0x7B02E
			DATA_RECORD_UWORD
			1.0000641
			F_0v00001526_p0_101
			0
			1.0000641
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				20
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n1
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_min_eal
			"Ctp_min_eal"
			CURVE
			0x7829A
			DATA_RECORD_UWORD
			399.9938965
			F_0v0061035156_p0_23
			0
			399.9938965
			/begin AXIS_DESCR COM_AXIS
				Vxx_prev2_n
				F_1_p0_14
				17
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_mis_n_17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_min_eal_1_2
			"Ctp_min_eal_1_2"
			CURVE
			0x782BC
			DATA_RECORD_UWORD
			399.9938965
			F_0v0061035156_p0_23
			0
			399.9938965
			/begin AXIS_DESCR COM_AXIS
				Vxx_prev2_n
				F_1_p0_14
				17
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_mis_n_17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_min_eal_off
			"Ctp_min_eal_off"
			CURVE
			0x782DE
			DATA_RECORD_UWORD
			399.9938965
			F_0v0061035156_p0_23
			0
			399.9938965
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tco
				F_0v625_m40_25
				9
				-40
				120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_min_map
			"Ctp_min_map"
			CURVE
			0x7A93A
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p0_21
			0
			242479.5
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				20
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n1
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_min_mv_cld_ad
			"Ctp_min_mv_cld_ad"
			CURVE
			0x755FB
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_ti_zon_nr
				Id_0x00
				5
				0
				4
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 1 5
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_mis_stop_is_iga_dif
			"Ctp_mis_stop_is_iga_dif"
			CURVE
			0x776B0
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_33
			0
			95.625
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tco
				F_0v625_m40_25
				11
				-40
				120
				MAX_GRAD 100.0
				/begin FIX_AXIS_PAR_LIST
					0
					16
					32
					48
					64
					96
					128
					160
					192
					224
					256
				/end FIX_AXIS_PAR_LIST
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_ac_is_cor
			"Ctp_n_ac_is_cor"
			CURVE
			0x73A3A
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				9
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n5
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_agb_tq_pwm
			"Ctp_n_agb_tq_pwm"
			CURVE
			0x73B70
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
			/begin AXIS_DESCR FIX_AXIS
				Vxx_is_n02
				F_2_p600_102
				9
				600
				1112
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_aj_fast_tq_dif_thd
			"Ctp_n_aj_fast_tq_dif_thd"
			CURVE
			0x71AE2
			DATA_RECORD_UBYTE
			31.875
			F_0v125_p0_30
			0
			31.875
			/begin AXIS_DESCR FIX_AXIS
				Vxx_n32
				F_32_p0_46
				9
				0
				8192
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_alt_is_cor
			"Ctp_n_alt_is_cor"
			CURVE
			0x73A43
			DATA_RECORD_UBYTE
			255
			F_1_p0_9
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_n32
				F_32_p0_46
				9
				0
				8160
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_is_cor_n
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_amp_prs_dif
			"Ctp_n_amp_prs_dif"
			CURVE
			0x7846D
			DATA_RECORD_UBYTE
			943.5
			F_3v7_p0_21
			0
			943.5
			/begin AXIS_DESCR FIX_AXIS
				Vxx_n32
				F_32_p0_46
				9
				800
				4896
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 25 16 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_amp_spg_dif_cut
			"Ctp_n_amp_spg_dif_cut"
			CURVE
			0x7AD8E
			DATA_RECORD_UBYTE
			943.5
			F_3v7_p0_21
			0
			943.5
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				9
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n3
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_cold_eng_sta_iga
			"Ctp_n_cold_eng_sta_iga"
			CURVE
			0x71AEB
			DATA_RECORD_UBYTE
			95.625
			F_0v375_m23v625_6
			-23.625
			72
			/begin AXIS_DESCR FIX_AXIS
				Vxx_n01
				F_1_p0_14
				9
				64
				1088
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 64 128 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_diag_knk_acq
			"Ctp_n_diag_knk_acq"
			CURVE
			0x725C0
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
			/begin AXIS_DESCR FIX_AXIS
				Vxx_n32
				F_32_p0_46
				9
				0
				8192
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_dif_tkof_p
			"Ctp_n_dif_tkof_p"
			CURVE
			0x7A962
			DATA_RECORD_UWORD
			12.79980469
			F_0v0001953125_m0v1_103
			-0.1
			12.69980469
			/begin AXIS_DESCR COM_AXIS
				Vxx_tkof_n_dif
				F_1_m4096_65
				9
				-4096
				61439
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n_dif
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_dly_ofs_dly
			"Ctp_n_dly_ofs_dly"
			CURVE
			0x75600
			DATA_RECORD_UBYTE
			130560
			F_512_p0_104
			0
			130560
			/begin AXIS_DESCR FIX_AXIS
				Vxx_cor_n
				F_16_p800_57
				9
				800
				4896
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_dly_ofs_dly_lpg
			"Ctp_n_dly_ofs_dly_lpg"
			CURVE
			0x75609
			DATA_RECORD_UBYTE
			130560
			F_512_p0_104
			0
			130560
			/begin AXIS_DESCR FIX_AXIS
				Vxx_cor_n
				F_16_p800_57
				9
				800
				4896
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_dri_dyn_iga_fac
			"Ctp_n_dri_dyn_iga_fac"
			CURVE
			0x71AF4
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_dyn_iga_n_dif
				F_1_m128_105
				9
				-128
				128
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_dri_dyn_iga_fac1
			"Ctp_n_dri_dyn_iga_fac1"
			CURVE
			0x71B06
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_dyn_iga_n_dif
				F_1_m128_105
				9
				-128
				128
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_dri_dyn_iga_fac2
			"Ctp_n_dri_dyn_iga_fac2"
			CURVE
			0x71B0F
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_dyn_iga_n_dif
				F_1_m128_105
				9
				-128
				128
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_dri_dyn_iga_fac3
			"Ctp_n_dri_dyn_iga_fac3"
			CURVE
			0x71B18
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_dyn_iga_n_dif
				F_1_m128_105
				9
				-128
				128
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_dri_dyn_iga_fac4
			"Ctp_n_dri_dyn_iga_fac4"
			CURVE
			0x71B21
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_dyn_iga_n_dif
				F_1_m128_105
				9
				-128
				128
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_dri_dyn_iga_fac5
			"Ctp_n_dri_dyn_iga_fac5"
			CURVE
			0x71B2A
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_dyn_iga_n_dif
				F_1_m128_105
				9
				-128
				128
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_dri_dyn_iga_fac_lpg
			"Ctp_n_dri_dyn_iga_fac_lpg"
			CURVE
			0x71AFD
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_dyn_iga_n_dif
				F_1_m128_105
				9
				-128
				128
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_drv_tkof_d
			"Ctp_n_drv_tkof_d"
			CURVE
			0x7A974
			DATA_RECORD_UWORD
			12.79980469
			F_0v0001953125_m0v1_103
			-0.1
			12.69980469
			/begin AXIS_DESCR COM_AXIS
				Vxx_tkof_n_dif_drv
				F_1_m8192_66
				9
				-8192
				57343
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n_drv
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_h_thr_tq
			"Ctp_n_h_thr_tq"
			CURVE
			0x7A986
			DATA_RECORD_UWORD
			511.9921875
			F_0v0078125_p0_15
			0
			511.9921875
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				20
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_hot_eng_sta_iga
			"Ctp_n_hot_eng_sta_iga"
			CURVE
			0x71B33
			DATA_RECORD_UBYTE
			95.625
			F_0v375_m23v625_6
			-23.625
			72
			/begin AXIS_DESCR FIX_AXIS
				Vxx_n01
				F_1_p0_14
				9
				64
				1088
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 64 128 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_inj_cut_dly
			"Ctp_n_inj_cut_dly"
			CURVE
			0x75612
			DATA_RECORD_UBYTE
			2040
			F_8_p0_56
			0
			2040
			/begin AXIS_DESCR FIX_AXIS
				Vxx_n32
				F_32_p0_46
				9
				0
				8192
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_kd_iga_cor
			"Ctp_n_kd_iga_cor"
			CURVE
			0x71B3C
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				20
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_kd_rel_thr_thd
			"Ctp_n_kd_rel_thr_thd"
			CURVE
			0x784B0
			DATA_RECORD_UBYTE
			102
			F_0v4_p0_106
			0
			102
			/begin AXIS_DESCR FIX_AXIS
				Vxx_n32
				F_32_p0_46
				9
				1280
				3328
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 40 8 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_kd_rich_fac
			"Ctp_n_kd_rich_fac"
			CURVE
			0x76E7E
			DATA_RECORD_UWORD
			170.664281
			F_0v00260417_p0v667_32
			0.667
			171.331281
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				20
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_kd_rich_fac_lpg
			"Ctp_n_kd_rich_fac_lpg"
			CURVE
			0x76EA6
			DATA_RECORD_UWORD
			170.664281
			F_0v00260417_p0v667_32
			0.667
			171.331281
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				20
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_knk_acq_frq
			"Ctp_n_knk_acq_frq"
			CURVE
			0x724F2
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_n32
				F_32_p0_46
				9
				0
				8192
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_knk_acq_int
			"Ctp_n_knk_acq_int"
			CURVE
			0x724FB
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				20
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_knk_fac
			"Ctp_n_knk_fac"
			CURVE
			0x7250F
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				20
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_knk_fac_cyl1
			"Ctp_n_knk_fac_cyl1"
			CURVE
			0x721AA
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				20
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n_knk
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_knk_fac_cyl2
			"Ctp_n_knk_fac_cyl2"
			CURVE
			0x721E6
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				20
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n_knk
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_knk_fac_cyl3
			"Ctp_n_knk_fac_cyl3"
			CURVE
			0x721BE
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				20
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n_knk
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_knk_fac_cyl4
			"Ctp_n_knk_fac_cyl4"
			CURVE
			0x721D2
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				20
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n_knk
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_knk_fast_inc_iga
			"Ctp_n_knk_fast_inc_iga"
			CURVE
			0x71B50
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				20
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_knk_fil_fac_1_4
			"Ctp_n_knk_fil_fac_1_4"
			CURVE
			0x725D2
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				20
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_knk_fil_fac_2_3
			"Ctp_n_knk_fil_fac_2_3"
			CURVE
			0x725FA
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				20
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_knk_ofs
			"Ctp_n_knk_ofs"
			CURVE
			0x72523
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				20
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_knk_ofs_cyl1
			"Ctp_n_knk_ofs_cyl1"
			CURVE
			0x721FA
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				20
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n_knk
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_knk_ofs_cyl2
			"Ctp_n_knk_ofs_cyl2"
			CURVE
			0x72236
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				20
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n_knk
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_knk_ofs_cyl3
			"Ctp_n_knk_ofs_cyl3"
			CURVE
			0x7220E
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				20
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n_knk
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_knk_ofs_cyl4
			"Ctp_n_knk_ofs_cyl4"
			CURVE
			0x72222
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				20
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n_knk
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_knk_win_frst
			"Ctp_n_knk_win_frst"
			CURVE
			0x72537
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				20
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_knk_win_long
			"Ctp_n_knk_win_long"
			CURVE
			0x7254B
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				20
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_knk_zon
			"Ctp_n_knk_zon"
			CURVE
			0x72622
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				20
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n_knk
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_l_ti_i_cor
			"Ctp_n_l_ti_i_cor"
			CURVE
			0x7561B
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_cor_n
				F_16_p800_57
				9
				800
				4896
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_l_ti_i_cor_lean
			"Ctp_n_l_ti_i_cor_lean"
			CURVE
			0x75624
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_cor_n
				F_16_p800_57
				9
				800
				4896
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_l_ti_i_cor_lpg
			"Ctp_n_l_ti_i_cor_lpg"
			CURVE
			0x7562D
			DATA_RECORD_UBYTE
			255
			F_1_p0_9
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_cor_n
				F_16_p800_57
				9
				800
				4896
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_lbdw_hot_dsb_map
			"Ctp_n_lbdw_hot_dsb_map"
			CURVE
			0x783D4
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
			/begin AXIS_DESCR FIX_AXIS
				Vxx_n32
				F_32_p0_46
				9
				0
				8192
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_lbup_hot_dsb_map
			"Ctp_n_lbup_hot_dsb_map"
			CURVE
			0x783E6
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
			/begin AXIS_DESCR FIX_AXIS
				Vxx_n32
				F_32_p0_46
				9
				0
				8192
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_map_fil_fac
			"Ctp_n_map_fil_fac"
			CURVE
			0x78730
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_n32
				F_32_p0_46
				9
				0
				8192
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_mfld_inv_fil_fac
			"Ctp_n_mfld_inv_fil_fac"
			CURVE
			0x7A9AE
			DATA_RECORD_UWORD
			99.9985458
			F_0v00152588_p0_107
			0
			99.9985458
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				9
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n2
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_min_gas_lim_tq
			"Ctp_n_min_gas_lim_tq"
			CURVE
			0x79435
			DATA_RECORD_UBYTE
			510
			F_2_m100_36
			-100
			410
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				20
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_neut_dyn_iga_fac
			"Ctp_n_neut_dyn_iga_fac"
			CURVE
			0x71B64
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_dyn_iga_n_dif
				F_1_m128_105
				9
				-128
				128
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_neut_dyn_iga_fac1
			"Ctp_n_neut_dyn_iga_fac1"
			CURVE
			0x71B6D
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_dyn_iga_n_dif
				F_1_m128_105
				9
				-128
				128
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_neut_dyn_iga_fac2
			"Ctp_n_neut_dyn_iga_fac2"
			CURVE
			0x71B76
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_dyn_iga_n_dif
				F_1_m128_105
				9
				-128
				128
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_neut_dyn_iga_fac3
			"Ctp_n_neut_dyn_iga_fac3"
			CURVE
			0x71B7F
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_dyn_iga_n_dif
				F_1_m128_105
				9
				-128
				128
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_neut_dyn_iga_fac4
			"Ctp_n_neut_dyn_iga_fac4"
			CURVE
			0x71B88
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_dyn_iga_n_dif
				F_1_m128_105
				9
				-128
				128
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_neut_dyn_iga_fac5
			"Ctp_n_neut_dyn_iga_fac5"
			CURVE
			0x71B91
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_dyn_iga_n_dif
				F_1_m128_105
				9
				-128
				128
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_neut_dyn_iga_fac6
			"Ctp_n_neut_dyn_iga_fac6"
			CURVE
			0x71B9A
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_dyn_iga_n_dif
				F_1_m128_105
				9
				-128
				128
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_pred_val_fil_fac
			"Ctp_n_pred_val_fil_fac"
			CURVE
			0x79449
			DATA_RECORD_UBYTE
			0.99609375
			F_0v00390625_p0_90
			0
			0.99609375
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				20
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n1
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_ptc_is_cor
			"Ctp_n_ptc_is_cor"
			CURVE
			0x73A4C
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_ptc_pow
				F_100_p0_70
				6
				0
				25500
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctd_n_ptc_is_cor
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_rams_max_thr_ar
			"Ctp_n_rams_max_thr_ar"
			CURVE
			0x7A9C0
			DATA_RECORD_UWORD
			3905.886
			F_0v0596_p0_108
			0
			3905.886
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				20
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n1
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_spg_dft_mod
			"Ctp_n_spg_dft_mod"
			CURVE
			0x7B056
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				6
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_spg_n
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_sta_ti
			"Ctp_n_sta_ti"
			CURVE
			0x75636
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_n01
				F_1_p0_14
				9
				64
				1088
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 64 128 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_ti_p_cor
			"Ctp_n_ti_p_cor"
			CURVE
			0x7563F
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_cor_n
				F_16_p800_57
				9
				800
				4896
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_ti_p_cor_lean1
			"Ctp_n_ti_p_cor_lean1"
			CURVE
			0x75648
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_cor_n
				F_16_p800_57
				9
				800
				4896
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_ti_p_cor_lean2
			"Ctp_n_ti_p_cor_lean2"
			CURVE
			0x75651
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_cor_n
				F_16_p800_57
				9
				800
				4896
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_ti_p_cor_lpg
			"Ctp_n_ti_p_cor_lpg"
			CURVE
			0x7565A
			DATA_RECORD_UBYTE
			255
			F_1_p0_9
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_cor_n
				F_16_p800_57
				9
				800
				4896
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_tia_fac
			"Ctp_n_tia_fac"
			CURVE
			0x75663
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
			/begin AXIS_DESCR FIX_AXIS
				Vxx_n32
				F_32_p0_46
				17
				0
				8192
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 16 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_n_tqi_dyn_lim
			"Ctp_n_tqi_dyn_lim"
			CURVE
			0x7A9E8
			DATA_RECORD_UWORD
			511.9921875
			F_0v0078125_p0_15
			0
			511.9921875
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				9
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n2
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_neg_whl_spd
			"Ctp_neg_whl_spd"
			CURVE
			0x7360F
			DATA_RECORD_UBYTE
			2231.76
			F_8v752_p0_109
			0
			2231.76
			/begin AXIS_DESCR COM_AXIS
				Vxx_vs
				F_0v0625_p0_110
				9
				0
				15.9375
				MAX_GRAD 100.0
				AXIS_PTS_REF Ntb_whl_spd
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_neut_cata_is_iga_cor
			"Ctp_neut_cata_is_iga_cor"
			CURVE
			0x71BA3
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
			/begin AXIS_DESCR COM_AXIS
				Vxx_cata_wup_ctr
				F_1_p0_53
				17
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_is_cata_wup_ctr
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_neut_cata_is_iga_cor1
			"Ctp_neut_cata_is_iga_cor1"
			CURVE
			0x71BB4
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
			/begin AXIS_DESCR COM_AXIS
				Vxx_cata_wup_ctr
				F_1_p0_53
				17
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_is_cata_wup_ctr
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_ol_is_lean_cylr
			"Ctp_ol_is_lean_cylr"
			CURVE
			0x75674
			DATA_RECORD_UBYTE
			198.9
			F_0v78_m100_47
			-100
			98.9
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tco
				F_0v625_m40_25
				9
				-40
				120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_ol_is_rich_cylr
			"Ctp_ol_is_rich_cylr"
			CURVE
			0x7567D
			DATA_RECORD_UBYTE
			198.9
			F_0v78_m100_47
			-100
			98.9
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tco
				F_0v625_m40_25
				9
				-40
				120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_pdl_psn_fil_mes_v2_v1
			"Ctp_pdl_psn_fil_mes_v2_v1"
			CURVE
			0x7332A
			DATA_RECORD_UWORD
			6399.49275
			F_0v09765_p0_3
			0
			6399.49275
			/begin AXIS_DESCR FIX_AXIS
				Vxx_sens2_pdl_fil_psn
				F_0v097656_p0_5
				9
				0
				99.999744
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 128 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_perf_inj_clos_angl
			"Ctp_perf_inj_clos_angl"
			CURVE
			0x75686
			DATA_RECORD_UBYTE
			765
			F_3_p0_111
			0
			765
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				20
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_pn_tco_min_is_n
			"Ctp_pn_tco_min_is_n"
			CURVE
			0x78B15
			DATA_RECORD_UBYTE
			4080
			F_16_p0_83
			0
			4080
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tco
				F_0v625_m40_25
				17
				-40
				120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 16 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_polu_inj_clos_angl
			"Ctp_polu_inj_clos_angl"
			CURVE
			0x7569A
			DATA_RECORD_UBYTE
			765
			F_3_p0_111
			0
			765
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				20
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_pos_whl_spd
			"Ctp_pos_whl_spd"
			CURVE
			0x73618
			DATA_RECORD_UBYTE
			2231.76
			F_8v752_p0_109
			0
			2231.76
			/begin AXIS_DESCR COM_AXIS
				Vxx_vs
				F_0v0625_p0_110
				9
				0
				15.9375
				MAX_GRAD 100.0
				AXIS_PTS_REF Ntb_whl_spd
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_pred_map_prs_rat
			"Ctp_pred_map_prs_rat"
			CURVE
			0x78702
			DATA_RECORD_UWORD
			999984.7412
			F_15v2587890625_p0_68
			0
			999984.7412
			/begin AXIS_DESCR COM_AXIS
				Vxx_psi_fac_cor
				F_0v25_p0_69
				17
				0
				16383.75
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_psi_fac_cor
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_prs_fast_tq_max_lim
			"Ctp_prs_fast_tq_max_lim"
			CURVE
			0x71BC5
			DATA_RECORD_UBYTE
			127.5
			F_0v5_p0_28
			0
			127.5
			/begin AXIS_DESCR FIX_AXIS
				Diff_pres_coll_pres_sural
				F_3v7_p0_21
				9
				0
				947.2
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_prs_fast_tq_min_lim
			"Ctp_prs_fast_tq_min_lim"
			CURVE
			0x71BCE
			DATA_RECORD_UBYTE
			127.5
			F_0v5_p0_28
			0
			127.5
			/begin AXIS_DESCR FIX_AXIS
				Diff_pres_coll_pres_sural
				F_3v7_p0_21
				9
				0
				947.2
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_prs_gas_trs_cor_min
			"Ctp_prs_gas_trs_cor_min"
			CURVE
			0x737BC
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_pred_map
				F_3v7_p103_37
				17
				103
				242582.5
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_map
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_prs_is_i_set
			"Ctp_prs_is_i_set"
			CURVE
			0x73B82
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
			/begin AXIS_DESCR FIX_AXIS
				Vxx_alti
				F_3v7_p0_21
				9
				0
				473.6
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 16 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_prs_knk_win_frst
			"Ctp_prs_knk_win_frst"
			CURVE
			0x7255F
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
			/begin AXIS_DESCR COM_AXIS
				Vxx_map
				F_3v7_p103_37
				17
				103
				242582.5
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_map
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_prs_l_ti_i_cor
			"Ctp_prs_l_ti_i_cor"
			CURVE
			0x756AE
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_map
				F_3v7_p103_37
				17
				103
				242582.5
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_map
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_prs_l_ti_i_cor_lean
			"Ctp_prs_l_ti_i_cor_lean"
			CURVE
			0x756BF
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_map
				F_3v7_p103_37
				17
				103
				242582.5
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_map
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_prs_l_ti_i_cor_lpg
			"Ctp_prs_l_ti_i_cor_lpg"
			CURVE
			0x756D0
			DATA_RECORD_UBYTE
			255
			F_1_p0_9
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_map
				F_3v7_p103_37
				17
				103
				242582.5
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_map
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_prs_lpg_trs_cor_min
			"Ctp_prs_lpg_trs_cor_min"
			CURVE
			0x737CD
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_pred_map
				F_3v7_p103_37
				17
				103
				242582.5
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_map
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_prs_rat_fil_fac
			"Ctp_prs_rat_fil_fac"
			CURVE
			0x7945D
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
			/begin AXIS_DESCR COM_AXIS
				Vxx_raw_prs_rat
				F_15v2587890625_p0_68
				22
				0
				999984.7412
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_prs_rat
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_prs_ti_ofs1
			"Ctp_prs_ti_ofs1"
			CURVE
			0x756E1
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_map
				F_3v7_p103_37
				17
				103
				242582.5
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_map
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_prs_ti_ofs1_lpg
			"Ctp_prs_ti_ofs1_lpg"
			CURVE
			0x756F2
			DATA_RECORD_UBYTE
			255
			F_1_p0_9
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_map
				F_3v7_p103_37
				17
				103
				242582.5
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_map
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_prs_ti_ofs2
			"Ctp_prs_ti_ofs2"
			CURVE
			0x75703
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_map
				F_3v7_p103_37
				17
				103
				242582.5
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_map
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_prs_ti_ofs2_lpg
			"Ctp_prs_ti_ofs2_lpg"
			CURVE
			0x75714
			DATA_RECORD_UBYTE
			255
			F_1_p0_9
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_map
				F_3v7_p103_37
				17
				103
				242582.5
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_map
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_prs_tia_fac
			"Ctp_prs_tia_fac"
			CURVE
			0x75725
			DATA_RECORD_UBYTE
			255
			F_1_m128_98
			-128
			127
			/begin AXIS_DESCR COM_AXIS
				Vxx_map
				F_3v7_p103_37
				17
				103
				242582.5
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_map
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_prs_tmp_flr_val
			"Ctp_prs_tmp_flr_val"
			CURVE
			0x7A9FA
			DATA_RECORD_UWORD
			62500.7295
			F_0v9537_p0_73
			0
			62500.7295
			/begin AXIS_DESCR COM_AXIS
				Vxx_up_down_thr_prs_rat
				F_15v2587890625_p0_68
				22
				0
				999984.7412
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_prs_rat
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_prs_tq_trs_fac
			"Ctp_prs_tq_trs_fac"
			CURVE
			0x79473
			DATA_RECORD_UBYTE
			336.518145
			F_1v319679_p0_112
			0
			336.518145
			/begin AXIS_DESCR COM_AXIS
				Vxx_fil_pred_prs
				F_3v7_p103_37
				17
				103
				242582.5
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_map
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_ptc_pow_cor
			"Ctp_ptc_pow_cor"
			CURVE
			0x79484
			DATA_RECORD_UBYTE
			5100
			F_20_p0_63
			0
			5100
			/begin AXIS_DESCR COM_AXIS
				Vxx_ptc_pow
				F_100_p0_70
				5
				0
				25500
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_ptc_pow
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_pwm_cp_efv_ar1
			"Ctp_pwm_cp_efv_ar1"
			CURVE
			0x7AA26
			DATA_RECORD_UWORD
			244.1375355
			F_0v0037253_p0_113
			0
			244.1375355
			/begin AXIS_DESCR FIX_AXIS
				Vxx_cp_pwm_appl
				F_0v0039_p0_114
				9
				0
				255.5904
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 8192 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_pwm_cp_efv_ar2
			"Ctp_pwm_cp_efv_ar2"
			CURVE
			0x7AA38
			DATA_RECORD_UWORD
			244.1375355
			F_0v0037253_p0_113
			0
			244.1375355
			/begin AXIS_DESCR FIX_AXIS
				Vxx_cp_pwm_appl
				F_0v0039_p0_114
				9
				0
				255.5904
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 8192 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_pwst_iga_cor_max_lim
			"Ctp_pwst_iga_cor_max_lim"
			CURVE
			0x71BD7
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tco
				F_0v625_m40_25
				9
				-40
				120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_rams_driv_tq_fil_acel
			"Ctp_rams_driv_tq_fil_acel"
			CURVE
			0x79489
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				9
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n2
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_rams_driv_tq_fil_decl
			"Ctp_rams_driv_tq_fil_decl"
			CURVE
			0x79492
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				9
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n2
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_rams_esti_tqe_neg_err
			"Ctp_rams_esti_tqe_neg_err"
			CURVE
			0x7AA4A
			DATA_RECORD_UWORD
			511.9921875
			F_0v0078125_p0_15
			0
			511.9921875
			/begin AXIS_DESCR COM_AXIS
				Vxx_rams_mask_t_tq_req
				F_0v0078125_m100_35
				17
				-100
				411.9921875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_rams_tq_req
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_rams_esti_tqe_pos_err
			"Ctp_rams_esti_tqe_pos_err"
			CURVE
			0x7AA6C
			DATA_RECORD_UWORD
			511.9921875
			F_0v0078125_p0_15
			0
			511.9921875
			/begin AXIS_DESCR COM_AXIS
				Vxx_rams_mask_t_tq_req
				F_0v0078125_m100_35
				17
				-100
				411.9921875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_rams_tq_req
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_rams_h_vs_pdl_fac
			"Ctp_rams_h_vs_pdl_fac"
			CURVE
			0x7AA8E
			DATA_RECORD_UWORD
			99.99847412
			F_0v0015258789_p0_115
			0
			99.99847412
			/begin AXIS_DESCR COM_AXIS
				Vxx_rams_pdl_psn_rat
				F_0v09765625_p0_71
				17
				0
				6399.902344
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_rel_pdl_psn
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_rams_l_vs_pdl_fac
			"Ctp_rams_l_vs_pdl_fac"
			CURVE
			0x7AAB0
			DATA_RECORD_UWORD
			99.99847412
			F_0v0015258789_p0_115
			0
			99.99847412
			/begin AXIS_DESCR COM_AXIS
				Vxx_rams_pdl_psn_rat
				F_0v09765625_p0_71
				17
				0
				6399.902344
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_rel_pdl_psn
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_rams_n_max_tqi
			"Ctp_rams_n_max_tqi"
			CURVE
			0x7AAD2
			DATA_RECORD_UWORD
			511.9921875
			F_0v0078125_p0_15
			0
			511.9921875
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				20
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n1
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_rams_n_ovt_tqi_ofs
			"Ctp_rams_n_ovt_tqi_ofs"
			CURVE
			0x7AAFA
			DATA_RECORD_UWORD
			511.9921875
			F_0v0078125_p0_15
			0
			511.9921875
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				20
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n1
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_rams_n_tqi_dyn_lim
			"Ctp_rams_n_tqi_dyn_lim"
			CURVE
			0x7AB22
			DATA_RECORD_UWORD
			511.9921875
			F_0v0078125_p0_15
			0
			511.9921875
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				9
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n2
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_rams_rvr_pdl_fac
			"Ctp_rams_rvr_pdl_fac"
			CURVE
			0x7AB34
			DATA_RECORD_UWORD
			99.99847412
			F_0v0015258789_p0_115
			0
			99.99847412
			/begin AXIS_DESCR COM_AXIS
				Vxx_rams_pdl_psn_rat
				F_0v09765625_p0_71
				17
				0
				6399.902344
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_rel_pdl_psn
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_rams_tq_req_neg_err
			"Ctp_rams_tq_req_neg_err"
			CURVE
			0x7AB56
			DATA_RECORD_UWORD
			511.9921875
			F_0v0078125_p0_15
			0
			511.9921875
			/begin AXIS_DESCR COM_AXIS
				Vxx_rams_mask_t_tq_req
				F_0v0078125_m100_35
				17
				-100
				411.9921875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_rams_tq_req
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_rams_tq_req_pos_err
			"Ctp_rams_tq_req_pos_err"
			CURVE
			0x7AB78
			DATA_RECORD_UWORD
			511.9921875
			F_0v0078125_p0_15
			0
			511.9921875
			/begin AXIS_DESCR COM_AXIS
				Vxx_rams_mask_t_tq_req
				F_0v0078125_m100_35
				17
				-100
				411.9921875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_rams_tq_req
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_rich_lpg_otl_iga_tqi
			"Ctp_rich_lpg_otl_iga_tqi"
			CURVE
			0x7AB9A
			DATA_RECORD_UWORD
			524280
			F_8_p0_116
			0
			524280
			/begin AXIS_DESCR COM_AXIS
				Vxx_rich_sp
				F_0v0000305176_p0_72
				9
				0
				1.999969605
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_rich_sp9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_rich_otl_iga_mv_tqi
			"Ctp_rich_otl_iga_mv_tqi"
			CURVE
			0x7ABAC
			DATA_RECORD_UWORD
			524280
			F_8_p0_116
			0
			524280
			/begin AXIS_DESCR COM_AXIS
				Vxx_rich_sp
				F_0v0000305176_p0_72
				9
				0
				1.999969605
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_rich_sp9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_rvr_pdl_fac
			"Ctp_rvr_pdl_fac"
			CURVE
			0x78634
			DATA_RECORD_UWORD
			99.9985458
			F_0v00152588_p0_107
			0
			99.9985458
			/begin AXIS_DESCR COM_AXIS
				Vxx_pdl_psn_rat10
				F_0v09765625_p0_71
				17
				0
				6399.902344
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_rel_pdl_psn
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_spg_cl_spg_prs_thd
			"Ctp_spg_cl_spg_prs_thd"
			CURVE
			0x7AD97
			DATA_RECORD_UBYTE
			1887
			F_7v4_p750_49
			750
			2637
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				9
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n3
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_spg_l_hys
			"Ctp_spg_l_hys"
			CURVE
			0x7B062
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p0_21
			0
			242479.5
			/begin AXIS_DESCR FIX_AXIS
				Vxx_mes_spg
				F_3v7_p103_37
				17
				103
				3891.8
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 64 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_spg_max_grd
			"Ctp_spg_max_grd"
			CURVE
			0x7ADA0
			DATA_RECORD_UBYTE
			943.5
			F_3v7_p0_21
			0
			943.5
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				9
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n3
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_spg_prs_dif_thd_trs
			"Ctp_spg_prs_dif_thd_trs"
			CURVE
			0x7ADA9
			DATA_RECORD_UBYTE
			943.5
			F_3v7_p0_21
			0
			943.5
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				9
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n3
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_spg_prs_rat_sp
			"Ctp_spg_prs_rat_sp"
			CURVE
			0x7ADB2
			DATA_RECORD_UBYTE
			0.2490228
			F_0v00097656_p1_117
			1
			1.2490228
			/begin AXIS_DESCR COM_AXIS
				Vxx_spg_tq_rat_sp
				F_0v00390625_p0_74
				9
				0
				0.99609375
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_spg_tq_rat
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_spg_tia_cor
			"Ctp_spg_tia_cor"
			CURVE
			0x7ADBB
			DATA_RECORD_UBYTE
			943.5
			F_3v7_m473v6_118
			-473.6
			469.9
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tia
				F_0v625_m40_25
				9
				-40
				120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_spg_up_hys
			"Ctp_spg_up_hys"
			CURVE
			0x7B084
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p0_21
			0
			242479.5
			/begin AXIS_DESCR FIX_AXIS
				Vxx_mes_spg
				F_3v7_p103_37
				17
				103
				3891.8
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 64 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_sta_is_fil_pwm_dec
			"Ctp_sta_is_fil_pwm_dec"
			CURVE
			0x73B94
			DATA_RECORD_UWORD
			99.9998565
			F_0v0015259_p0_92
			0
			99.9998565
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tco
				F_0v625_m40_25
				17
				-40
				120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 16 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_sta_tco_dly
			"Ctp_sta_tco_dly"
			CURVE
			0x78B26
			DATA_RECORD_UBYTE
			261.12
			F_1v024_p0_119
			0
			261.12
			/begin AXIS_DESCR COM_AXIS
				NO_INPUT_QUANTITY
				F_0v625_m40_25
				16
				-40
				119.375
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_tco
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_sta_tco_oil_temp_t
			"Ctp_sta_tco_oil_temp_t"
			CURVE
			0x78B36
			DATA_RECORD_UBYTE
			1044.48
			F_4v096_p0_12
			0
			1044.48
			/begin AXIS_DESCR FIX_AXIS
				Vxx_sta_tco
				F_0v625_m40_25
				9
				-40
				120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tco_aftr_ti_fac
			"Ctp_tco_aftr_ti_fac"
			CURVE
			0x75736
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tco
				F_0v625_m40_25
				9
				-40
				120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tco_agb_dri_dly
			"Ctp_tco_agb_dri_dly"
			CURVE
			0x71EBB
			DATA_RECORD_UBYTE
			4080
			F_16_p0_10
			0
			4080
			/begin AXIS_DESCR COM_AXIS
				Vxx_tco
				F_0v625_m40_25
				16
				-40
				119.375
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_tco
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tco_agb_neut_dly
			"Ctp_tco_agb_neut_dly"
			CURVE
			0x72052
			DATA_RECORD_UWORD
			1048560
			F_16_p0_10
			0
			1048560
			/begin AXIS_DESCR COM_AXIS
				Vxx_tco
				F_0v625_m40_25
				16
				-40
				119.375
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_tco
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tco_agb_neut_tq
			"Ctp_tco_agb_neut_tq"
			CURVE
			0x72072
			DATA_RECORD_UWORD
			511.9921875
			F_0v0078125_p0_15
			0
			511.9921875
			/begin AXIS_DESCR COM_AXIS
				Vxx_tco
				F_0v625_m40_25
				16
				-40
				119.375
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_tco
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tco_agb_tq
			"Ctp_tco_agb_tq"
			CURVE
			0x72092
			DATA_RECORD_UWORD
			511.9921875
			F_0v0078125_p0_15
			0
			511.9921875
			/begin AXIS_DESCR COM_AXIS
				Vxx_tco
				F_0v625_m40_25
				16
				-40
				119.375
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_tco
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tco_alt_cor
			"Ctp_tco_alt_cor"
			CURVE
			0x7949B
			DATA_RECORD_UBYTE
			5.1
			F_0v02_p0_120
			0
			5.1
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tco
				F_0v625_m40_25
				9
				-40
				120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tco_aut_thd
			"Ctp_tco_aut_thd"
			CURVE
			0x78757
			DATA_RECORD_UBYTE
			261.12
			F_1v024_p0_119
			0
			261.12
			/begin AXIS_DESCR COM_AXIS
				Vxx_tco
				F_0v625_m40_25
				9
				-40
				119.375
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_tco_thd
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tco_cl2_ena_ctr
			"Ctp_tco_cl2_ena_ctr"
			CURVE
			0x76EE8
			DATA_RECORD_UWORD
			65535
			F_1_p0_53
			0
			65535
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tco
				F_0v625_m40_25
				9
				-40
				120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tco_cl2_ena_ctr_lpg
			"Ctp_tco_cl2_ena_ctr_lpg"
			CURVE
			0x76EFA
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tco
				F_0v625_m40_25
				9
				-40
				120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tco_cl_off_dly
			"Ctp_tco_cl_off_dly"
			CURVE
			0x76ECE
			DATA_RECORD_UWORD
			33553.92
			F_0v512_p0_121
			0
			33553.92
			/begin AXIS_DESCR COM_AXIS
				Vxx_tco
				F_0v625_m40_25
				13
				-40
				119.375
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_tco_cl_off
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tco_clos_thr_t
			"Ctp_tco_clos_thr_t"
			CURVE
			0x794A4
			DATA_RECORD_UBYTE
			8160
			F_32_p0_122
			0
			8160
			/begin AXIS_DESCR COM_AXIS
				Vxx_tco
				F_0v625_m40_25
				16
				-40
				119.375
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_tco
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tco_cut_decl_off_dly
			"Ctp_tco_cut_decl_off_dly"
			CURVE
			0x7573F
			DATA_RECORD_UBYTE
			261.12
			F_1v024_p0_119
			0
			261.12
			/begin AXIS_DESCR COM_AXIS
				Vxx_tco
				F_0v625_m40_25
				9
				-40
				119.375
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_tco_cut
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tco_cut_decl_off_dly1
			"Ctp_tco_cut_decl_off_dly1"
			CURVE
			0x75748
			DATA_RECORD_UBYTE
			261.12
			F_1v024_p0_119
			0
			261.12
			/begin AXIS_DESCR COM_AXIS
				Vxx_tco
				F_0v625_m40_25
				9
				-40
				119.375
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_tco_cut
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tco_dec_sta_ti
			"Ctp_tco_dec_sta_ti"
			CURVE
			0x75751
			DATA_RECORD_UBYTE
			16.32
			F_0v064_p0_123
			0
			16.32
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tco
				F_0v625_m40_25
				17
				-40
				120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 16 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tco_dif_max
			"Ctp_tco_dif_max"
			CURVE
			0x7B18A
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
			/begin AXIS_DESCR COM_AXIS
				Vxx_tco_mdl
				F_0v625_m40_25
				5
				-40
				119.375
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_tco_dif_max
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tco_dri_agb_is_iga
			"Ctp_tco_dri_agb_is_iga"
			CURVE
			0x71BE0
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tco
				F_0v625_m40_25
				11
				-40
				120
				MAX_GRAD 100.0
				/begin FIX_AXIS_PAR_LIST
					0
					16
					32
					48
					64
					96
					128
					160
					192
					224
					256
				/end FIX_AXIS_PAR_LIST
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tco_dri_is_cor_ofs
			"Ctp_tco_dri_is_cor_ofs"
			CURVE
			0x73BB6
			DATA_RECORD_UWORD
			65535
			F_1_m100_124
			-100
			65435
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tco
				F_0v625_m40_25
				17
				-40
				120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 16 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tco_dri_is_iga_lpg
			"Ctp_tco_dri_is_iga_lpg"
			CURVE
			0x71BEB
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tco
				F_0v625_m40_25
				11
				-40
				120
				MAX_GRAD 100.0
				/begin FIX_AXIS_PAR_LIST
					0
					16
					32
					48
					64
					96
					128
					160
					192
					224
					256
				/end FIX_AXIS_PAR_LIST
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tco_eai_ti_fac_cor
			"Ctp_tco_eai_ti_fac_cor"
			CURVE
			0x75762
			DATA_RECORD_UBYTE
			255
			F_1_m128_98
			-128
			127
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tco
				F_0v625_m40_25
				17
				-20
				60
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 32 8 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tco_ini_fil_is_i_ad
			"Ctp_tco_ini_fil_is_i_ad"
			CURVE
			0x72139
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tco
				F_0v625_m40_25
				9
				-40
				120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tco_ini_is_i
			"Ctp_tco_ini_is_i"
			CURVE
			0x73A52
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tco
				F_0v625_m40_25
				9
				-40
				120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tco_inj_sta_dly
			"Ctp_tco_inj_sta_dly"
			CURVE
			0x75773
			DATA_RECORD_UBYTE
			32640
			F_128_p0_125
			0
			32640
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tco
				F_0v625_m40_25
				9
				-40
				120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tco_is_bas_iga
			"Ctp_tco_is_bas_iga"
			CURVE
			0x71BF6
			DATA_RECORD_UBYTE
			95.625
			F_0v375_m23v625_6
			-23.625
			72
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tco
				F_0v625_m40_25
				11
				-40
				120
				MAX_GRAD 100.0
				/begin FIX_AXIS_PAR_LIST
					0
					16
					32
					48
					64
					96
					128
					160
					192
					224
					256
				/end FIX_AXIS_PAR_LIST
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tco_is_bas_iga_lpg
			"Ctp_tco_is_bas_iga_lpg"
			CURVE
			0x71C01
			DATA_RECORD_UBYTE
			95.625
			F_0v375_m23v625_6
			-23.625
			72
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tco
				F_0v625_m40_25
				11
				-40
				120
				MAX_GRAD 100.0
				/begin FIX_AXIS_PAR_LIST
					0
					16
					32
					48
					64
					96
					128
					160
					192
					224
					256
				/end FIX_AXIS_PAR_LIST
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tco_lbdw_hot_dly
			"Ctp_tco_lbdw_hot_dly"
			CURVE
			0x783F8
			DATA_RECORD_UWORD
			65535
			F_1_p0_53
			0
			65535
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tco
				F_0v625_m40_25
				9
				-40
				120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tco_lbup_hot_dly
			"Ctp_tco_lbup_hot_dly"
			CURVE
			0x7840A
			DATA_RECORD_UWORD
			65535
			F_1_p0_53
			0
			65535
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tco
				F_0v625_m40_25
				9
				-40
				120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tco_lean_cylr
			"Ctp_tco_lean_cylr"
			CURVE
			0x7577C
			DATA_RECORD_UBYTE
			198.9
			F_0v78_m100_47
			-100
			98.9
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tco_ti_cor
				F_0v015625_p0v5_126
				9
				1
				2
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 32 8 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tco_lean_ti_fac_cor
			"Ctp_tco_lean_ti_fac_cor"
			CURVE
			0x75785
			DATA_RECORD_UBYTE
			255
			F_1_m128_98
			-128
			127
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tco
				F_0v625_m40_25
				17
				-20
				60
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 32 8 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tco_lim_sta_iga
			"Ctp_tco_lim_sta_iga"
			CURVE
			0x71C0C
			DATA_RECORD_UBYTE
			95.625
			F_0v375_m23v625_6
			-23.625
			72
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tco
				F_0v625_m40_25
				9
				-40
				120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tco_lim_tqi
			"Ctp_tco_lim_tqi"
			CURVE
			0x794B4
			DATA_RECORD_UBYTE
			510
			F_2_m100_36
			-100
			410
			/begin AXIS_DESCR COM_AXIS
				Vxx_tco
				F_0v625_m40_25
				16
				-40
				119.375
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_tco
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tco_max_n
			"Ctp_tco_max_n"
			CURVE
			0x78D08
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
			/begin AXIS_DESCR COM_AXIS
				Vxx_tco
				F_0v625_m40_25
				16
				-40
				119.375
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_tco
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tco_max_pow_thd
			"Ctp_tco_max_pow_thd"
			CURVE
			0x78760
			DATA_RECORD_UBYTE
			5100
			F_20_p0_63
			0
			5100
			/begin AXIS_DESCR COM_AXIS
				Vxx_tco
				F_0v625_m40_25
				9
				-40
				119.375
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_tco_thd
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tco_mdl_tdc_nr
			"Ctp_tco_mdl_tdc_nr"
			CURVE
			0x7B1B8
			DATA_RECORD_UWORD
			65535
			F_1_p0_53
			0
			65535
			/begin AXIS_DESCR COM_AXIS
				Vxx_sta_tco
				F_0v625_m40_25
				5
				-40
				119.375
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_tco_mdl
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tco_n_ini
			"Ctp_tco_n_ini"
			CURVE
			0x78B3F
			DATA_RECORD_UBYTE
			510
			F_2_p0_127
			0
			510
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tco
				F_0v625_m40_25
				9
				-40
				120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tco_neut_is_cor
			"Ctp_tco_neut_is_cor"
			CURVE
			0x73BD8
			DATA_RECORD_UWORD
			65535
			F_1_m100_124
			-100
			65435
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tco
				F_0v625_m40_25
				17
				-40
				120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 16 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tco_pinj_t
			"Ctp_tco_pinj_t"
			CURVE
			0x75796
			DATA_RECORD_UBYTE
			1020
			F_4_p0_128
			0
			1020
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tco
				F_0v625_m40_25
				11
				-40
				120
				MAX_GRAD 100.0
				/begin FIX_AXIS_PAR_LIST
					0
					16
					32
					48
					64
					96
					128
					160
					192
					224
					256
				/end FIX_AXIS_PAR_LIST
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tco_rich_cylr
			"Ctp_tco_rich_cylr"
			CURVE
			0x757A1
			DATA_RECORD_UBYTE
			198.9
			F_0v78_m100_47
			-100
			98.9
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tco_ti_cor
				F_0v015625_p0v5_126
				9
				1
				2
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 32 8 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tco_sta_is_pwm
			"Ctp_tco_sta_is_pwm"
			CURVE
			0x73A5B
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tco
				F_0v625_m40_25
				17
				-40
				120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 16 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tco_sta_out_sfg_dly
			"Ctp_tco_sta_out_sfg_dly"
			CURVE
			0x757AA
			DATA_RECORD_UBYTE
			255
			F_1_p0_53
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tco
				F_0v625_m40_25
				9
				-40
				120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tco_sta_rich_dec
			"Ctp_tco_sta_rich_dec"
			CURVE
			0x757B3
			DATA_RECORD_UBYTE
			255
			F_1_p0_53
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tco
				F_0v625_m40_25
				11
				-40
				120
				MAX_GRAD 100.0
				/begin FIX_AXIS_PAR_LIST
					0
					16
					32
					48
					64
					96
					128
					160
					192
					224
					256
				/end FIX_AXIS_PAR_LIST
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tco_sta_ti
			"Ctp_tco_sta_ti"
			CURVE
			0x757BE
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tco
				F_0v625_m40_25
				17
				-40
				120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 16 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tco_sta_ti_fac
			"Ctp_tco_sta_ti_fac"
			CURVE
			0x757CF
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tco
				F_0v625_m40_25
				17
				-40
				120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 16 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tco_ti_fac1
			"Ctp_tco_ti_fac1"
			CURVE
			0x757E0
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tco
				F_0v625_m40_25
				17
				-40
				120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 16 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tco_ti_fac3
			"Ctp_tco_ti_fac3"
			CURVE
			0x757F1
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tco
				F_0v625_m40_25
				17
				-40
				120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 16 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tco_tkof_degr_fac
			"Ctp_tco_tkof_degr_fac"
			CURVE
			0x7ABBE
			DATA_RECORD_UWORD
			63.9990562
			F_0v000976563_p0_129
			0
			63.9990562
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tco
				F_0v625_m40_25
				9
				-40
				120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tco_tkof_l_thd
			"Ctp_tco_tkof_l_thd"
			CURVE
			0x78769
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
			/begin AXIS_DESCR COM_AXIS
				Vxx_tco
				F_0v625_m40_25
				9
				-40
				119.375
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_tco_thd
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tco_toil_ofs
			"Ctp_tco_toil_ofs"
			CURVE
			0x76FE6
			DATA_RECORD_UBYTE
			255
			F_1_m40_40
			-40
			215
			/begin AXIS_DESCR COM_AXIS
				Vxx_tco_dif
				F_0v625_m40_25
				9
				-40
				119.375
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_tco_dif
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tdc_agb_tco_is_n_ofs
			"Ctp_tdc_agb_tco_is_n_ofs"
			CURVE
			0x78B48
			DATA_RECORD_UBYTE
			4080
			F_16_p0_83
			0
			4080
			/begin AXIS_DESCR COM_AXIS
				Vxx_cata_wup_ctr
				F_1_p0_53
				17
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_is_cata_wup_ctr
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tdc_drag_red_tco_is_n_ofs
			"Ctp_tdc_drag_red_tco_is_n_ofs"
			CURVE
			0x78B59
			DATA_RECORD_UBYTE
			4080
			F_16_p0_83
			0
			4080
			/begin AXIS_DESCR COM_AXIS
				Vxx_cata_wup_ctr
				F_1_p0_53
				17
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_is_cata_wup_ctr
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tdc_pn_tco_is_n_ofs
			"Ctp_tdc_pn_tco_is_n_ofs"
			CURVE
			0x78B6A
			DATA_RECORD_UBYTE
			4080
			F_16_p0_83
			0
			4080
			/begin AXIS_DESCR COM_AXIS
				Vxx_cata_wup_ctr
				F_1_p0_53
				17
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_is_cata_wup_ctr
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_thpl_air_fac
			"Ctp_thpl_air_fac"
			CURVE
			0x73A6C
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Regime_moteur_affine_2
				Id_0x00
				9
				0
				256
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_thpl_el_csm_vb
			"Ctp_thpl_el_csm_vb"
			CURVE
			0x790A1
			DATA_RECORD_UBYTE
			8.16
			F_0v032_p8_130
			8
			16.16
			/begin AXIS_DESCR FIX_AXIS
				Regime_moteur_affine_2
				Id_0x00
				9
				0
				256
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_thpl_is_n
			"Ctp_thpl_is_n"
			CURVE
			0x78B7B
			DATA_RECORD_UBYTE
			4080
			F_16_p0_83
			0
			4080
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tco
				F_0v625_m40_25
				9
				-40
				120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_thpl_tco
			"Ctp_thpl_tco"
			CURVE
			0x790AA
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_131
			-40
			119.375
			/begin AXIS_DESCR FIX_AXIS
				Vxx_thpl_min_tia
				F_0v625_m40_131
				9
				-25
				15
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 24 8 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_thr_mcut_ol_v
			"Ctp_thr_mcut_ol_v"
			CURVE
			0x7333C
			DATA_RECORD_UWORD
			40959.375
			F_0v625_m20480_132
			-20480
			20479.375
			/begin AXIS_DESCR COM_AXIS
				Tpac_relative_lh_throttle_pos
				F_0v097656_m100_77
				10
				-100
				6299.88596
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_thr_mcut_psn
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_thr_sge_ol_v
			"Ctp_thr_sge_ol_v"
			CURVE
			0x73350
			DATA_RECORD_UWORD
			40959.375
			F_0v625_m20480_132
			-20480
			20479.375
			/begin AXIS_DESCR COM_AXIS
				Tpac_relative_lh_throttle_pos
				F_0v097656_m100_77
				10
				-100
				6299.88596
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_thr_sge_psn
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_ti_cor_eai_fil_ctr
			"Ctp_ti_cor_eai_fil_ctr"
			CURVE
			0x75802
			DATA_RECORD_UBYTE
			255
			F_1_p0_53
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_ti_cor_eai_tdc_ctr
				Id_0x00
				9
				0
				256
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tia_inj_cor
			"Ctp_tia_inj_cor"
			CURVE
			0x7580B
			DATA_RECORD_UBYTE
			99.603
			F_0v3906_p0_133
			0
			99.603
			/begin AXIS_DESCR FIX_AXIS
				Vxx_clc_tia_fil
				F_0v00244_m40_134
				9
				-40
				119.90784
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 8192 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tia_is_cor
			"Ctp_tia_is_cor"
			CURVE
			0x73A75
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tia
				F_0v625_m40_25
				9
				-40
				120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tia_max_tqi_cor
			"Ctp_tia_max_tqi_cor"
			CURVE
			0x794C4
			DATA_RECORD_UBYTE
			0.99609375
			F_0v00390625_p0v5_20
			0.5
			1.49609375
			/begin AXIS_DESCR COM_AXIS
				Vxx_tia
				F_0v625_m40_25
				17
				-40
				119.375
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_tia_17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tia_sta_ti_fac
			"Ctp_tia_sta_ti_fac"
			CURVE
			0x75814
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tia
				F_0v625_m40_25
				17
				-40
				120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 16 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tlz_ad_b_grd_prs
			"Ctp_tlz_ad_b_grd_prs"
			CURVE
			0x73140
			DATA_RECORD_UWORD
			65535
			F_1_p0_9
			0
			65535
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				6
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n_tlz_ad_b
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tlz_fil_fac
			"Ctp_tlz_fil_fac"
			CURVE
			0x776BB
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_eal_tdc_2
				F_0v0061035156_p0_23
				17
				0
				399.9938965
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_dft_comb_eal
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tlz_fil_fac_lpg
			"Ctp_tlz_fil_fac_lpg"
			CURVE
			0x776CC
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_eal_tdc_2
				F_0v0061035156_p0_23
				17
				0
				399.9938965
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_dft_comb_eal
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tlz_fil_rst_eal_dif
			"Ctp_tlz_fil_rst_eal_dif"
			CURVE
			0x782F0
			DATA_RECORD_UWORD
			399.9938965
			F_0v0061035156_p0_23
			0
			399.9938965
			/begin AXIS_DESCR COM_AXIS
				Vxx_eal_tdc_2
				F_0v0061035156_p0_23
				17
				0
				399.9938965
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_dft_comb_eal
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_toil_fil
			"Ctp_toil_fil"
			CURVE
			0x7700A
			DATA_RECORD_UWORD
			99.99841473
			F_0v001525878_p0_135
			0
			99.99841473
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				6
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n4
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_toil_is_n_ofs
			"Ctp_toil_is_n_ofs"
			CURVE
			0x78B84
			DATA_RECORD_UBYTE
			4080
			F_16_p0_83
			0
			4080
			/begin AXIS_DESCR COM_AXIS
				Vxx_toil
				F_0v625_m40_25
				5
				-40
				40919.375
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_toil
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_toil_lim_tq
			"Ctp_toil_lim_tq"
			CURVE
			0x794D5
			DATA_RECORD_UBYTE
			510
			F_2_m100_36
			-100
			410
			/begin AXIS_DESCR COM_AXIS
				Vxx_toil
				F_0v625_m40_25
				17
				-40
				40919.375
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_toil2
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_toil_max_n
			"Ctp_toil_max_n"
			CURVE
			0x78D28
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
			/begin AXIS_DESCR COM_AXIS
				Vxx_toil
				F_0v625_m40_25
				17
				-40
				40919.375
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_toil2
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tq_agb_is_iga
			"Ctp_tq_agb_is_iga"
			CURVE
			0x71C15
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_33
			0
			95.625
			/begin AXIS_DESCR COM_AXIS
				Vxx_agb_csm_tq
				F_0v0078125_p0_15
				9
				0
				511.9921875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_csm_agb_tq
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tq_agb_is_iga_lpg
			"Ctp_tq_agb_is_iga_lpg"
			CURVE
			0x71C1E
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_33
			0
			95.625
			/begin AXIS_DESCR COM_AXIS
				Vxx_agb_csm_tq
				F_0v0078125_p0_15
				9
				0
				511.9921875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_csm_agb_tq
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tq_rat_fil_fac
			"Ctp_tq_rat_fil_fac"
			CURVE
			0x794E6
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				9
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n2
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tqr_ct
			"Ctp_tqr_ct"
			CURVE
			0x71C27
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
			/begin AXIS_DESCR COM_AXIS
				Vxx_n0125
				F_0v125_p0_30
				20
				0
				8191.875
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_n
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tqr_ct_fmt
			"Ctp_tqr_ct_fmt"
			CURVE
			0x71C3B
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
			/begin AXIS_DESCR FIX_AXIS
				Diff_pres_coll_pres_sural
				F_3v7_p0_21
				9
				0
				947.2
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tqr_cut
			"Ctp_tqr_cut"
			CURVE
			0x71C44
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
			/begin AXIS_DESCR COM_AXIS
				Vxx_map
				F_3v7_p103_37
				17
				103
				242582.5
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_map
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tqr_cut_lpg
			"Ctp_tqr_cut_lpg"
			CURVE
			0x71C55
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
			/begin AXIS_DESCR COM_AXIS
				Vxx_map
				F_3v7_p103_37
				17
				103
				242582.5
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_map
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tqr_swi
			"Ctp_tqr_swi"
			CURVE
			0x71C66
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
			/begin AXIS_DESCR FIX_AXIS
				Vxx_n32
				F_32_p0_46
				9
				0
				4096
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 16 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tqr_swi_fmt
			"Ctp_tqr_swi_fmt"
			CURVE
			0x71C6F
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
			/begin AXIS_DESCR FIX_AXIS
				Diff_pres_coll_pres_sural
				F_3v7_p0_21
				9
				0
				947.2
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_tqr_swi_lpg
			"Ctp_tqr_swi_lpg"
			CURVE
			0x71C78
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
			/begin AXIS_DESCR FIX_AXIS
				Vxx_n32
				F_32_p0_46
				9
				0
				4096
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 16 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_ufld_tco_thd
			"Ctp_ufld_tco_thd"
			VALUE
			0x75825
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_v1_v2_max_dif
			"Ctp_v1_v2_max_dif"
			CURVE
			0x73364
			DATA_RECORD_UWORD
			6399.49275
			F_0v09765_p0_3
			0
			6399.49275
			/begin AXIS_DESCR FIX_AXIS
				Vxx_sens1_pdl_fil_psn
				F_0v097656_p0_5
				9
				0
				99.999744
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 128 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_vb_inj_dly_cor
			"Ctp_vb_inj_dly_cor"
			CURVE
			0x75826
			DATA_RECORD_UBYTE
			2040
			F_8_p0_136
			0
			2040
			/begin AXIS_DESCR FIX_AXIS
				Vxx_fil_vb
				F_0v000125_p8_7
				9
				8
				16.192
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 8192 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_vs_l_tq_pdl_thd
			"Ctp_vs_l_tq_pdl_thd"
			CURVE
			0x7ABD0
			DATA_RECORD_UWORD
			99.99789045
			F_0v00152587_p0_137
			0
			99.99789045
			/begin AXIS_DESCR COM_AXIS
				Vxx_vs
				F_1_p0_58
				9
				0
				255
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_vs
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_vs_mvac_dp_dec
			"Ctp_vs_mvac_dp_dec"
			CURVE
			0x7370E
			DATA_RECORD_UBYTE
			943.5
			F_3v7_p0_21
			0
			943.5
			/begin AXIS_DESCR COM_AXIS
				Vxx_vs
				F_1_p0_58
				7
				0
				255
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_vs_mvac_dp
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_vs_n_tkof_degr
			"Ctp_vs_n_tkof_degr"
			CURVE
			0x7ABE2
			DATA_RECORD_UWORD
			63.99902344
			F_0v0009765625_p0_138
			0
			63.99902344
			/begin AXIS_DESCR COM_AXIS
				Vxx_fil_vs_n_rat
				F_0v0015259_p0_78
				7
				0
				99.9998565
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_tkof_vs_n_rat
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_vvtc_act_temp_h_thd
			"Ctp_vvtc_act_temp_h_thd"
			CURVE
			0x735F6
			DATA_RECORD_UWORD
			40959.375
			F_0v625_p56_139
			56
			41015.375
			/begin AXIS_DESCR COM_AXIS
				Vxx_n01
				F_1_p0_14
				9
				0
				65535
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_vvt_n1
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_vvtc_angl_iga_fac1
			"Ctp_vvtc_angl_iga_fac1"
			CURVE
			0x71C81
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
			/begin AXIS_DESCR FIX_AXIS
				Vvt_angle_fac1_para
				F_0v00390625_p0_74
				9
				0
				1
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_vvtc_angl_iga_fac2
			"Ctp_vvtc_angl_iga_fac2"
			CURVE
			0x71C8A
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
			/begin AXIS_DESCR FIX_AXIS
				Vvt_angle_fac2_para
				F_0v00390625_p0_74
				9
				0
				1
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_wet_acel_cor_fac
			"Ctp_wet_acel_cor_fac"
			CURVE
			0x7582F
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tco
				F_0v625_m40_25
				17
				-40
				120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 16 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_wet_decl_cor_fac
			"Ctp_wet_decl_cor_fac"
			CURVE
			0x75840
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tco
				F_0v625_m40_25
				17
				-40
				120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 16 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_wet_decl_fil_fac
			"Ctp_wet_decl_fil_fac"
			CURVE
			0x75851
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tco
				F_0v625_m40_25
				17
				-40
				120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 16 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_wet_ini_acel_cor_ofs
			"Ctp_wet_ini_acel_cor_ofs"
			CURVE
			0x75862
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tco
				F_0v625_m40_25
				17
				-40
				120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 16 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_wet_tb_acel_vol_fac
			"Ctp_wet_tb_acel_vol_fac"
			CURVE
			0x75873
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_wet_tdc_rat_ctr
				Id_0x00
				9
				0
				255
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_wet_tdc_rat_ctr
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_wet_tb_decl_vol_fac
			"Ctp_wet_tb_decl_vol_fac"
			CURVE
			0x7587C
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
			/begin AXIS_DESCR COM_AXIS
				Vxx_wet_tdc_rat_ctr
				Id_0x00
				9
				0
				255
				MAX_GRAD 100.0
				AXIS_PTS_REF Ctb_wet_tdc_rat_ctr
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_wet_vol_dif_thd_acel
			"Ctp_wet_vol_dif_thd_acel"
			CURVE
			0x76F0C
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tco
				F_0v625_m40_25
				9
				-40
				120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_wet_vol_dif_thd_decl
			"Ctp_wet_vol_dif_thd_decl"
			CURVE
			0x76F1E
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tco
				F_0v625_m40_25
				9
				-40
				120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_wet_vol_dif_thd_ini
			"Ctp_wet_vol_dif_thd_ini"
			CURVE
			0x76F30
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tco
				F_0v625_m40_25
				9
				-40
				120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_wet_vol_dif_thd_sta
			"Ctp_wet_vol_dif_thd_sta"
			CURVE
			0x76F42
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tco
				F_0v625_m40_25
				9
				-40
				120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctp_wet_vol_dif_thd_sta_t
			"Ctp_wet_vol_dif_thd_sta_t"
			CURVE
			0x75885
			DATA_RECORD_UBYTE
			255
			F_1_p0_54
			0
			255
			/begin AXIS_DESCR FIX_AXIS
				Vxx_tco
				F_0v625_m40_25
				9
				-40
				120
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 32 9
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctx_fac_cor_thr_ar_max
			"Ctx_fac_cor_thr_ar_max"
			CURVE
			0x70D29
			DATA_RECORD_UBYTE
			0.99609375
			F_0v00390625_p1_100
			1
			1.99609375
			/begin AXIS_DESCR FIX_AXIS
				NO_INPUT_QUANTITY
				Id_0x00
				17
				0
				16
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 1 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Ctx_fac_cor_thr_ar_min
			"Ctx_fac_cor_thr_ar_min"
			CURVE
			0x70D3A
			DATA_RECORD_UBYTE
			0.99609375
			F_0v00390625_p0_90
			0
			0.99609375
			/begin AXIS_DESCR FIX_AXIS
				NO_INPUT_QUANTITY
				Id_0x00
				17
				0
				16
				MAX_GRAD 100.0
				FIX_AXIS_PAR_DIST 0 1 17
			/end AXIS_DESCR
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_1_thr_ad_lh_lim_max
			"Cxx_1_thr_ad_lh_lim_max"
			VALUE
			0x73376
			DATA_RECORD_UWORD
			6399.902344
			F_0v09765625_p0_71
			0
			6399.902344
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_1_thr_lh_chk_lim_max
			"Cxx_1_thr_lh_chk_lim_max"
			VALUE
			0x73378
			DATA_RECORD_UWORD
			6399.88596
			F_0v097656_p0_5
			0
			6399.88596
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_2_thr_ad_lh_lim_max
			"Cxx_2_thr_ad_lh_lim_max"
			VALUE
			0x7337A
			DATA_RECORD_UWORD
			6399.902344
			F_0v09765625_p0_71
			0
			6399.902344
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_2_thr_lh_chk_lim_max
			"Cxx_2_thr_lh_chk_lim_max"
			VALUE
			0x7337C
			DATA_RECORD_UWORD
			6399.88596
			F_0v097656_p0_5
			0
			6399.88596
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_abs_abst_nr_fail
			"Cxx_abs_abst_nr_fail"
			VALUE
			0x71ECB
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_abs_whl_spd_med_zon
			"Cxx_abs_whl_spd_med_zon"
			VALUE
			0x73621
			DATA_RECORD_UBYTE
			2231.76
			F_8v752_p0_109
			0
			2231.76
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ac_abst_nr_fail
			"Cxx_ac_abst_nr_fail"
			VALUE
			0x71ECC
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ac_acel_is_h_prs_thd
			"Cxx_ac_acel_is_h_prs_thd"
			VALUE
			0x7217C
			DATA_RECORD_UWORD
			6553.5
			F_0v1_p0_141
			0
			6553.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ac_acel_is_l_prs_thd
			"Cxx_ac_acel_is_l_prs_thd"
			VALUE
			0x7217E
			DATA_RECORD_UWORD
			6553.5
			F_0v1_p0_141
			0
			6553.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ac_acel_is_req_dly
			"Cxx_ac_acel_is_req_dly"
			VALUE
			0x72142
			DATA_RECORD_UBYTE
			65280
			F_256_p0_142
			0
			65280
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ac_aut_swi1_is_ofs
			"Cxx_ac_aut_swi1_is_ofs"
			VALUE
			0x75898
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ac_aut_swi1_is_ofs1
			"Cxx_ac_aut_swi1_is_ofs1"
			VALUE
			0x75899
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ac_aut_swi_is_ofs
			"Cxx_ac_aut_swi_is_ofs"
			VALUE
			0x75896
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ac_aut_swi_is_ofs_lpg
			"Cxx_ac_aut_swi_is_ofs_lpg"
			VALUE
			0x75897
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ac_cut_n_ofs
			"Cxx_ac_cut_n_ofs"
			VALUE
			0x7589A
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ac_dsb_tco_thd
			"Cxx_ac_dsb_tco_thd"
			VALUE
			0x7372D
			DATA_RECORD_UBYTE
			159.375
			F_0v625_p0_143
			0
			159.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ac_ena_tco_thd
			"Cxx_ac_ena_tco_thd"
			VALUE
			0x7372E
			DATA_RECORD_UBYTE
			159.375
			F_0v625_p0_143
			0
			159.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ac_is_i_n_drv_thd
			"Cxx_ac_is_i_n_drv_thd"
			VALUE
			0x73A7E
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ac_is_in_cdn_ofs
			"Cxx_ac_is_in_cdn_ofs"
			VALUE
			0x73A7F
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ac_is_in_cdn_ofs2
			"Cxx_ac_is_in_cdn_ofs2"
			VALUE
			0x73A80
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ac_is_in_dly
			"Cxx_ac_is_in_dly"
			VALUE
			0x73A81
			DATA_RECORD_UBYTE
			8160
			F_32_p0_122
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ac_is_out_n_ofs
			"Cxx_ac_is_out_n_ofs"
			VALUE
			0x73A82
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ac_is_out_n_ofs2
			"Cxx_ac_is_out_n_ofs2"
			VALUE
			0x73A83
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ac_load_dft
			"Cxx_ac_load_dft"
			VALUE
			0x72143
			DATA_RECORD_UBYTE
			5100
			F_20_p0_63
			0
			5100
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ac_max_mdf_dly
			"Cxx_ac_max_mdf_dly"
			VALUE
			0x72144
			DATA_RECORD_UBYTE
			261.12
			F_1v024_p0_119
			0
			261.12
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ac_mdf1_is_cor
			"Cxx_ac_mdf1_is_cor"
			VALUE
			0x73A84
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ac_mdf1_is_cor1
			"Cxx_ac_mdf1_is_cor1"
			VALUE
			0x73A85
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ac_mdf2_is_cor
			"Cxx_ac_mdf2_is_cor"
			VALUE
			0x73A86
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ac_mdf2_is_cor1
			"Cxx_ac_mdf2_is_cor1"
			VALUE
			0x73A87
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ac_mdf_vs_thd1
			"Cxx_ac_mdf_vs_thd1"
			VALUE
			0x72145
			DATA_RECORD_UBYTE
			255
			F_1_p0_58
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ac_mdf_vs_thd2
			"Cxx_ac_mdf_vs_thd2"
			VALUE
			0x72146
			DATA_RECORD_UBYTE
			255
			F_1_p0_58
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ac_mdf_vs_thd3
			"Cxx_ac_mdf_vs_thd3"
			VALUE
			0x72147
			DATA_RECORD_UBYTE
			255
			F_1_p0_58
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ac_mdf_vs_thd4
			"Cxx_ac_mdf_vs_thd4"
			VALUE
			0x72148
			DATA_RECORD_UBYTE
			255
			F_1_p0_58
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ac_min_is_n_step
			"Cxx_ac_min_is_n_step"
			VALUE
			0x78B89
			DATA_RECORD_UBYTE
			4080
			F_16_p0_83
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ac_min_is_n_step_dly
			"Cxx_ac_min_is_n_step_dly"
			VALUE
			0x78B8A
			DATA_RECORD_UBYTE
			32.64
			F_0v128_p0_75
			0
			32.64
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ac_pow_max
			"Cxx_ac_pow_max"
			VALUE
			0x72149
			DATA_RECORD_UBYTE
			5100
			F_20_p0_63
			0
			5100
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ac_pow_min
			"Cxx_ac_pow_min"
			VALUE
			0x7214A
			DATA_RECORD_UBYTE
			5100
			F_20_p0_63
			0
			5100
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ac_pow_n_fac
			"Cxx_ac_pow_n_fac"
			VALUE
			0x72180
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ac_pow_prs_fac
			"Cxx_ac_pow_prs_fac"
			VALUE
			0x72182
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ac_pow_prs_n_fac
			"Cxx_ac_pow_prs_n_fac"
			VALUE
			0x72184
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ac_prs_fac
			"Cxx_ac_prs_fac"
			VALUE
			0x7214B
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ac_prs_ofs
			"Cxx_ac_prs_ofs"
			VALUE
			0x72186
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ac_prs_v_max
			"Cxx_ac_prs_v_max"
			VALUE
			0x72188
			DATA_RECORD_UWORD
			4.99966515
			F_0v00007629_p0_144
			0
			4.99966515
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ac_prs_v_min
			"Cxx_ac_prs_v_min"
			VALUE
			0x7218A
			DATA_RECORD_UWORD
			4.99966515
			F_0v00007629_p0_144
			0
			4.99966515
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ac_req_dly
			"Cxx_ac_req_dly"
			VALUE
			0x7214C
			DATA_RECORD_UBYTE
			16320
			F_64_p0_145
			0
			16320
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ac_swi_is_ofs
			"Cxx_ac_swi_is_ofs"
			VALUE
			0x7589B
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ac_swi_is_ofs_lpg
			"Cxx_ac_swi_is_ofs_lpg"
			VALUE
			0x7589C
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_acc_bk
			"Cxx_acc_bk"
			VALUE
			0x78EF3
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_acc_frm_abst_nr
			"Cxx_acc_frm_abst_nr"
			VALUE
			0x78EF4
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_acc_neut
			"Cxx_acc_neut"
			VALUE
			0x78EF5
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_acc_stt_cge_dly_1
			"Cxx_acc_stt_cge_dly_1"
			VALUE
			0x78EF6
			DATA_RECORD_UBYTE
			4080
			F_16_p0_10
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_acc_stt_cge_dly_2
			"Cxx_acc_stt_cge_dly_2"
			VALUE
			0x78EF7
			DATA_RECORD_UBYTE
			4080
			F_16_p0_10
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_acel_esti_tqe_fil_fac
			"Cxx_acel_esti_tqe_fil_fac"
			VALUE
			0x794EF
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_acel_fast_slop
			"Cxx_acel_fast_slop"
			VALUE
			0x7589D
			DATA_RECORD_UBYTE
			127.5
			F_0v5_p0_146
			0
			127.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_acel_fast_slop_lean
			"Cxx_acel_fast_slop_lean"
			VALUE
			0x7589E
			DATA_RECORD_UBYTE
			127.5
			F_0v5_p0_146
			0
			127.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_acel_is_req_dclu_acc
			"Cxx_acel_is_req_dclu_acc"
			VALUE
			0x7214D
			DATA_RECORD_UBYTE
			4080
			F_16_p0_10
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_acel_pdl_kd_in_thd
			"Cxx_acel_pdl_kd_in_thd"
			VALUE
			0x78FC2
			DATA_RECORD_UWORD
			6399.902344
			F_0v09765625_p0_147
			0
			6399.902344
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_acel_pdl_kd_out_thd
			"Cxx_acel_pdl_kd_out_thd"
			VALUE
			0x78FC4
			DATA_RECORD_UWORD
			6399.902344
			F_0v09765625_p0_147
			0
			6399.902344
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_acr_eng_fac
			"Cxx_acr_eng_fac"
			VALUE
			0x7214E
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ad_cor_dsb_dly
			"Cxx_ad_cor_dsb_dly"
			VALUE
			0x73A88
			DATA_RECORD_UBYTE
			261.12
			F_1v024_p0_119
			0
			261.12
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ad_lamb_swi_ctr
			"Cxx_ad_lamb_swi_ctr"
			VALUE
			0x7589F
			DATA_RECORD_UBYTE
			255
			F_1_p0_148
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ad_off_ti_ad_fac
			"Cxx_ad_off_ti_ad_fac"
			VALUE
			0x758A0
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ad_off_ti_ad_ofs
			"Cxx_ad_off_ti_ad_ofs"
			VALUE
			0x758A1
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ad_ptc_pow_thd
			"Cxx_ad_ptc_pow_thd"
			VALUE
			0x73A89
			DATA_RECORD_UBYTE
			25500
			F_100_p0_70
			0
			25500
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ad_tq_fil_fac
			"Cxx_ad_tq_fil_fac"
			VALUE
			0x794F0
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_adac_csm_mux
			"Cxx_adac_csm_mux"
			VALUE
			0x720B2
			DATA_RECORD_UWORD
			262140
			F_4_p0_149
			0
			262140
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_adac_csm_mux_lpg
			"Cxx_adac_csm_mux_lpg"
			VALUE
			0x720B4
			DATA_RECORD_UWORD
			262140
			F_4_p0_149
			0
			262140
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_adac_ti_csm_fac
			"Cxx_adac_ti_csm_fac"
			VALUE
			0x73190
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_adac_ti_ofs
			"Cxx_adac_ti_ofs"
			VALUE
			0x71F3E
			DATA_RECORD_SWORD
			262140
			F_4_p0_149
			-131072
			131068
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_adac_ti_ofs_lpg
			"Cxx_adac_ti_ofs_lpg"
			VALUE
			0x71F40
			DATA_RECORD_SWORD
			262140
			F_4_p0_149
			-131072
			131068
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_adj_fac_thr_adj
			"Cxx_adj_fac_thr_adj"
			VALUE
			0x70D4B
			DATA_RECORD_UBYTE
			255
			F_1_p1_150
			1
			256
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_aftr_inj_map_dif
			"Cxx_aftr_inj_map_dif"
			VALUE
			0x76F54
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p0_21
			0
			242479.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_aftr_inj_map_fac
			"Cxx_aftr_inj_map_fac"
			VALUE
			0x758A2
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_aftr_inj_n_thd
			"Cxx_aftr_inj_n_thd"
			VALUE
			0x758A3
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_agb_abst_nr_fail
			"Cxx_agb_abst_nr_fail"
			VALUE
			0x71ECD
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_agb_ac_min_is_n
			"Cxx_agb_ac_min_is_n"
			VALUE
			0x78B8B
			DATA_RECORD_UBYTE
			4080
			F_16_p0_83
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_agb_clck_max_val
			"Cxx_agb_clck_max_val"
			VALUE
			0x71ECE
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_agb_conv_trs_dly
			"Cxx_agb_conv_trs_dly"
			VALUE
			0x71ECF
			DATA_RECORD_UBYTE
			8160
			F_32_p0_122
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_agb_min_is_n
			"Cxx_agb_min_is_n"
			VALUE
			0x71ED0
			DATA_RECORD_UBYTE
			4080
			F_16_p0_83
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_agb_min_is_n_step
			"Cxx_agb_min_is_n_step"
			VALUE
			0x78B8C
			DATA_RECORD_UBYTE
			4080
			F_16_p0_83
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_agb_min_is_n_step_dly
			"Cxx_agb_min_is_n_step_dly"
			VALUE
			0x78B8D
			DATA_RECORD_UBYTE
			32640
			F_128_p0_125
			0
			32640
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_agb_min_tqe_fac
			"Cxx_agb_min_tqe_fac"
			VALUE
			0x794F1
			DATA_RECORD_UBYTE
			3.984375
			F_0v015625_p0_13
			0
			3.984375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_agb_ptc_min_is_n
			"Cxx_agb_ptc_min_is_n"
			VALUE
			0x78B8E
			DATA_RECORD_UBYTE
			4080
			F_16_p0_83
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_agb_pwst_min_is_n
			"Cxx_agb_pwst_min_is_n"
			VALUE
			0x78B8F
			DATA_RECORD_UBYTE
			4080
			F_16_p0_83
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_agb_tco_is_n_ofs
			"Cxx_agb_tco_is_n_ofs"
			VALUE
			0x78B90
			DATA_RECORD_UBYTE
			4080
			F_16_p0_83
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_agb_tq_max_ofs
			"Cxx_agb_tq_max_ofs"
			VALUE
			0x720B6
			DATA_RECORD_UWORD
			511.9921875
			F_0v0078125_p0_15
			0
			511.9921875
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_agb_vh_min_is_n
			"Cxx_agb_vh_min_is_n"
			VALUE
			0x78B91
			DATA_RECORD_UBYTE
			4080
			F_16_p0_83
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_agb_wind_min_is_n
			"Cxx_agb_wind_min_is_n"
			VALUE
			0x78B92
			DATA_RECORD_UBYTE
			4080
			F_16_p0_83
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_air_pump_cor
			"Cxx_air_pump_cor"
			VALUE
			0x73A8A
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_air_pump_eal_dsb
			"Cxx_air_pump_eal_dsb"
			VALUE
			0x7B0A6
			DATA_RECORD_UWORD
			399.9938965
			F_0v0061035156_p0_23
			0
			399.9938965
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_air_pump_eal_dsb_hys
			"Cxx_air_pump_eal_dsb_hys"
			VALUE
			0x7B0A8
			DATA_RECORD_UWORD
			399.9938965
			F_0v0061035156_p0_23
			0
			399.9938965
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_air_pump_is_cor1
			"Cxx_air_pump_is_cor1"
			VALUE
			0x73A8B
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_air_pump_is_cor2
			"Cxx_air_pump_is_cor2"
			VALUE
			0x73A8C
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_air_pump_n_dsb
			"Cxx_air_pump_n_dsb"
			VALUE
			0x7ADC4
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_air_pump_n_dsb_hys
			"Cxx_air_pump_n_dsb_hys"
			VALUE
			0x7ADC5
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_air_pump_pow1
			"Cxx_air_pump_pow1"
			VALUE
			0x794F2
			DATA_RECORD_UBYTE
			5100
			F_20_p0_63
			0
			5100
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_air_pump_pow2
			"Cxx_air_pump_pow2"
			VALUE
			0x794F3
			DATA_RECORD_UBYTE
			5100
			F_20_p0_63
			0
			5100
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_air_pump_sta_dly
			"Cxx_air_pump_sta_dly"
			VALUE
			0x7ADC6
			DATA_RECORD_UBYTE
			32640
			F_128_p0_125
			0
			32640
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_air_pump_stop_dly
			"Cxx_air_pump_stop_dly"
			VALUE
			0x7ADC7
			DATA_RECORD_UBYTE
			32640
			F_128_p0_125
			0
			32640
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_air_pump_thr_ar_sp
			"Cxx_air_pump_thr_ar_sp"
			VALUE
			0x7B0AA
			DATA_RECORD_UWORD
			3906.190395
			F_0v0596046448_p0_151
			0
			3906.190395
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_air_pump_thr_ar_sp_hys
			"Cxx_air_pump_thr_ar_sp_hys"
			VALUE
			0x7B0AC
			DATA_RECORD_UWORD
			3906.190395
			F_0v0596046448_p0_151
			0
			3906.190395
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_air_tq_angl_dly
			"Cxx_air_tq_angl_dly"
			VALUE
			0x747E7
			DATA_RECORD_UBYTE
			3.984375
			F_0v015625_p0_13
			0
			3.984375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_air_tq_t_dly
			"Cxx_air_tq_t_dly"
			VALUE
			0x7485C
			DATA_RECORD_UWORD
			209712
			F_3v2_p0_152
			0
			209712
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_air_wht_fmt_fac
			"Cxx_air_wht_fmt_fac"
			VALUE
			0x7838A
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_air_wht_mpl_fac
			"Cxx_air_wht_mpl_fac"
			VALUE
			0x7594C
			DATA_RECORD_SWORD
			65535
			Id_0x00
			-32768
			32767
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_aj_fast_tq_dsb_n_thd
			"Cxx_aj_fast_tq_dsb_n_thd"
			VALUE
			0x71C93
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_aj_fast_tq_tco_thd
			"Cxx_aj_fast_tq_tco_thd"
			VALUE
			0x71C94
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_aj_tqe_thd_fac
			"Cxx_aj_tqe_thd_fac"
			VALUE
			0x794F4
			DATA_RECORD_UBYTE
			15.9375
			F_0v0625_p0_84
			0
			15.9375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_alt_crt_esti_dly
			"Cxx_alt_crt_esti_dly"
			VALUE
			0x70DF6
			DATA_RECORD_UBYTE
			2040
			F_8_p0_56
			0
			2040
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_alt_crt_fmt_fac
			"Cxx_alt_crt_fmt_fac"
			VALUE
			0x71ED1
			DATA_RECORD_UBYTE
			1.1953125
			F_0v0046875_p0_153
			0
			1.1953125
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_alt_crt_h_n
			"Cxx_alt_crt_h_n"
			VALUE
			0x71ED2
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_alt_crt_l_n
			"Cxx_alt_crt_l_n"
			VALUE
			0x71ED3
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_alt_crt_ofs
			"Cxx_alt_crt_ofs"
			VALUE
			0x71ED4
			DATA_RECORD_UBYTE
			12.036
			F_0v0472_p0_154
			0
			12.036
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_alt_efy
			"Cxx_alt_efy"
			VALUE
			0x78772
			DATA_RECORD_UBYTE
			2.55
			F_0v01_p0_155
			0
			2.55
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_alt_load_nok
			"Cxx_alt_load_nok"
			VALUE
			0x71ED5
			DATA_RECORD_UBYTE
			100.393755
			F_0v393701_p0_156
			0
			100.393755
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_alt_pow_fil_fac
			"Cxx_alt_pow_fil_fac"
			VALUE
			0x794F5
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_alt_pwm_edg_max_dly
			"Cxx_alt_pwm_edg_max_dly"
			VALUE
			0x70DF7
			DATA_RECORD_UBYTE
			1020
			F_4_p0_128
			0
			1020
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_alt_pwm_fil_fac
			"Cxx_alt_pwm_fil_fac"
			VALUE
			0x70DF8
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_alt_rat_fail_dly
			"Cxx_alt_rat_fail_dly"
			VALUE
			0x70E14
			DATA_RECORD_UWORD
			524280
			F_8_p0_56
			0
			524280
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_alt_temp_tco_ofs
			"Cxx_alt_temp_tco_ofs"
			VALUE
			0x70DE0
			DATA_RECORD_SBYTE
			159.375
			F_0v625_p0_143
			-80
			79.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_alt_tq_fil_fac
			"Cxx_alt_tq_fil_fac"
			VALUE
			0x794F6
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_alt_v_fil_fac
			"Cxx_alt_v_fil_fac"
			VALUE
			0x70DF9
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_alti_ini_fil_is_i
			"Cxx_alti_ini_fil_is_i"
			VALUE
			0x73A8D
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_alti_inj_cor
			"Cxx_alti_inj_cor"
			VALUE
			0x758A4
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_alti_is_cor
			"Cxx_alti_is_cor"
			VALUE
			0x73A8E
			DATA_RECORD_UBYTE
			199.21875
			F_0v78125_p0_16
			0
			199.21875
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_alti_is_dec
			"Cxx_alti_is_dec"
			VALUE
			0x73BFA
			DATA_RECORD_UWORD
			199.9969482
			F_0v0030517578_p0_157
			0
			199.9969482
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_alti_map_fil_fac
			"Cxx_alti_map_fil_fac"
			VALUE
			0x78476
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_alti_pinj_cor_fac
			"Cxx_alti_pinj_cor_fac"
			VALUE
			0x758A5
			DATA_RECORD_UBYTE
			199.21875
			F_0v78125_p0_16
			0
			199.21875
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_alti_prs2_fac
			"Cxx_alti_prs2_fac"
			VALUE
			0x758A6
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_alti_prs_dft_val
			"Cxx_alti_prs_dft_val"
			VALUE
			0x78477
			DATA_RECORD_UBYTE
			943.5
			F_3v7_p0_21
			0
			943.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_alti_prs_fil_fac
			"Cxx_alti_prs_fil_fac"
			VALUE
			0x78478
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_alti_upd_t_rst
			"Cxx_alti_upd_t_rst"
			VALUE
			0x70D70
			DATA_RECORD_UWORD
			67107.84
			F_1v024_p0_119
			0
			67107.84
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_amp_inj_cut_dly
			"Cxx_amp_inj_cut_dly"
			VALUE
			0x7ADC8
			DATA_RECORD_UBYTE
			32640
			F_128_p0_125
			0
			32640
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_amp_is_dly
			"Cxx_amp_is_dly"
			VALUE
			0x7ADC9
			DATA_RECORD_UBYTE
			32640
			F_128_p0_125
			0
			32640
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_amp_kd_dly
			"Cxx_amp_kd_dly"
			VALUE
			0x78479
			DATA_RECORD_UBYTE
			32640
			F_128_p0_125
			0
			32640
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_amp_prs_cge_n_thd
			"Cxx_amp_prs_cge_n_thd"
			VALUE
			0x7847A
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_amp_prs_dif_thd
			"Cxx_amp_prs_dif_thd"
			VALUE
			0x78480
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p0_21
			0
			242479.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_amp_spg_dif_fac
			"Cxx_amp_spg_dif_fac"
			VALUE
			0x7B0AE
			DATA_RECORD_UWORD
			1939836
			F_29v6_p1_158
			1
			1939837
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_aod_dly_ini
			"Cxx_aod_dly_ini"
			VALUE
			0x73622
			DATA_RECORD_UBYTE
			4080
			F_16_p0_10
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_aper_rich_sta_tco_thd
			"Cxx_aper_rich_sta_tco_thd"
			VALUE
			0x758A7
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_aper_rich_sta_tia_thd
			"Cxx_aper_rich_sta_tia_thd"
			VALUE
			0x758A8
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_appl_ti_ofs_ctr
			"Cxx_appl_ti_ofs_ctr"
			VALUE
			0x758A9
			DATA_RECORD_UBYTE
			255
			F_1_p0_53
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_appl_ti_ofs_ctr_lpg
			"Cxx_appl_ti_ofs_ctr_lpg"
			VALUE
			0x758AA
			DATA_RECORD_UBYTE
			255
			F_1_p0_53
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ar_flr_tmp_dsb
			"Cxx_ar_flr_tmp_dsb"
			VALUE
			0x7ABF0
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ar_flr_tmp_min
			"Cxx_ar_flr_tmp_min"
			VALUE
			0x7ABF2
			DATA_RECORD_UWORD
			62500.7295
			F_0v9537_p0_73
			0
			62500.7295
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_asd_lean_cylr
			"Cxx_asd_lean_cylr"
			VALUE
			0x758AB
			DATA_RECORD_UBYTE
			198.9
			F_0v78_m100_47
			-100
			98.9
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_asd_rich_cylr
			"Cxx_asd_rich_cylr"
			VALUE
			0x758AC
			DATA_RECORD_UBYTE
			198.9
			F_0v78_m100_47
			-100
			98.9
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_asr_ctr
			"Cxx_asr_ctr"
			VALUE
			0x71ED6
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_asr_msr_abst_dly
			"Cxx_asr_msr_abst_dly"
			VALUE
			0x71ED7
			DATA_RECORD_UBYTE
			4080
			F_16_p0_10
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_aut_eng_n_thd
			"Cxx_aut_eng_n_thd"
			VALUE
			0x736FC
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_aut_swi1_is_ofs
			"Cxx_aut_swi1_is_ofs"
			VALUE
			0x758AF
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_aut_swi1_is_ofs_lpg
			"Cxx_aut_swi1_is_ofs_lpg"
			VALUE
			0x758B0
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_aut_swi_is_ofs
			"Cxx_aut_swi_is_ofs"
			VALUE
			0x758AD
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_aut_swi_is_ofs_lpg
			"Cxx_aut_swi_is_ofs_lpg"
			VALUE
			0x758AE
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_bch_in_angl
			"Cxx_bch_in_angl"
			VALUE
			0x735DC
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_33
			0
			95.625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_bch_mod_nr
			"Cxx_bch_mod_nr"
			VALUE
			0x794F7
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_bch_mod_tq
			"Cxx_bch_mod_tq"
			VALUE
			0x794F8
			DATA_RECORD_UBYTE
			510
			F_2_m100_36
			-100
			410
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_bfr_cl_ctr
			"Cxx_bfr_cl_ctr"
			VALUE
			0x758B1
			DATA_RECORD_UBYTE
			255
			F_1_p0_53
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_bfr_cl_ctr_lpg
			"Cxx_bfr_cl_ctr_lpg"
			VALUE
			0x758B2
			DATA_RECORD_UBYTE
			255
			F_1_p0_53
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_brk_det_dly
			"Cxx_brk_det_dly"
			VALUE
			0x78EF8
			DATA_RECORD_UBYTE
			8160
			F_32_p0_122
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_brk_min_decl_thd
			"Cxx_brk_min_decl_thd"
			VALUE
			0x78EF9
			DATA_RECORD_UBYTE
			25.5
			F_0v1_p0_159
			0
			25.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_c_id1
			"Cxx_c_id1"
			VALUE
			0x731C3
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_c_id10
			"Cxx_c_id10"
			VALUE
			0x731CC
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_c_id11
			"Cxx_c_id11"
			VALUE
			0x731CD
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_c_id12
			"Cxx_c_id12"
			VALUE
			0x731CE
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_c_id13
			"Cxx_c_id13"
			VALUE
			0x731CF
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_c_id14
			"Cxx_c_id14"
			VALUE
			0x731D0
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_c_id15
			"Cxx_c_id15"
			VALUE
			0x731D1
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_c_id16
			"Cxx_c_id16"
			VALUE
			0x731D2
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_c_id2
			"Cxx_c_id2"
			VALUE
			0x731C4
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_c_id3
			"Cxx_c_id3"
			VALUE
			0x731C5
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_c_id4
			"Cxx_c_id4"
			VALUE
			0x731C6
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_c_id5
			"Cxx_c_id5"
			VALUE
			0x731C7
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_c_id6
			"Cxx_c_id6"
			VALUE
			0x731C8
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_c_id7
			"Cxx_c_id7"
			VALUE
			0x731C9
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_c_id8
			"Cxx_c_id8"
			VALUE
			0x731CA
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_c_id9
			"Cxx_c_id9"
			VALUE
			0x731CB
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_c_nr1
			"Cxx_c_nr1"
			VALUE
			0x73216
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_c_nr2
			"Cxx_c_nr2"
			VALUE
			0x73217
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cart_dyn_iga_tco_thd
			"Cxx_cart_dyn_iga_tco_thd"
			VALUE
			0x71C95
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cart_dyn_iga_vs
			"Cxx_cart_dyn_iga_vs"
			VALUE
			0x71C96
			DATA_RECORD_UBYTE
			255
			F_1_p0_58
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cart_iga_fil_cold_inc
			"Cxx_cart_iga_fil_cold_inc"
			VALUE
			0x71C97
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cart_iga_fil_dec
			"Cxx_cart_iga_fil_dec"
			VALUE
			0x71C98
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cart_iga_fil_inc
			"Cxx_cart_iga_fil_inc"
			VALUE
			0x71C99
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cata_asd_cl_stab_dly
			"Cxx_cata_asd_cl_stab_dly"
			VALUE
			0x776DD
			DATA_RECORD_UBYTE
			16320
			F_64_p0_145
			0
			16320
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cata_asd_diag_nr
			"Cxx_cata_asd_diag_nr"
			VALUE
			0x776DE
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cata_asd_in_nr
			"Cxx_cata_asd_in_nr"
			VALUE
			0x776DF
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cata_asd_maf_dif_max
			"Cxx_cata_asd_maf_dif_max"
			VALUE
			0x776E0
			DATA_RECORD_UBYTE
			255
			F_1_p0_9
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cata_asd_maf_max
			"Cxx_cata_asd_maf_max"
			VALUE
			0x776E1
			DATA_RECORD_UBYTE
			255
			F_1_p0_9
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cata_asd_maf_mes_max
			"Cxx_cata_asd_maf_mes_max"
			VALUE
			0x776E2
			DATA_RECORD_UBYTE
			255
			F_1_p0_9
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cata_asd_maf_min
			"Cxx_cata_asd_maf_min"
			VALUE
			0x776E3
			DATA_RECORD_UBYTE
			255
			F_1_p0_9
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cata_asd_n_max
			"Cxx_cata_asd_n_max"
			VALUE
			0x776E4
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cata_asd_n_min
			"Cxx_cata_asd_n_min"
			VALUE
			0x776E5
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cata_asd_sf_nr
			"Cxx_cata_asd_sf_nr"
			VALUE
			0x776E6
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cata_asd_tco_min
			"Cxx_cata_asd_tco_min"
			VALUE
			0x776E7
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_160
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cata_cl_stab_dly_min
			"Cxx_cata_cl_stab_dly_min"
			VALUE
			0x776E8
			DATA_RECORD_UBYTE
			16320
			F_64_p0_145
			0
			16320
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cata_hys_maf
			"Cxx_cata_hys_maf"
			VALUE
			0x776E9
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cata_hys_n
			"Cxx_cata_hys_n"
			VALUE
			0x776EA
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cata_in_nr
			"Cxx_cata_in_nr"
			VALUE
			0x776EB
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cata_maf_dif_max
			"Cxx_cata_maf_dif_max"
			VALUE
			0x776EC
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cata_maf_max
			"Cxx_cata_maf_max"
			VALUE
			0x776ED
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cata_maf_mes_max
			"Cxx_cata_maf_mes_max"
			VALUE
			0x776EE
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cata_maf_min
			"Cxx_cata_maf_min"
			VALUE
			0x776EF
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cata_n_max
			"Cxx_cata_n_max"
			VALUE
			0x776F0
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cata_n_min
			"Cxx_cata_n_min"
			VALUE
			0x776F1
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cata_ofs_neg_1
			"Cxx_cata_ofs_neg_1"
			VALUE
			0x78312
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cata_ofs_neg_2
			"Cxx_cata_ofs_neg_2"
			VALUE
			0x78314
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cata_ofs_ol_lbdw_fil
			"Cxx_cata_ofs_ol_lbdw_fil"
			VALUE
			0x776F2
			DATA_RECORD_UBYTE
			2488.8
			F_9v76_p0_45
			0
			2488.8
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cata_ofs_pos_1
			"Cxx_cata_ofs_pos_1"
			VALUE
			0x78316
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cata_ofs_pos_2
			"Cxx_cata_ofs_pos_2"
			VALUE
			0x78318
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cata_ol_apl
			"Cxx_cata_ol_apl"
			VALUE
			0x7831A
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cata_ol_per_dly
			"Cxx_cata_ol_per_dly"
			VALUE
			0x776F3
			DATA_RECORD_UBYTE
			2040
			F_8_p0_56
			0
			2040
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cata_ol_per_dly_mes
			"Cxx_cata_ol_per_dly_mes"
			VALUE
			0x776F4
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cata_ol_per_dly_stab
			"Cxx_cata_ol_per_dly_stab"
			VALUE
			0x776F5
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cata_ol_test_max_nr
			"Cxx_cata_ol_test_max_nr"
			VALUE
			0x776F6
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cata_ol_thd_lbdw_fil
			"Cxx_cata_ol_thd_lbdw_fil"
			VALUE
			0x776F7
			DATA_RECORD_UBYTE
			2488.8
			F_9v76_p0_45
			0
			2488.8
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cata_tb_fac
			"Cxx_cata_tb_fac"
			VALUE
			0x776F8
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cata_tb_ofs
			"Cxx_cata_tb_ofs"
			VALUE
			0x7701C
			DATA_RECORD_SBYTE
			255
			Id_0x00
			-128
			127
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cata_tco_min
			"Cxx_cata_tco_min"
			VALUE
			0x776F9
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cata_win_max
			"Cxx_cata_win_max"
			VALUE
			0x776FA
			DATA_RECORD_UBYTE
			2488.8
			F_9v76_p0_45
			0
			2488.8
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cata_win_min
			"Cxx_cata_win_min"
			VALUE
			0x776FB
			DATA_RECORD_UBYTE
			2488.8
			F_9v76_p0_45
			0
			2488.8
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cata_wup_dstb_n_max
			"Cxx_cata_wup_dstb_n_max"
			VALUE
			0x70E19
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cata_wup_dstb_ofs
			"Cxx_cata_wup_dstb_ofs"
			VALUE
			0x70FB4
			DATA_RECORD_UWORD
			65535
			F_1_p0_9
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cata_wup_dstb_prs_max
			"Cxx_cata_wup_dstb_prs_max"
			VALUE
			0x70FB6
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cata_wup_dstb_prs_min
			"Cxx_cata_wup_dstb_prs_min"
			VALUE
			0x70FB8
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cata_wup_sta_obd_eol
			"Cxx_cata_wup_sta_obd_eol"
			VALUE
			0x70FBA
			DATA_RECORD_UWORD
			65535
			F_1_p0_53
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cert_nr1
			"Cxx_cert_nr1"
			VALUE
			0x7321C
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cert_nr2
			"Cxx_cert_nr2"
			VALUE
			0x7321D
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cert_nr3
			"Cxx_cert_nr3"
			VALUE
			0x7321E
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cert_nr4
			"Cxx_cert_nr4"
			VALUE
			0x7321F
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cert_nr5
			"Cxx_cert_nr5"
			VALUE
			0x73220
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cl2_act_ctr
			"Cxx_cl2_act_ctr"
			VALUE
			0x758B7
			DATA_RECORD_UBYTE
			130560
			F_512_p0_104
			0
			130560
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cl2_asd_map_thd
			"Cxx_cl2_asd_map_thd"
			VALUE
			0x76F5A
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cl2_ena_ctr
			"Cxx_cl2_ena_ctr"
			VALUE
			0x76F5C
			DATA_RECORD_UWORD
			65535
			F_1_p0_53
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cl2_map_thd
			"Cxx_cl2_map_thd"
			VALUE
			0x76F5E
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cl2_n_thd
			"Cxx_cl2_n_thd"
			VALUE
			0x758B8
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cl_lean_ctr
			"Cxx_cl_lean_ctr"
			VALUE
			0x758B3
			DATA_RECORD_UBYTE
			2040
			F_8_p0_56
			0
			2040
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cl_off_n_thd
			"Cxx_cl_off_n_thd"
			VALUE
			0x758B4
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cl_run_prs_thd
			"Cxx_cl_run_prs_thd"
			VALUE
			0x76F56
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cl_stop_prs_thd
			"Cxx_cl_stop_prs_thd"
			VALUE
			0x76F58
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cl_t_fac
			"Cxx_cl_t_fac"
			VALUE
			0x758B5
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cl_ti_obd_fil_fac
			"Cxx_cl_ti_obd_fil_fac"
			VALUE
			0x758B6
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_clc_ct_pdl_psn_hys
			"Cxx_clc_ct_pdl_psn_hys"
			VALUE
			0x71ED8
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_clc_ct_pdl_psn_thd
			"Cxx_clc_ct_pdl_psn_thd"
			VALUE
			0x71ED9
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_clc_gear_det_l_gear
			"Cxx_clc_gear_det_l_gear"
			VALUE
			0x78A89
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_clc_gear_rat_hys_1
			"Cxx_clc_gear_rat_hys_1"
			VALUE
			0x78A8A
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_clc_gear_rat_hys_2
			"Cxx_clc_gear_rat_hys_2"
			VALUE
			0x78A8B
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_clc_gear_rat_hys_n
			"Cxx_clc_gear_rat_hys_n"
			VALUE
			0x78A80
			DATA_RECORD_SBYTE
			8160
			F_32_p0_46
			-4096
			4064
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_clc_gear_rat_stab_1
			"Cxx_clc_gear_rat_stab_1"
			VALUE
			0x78A8C
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_clc_gear_rat_stab_2
			"Cxx_clc_gear_rat_stab_2"
			VALUE
			0x78A8D
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_clc_gear_rat_stab_dly
			"Cxx_clc_gear_rat_stab_dly"
			VALUE
			0x78A8E
			DATA_RECORD_UBYTE
			16320
			F_64_p0_145
			0
			16320
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_clc_pdl_max_psn_thd
			"Cxx_clc_pdl_max_psn_thd"
			VALUE
			0x78EFA
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cld_ad_nr
			"Cxx_cld_ad_nr"
			VALUE
			0x758B9
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_clos_thr_n_max
			"Cxx_clos_thr_n_max"
			VALUE
			0x7ABF4
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_clos_thr_n_min
			"Cxx_clos_thr_n_min"
			VALUE
			0x7ABF6
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_clos_thr_tia_min
			"Cxx_clos_thr_tia_min"
			VALUE
			0x794F9
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_clos_thr_vs_max
			"Cxx_clos_thr_vs_max"
			VALUE
			0x794FA
			DATA_RECORD_UBYTE
			255
			F_1_p0_58
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_clu_acc
			"Cxx_clu_acc"
			VALUE
			0x7214F
			DATA_RECORD_UBYTE
			4080
			F_16_p0_10
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_clu_fail_vs_thd
			"Cxx_clu_fail_vs_thd"
			VALUE
			0x736E5
			DATA_RECORD_UBYTE
			255
			F_1_p0_58
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cmd_mdf_dly
			"Cxx_cmd_mdf_dly"
			VALUE
			0x7372F
			DATA_RECORD_UBYTE
			4177.92
			F_16v384_p0_161
			0
			4177.92
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cmd_vvt_req_off_tdc
			"Cxx_cmd_vvt_req_off_tdc"
			VALUE
			0x71C9A
			DATA_RECORD_UBYTE
			255
			F_1_p0_53
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cmd_vvt_req_on_tdc
			"Cxx_cmd_vvt_req_on_tdc"
			VALUE
			0x71C9B
			DATA_RECORD_UBYTE
			255
			F_1_p0_53
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cold_agb
			"Cxx_cold_agb"
			VALUE
			0x78B93
			DATA_RECORD_UBYTE
			4080
			F_16_p0_83
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cold_agb_tco_is_n_ofs
			"Cxx_cold_agb_tco_is_n_ofs"
			VALUE
			0x78B94
			DATA_RECORD_UBYTE
			4080
			F_16_p0_83
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cold_drag_red
			"Cxx_cold_drag_red"
			VALUE
			0x78B95
			DATA_RECORD_UBYTE
			4080
			F_16_p0_83
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cold_drag_red_tco_is_n_ofs
			"Cxx_cold_drag_red_tco_is_n_ofs"
			VALUE
			0x78B96
			DATA_RECORD_UBYTE
			4080
			F_16_p0_83
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cold_loop_kd_rich_fac
			"Cxx_cold_loop_kd_rich_fac"
			VALUE
			0x758BA
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cold_pn
			"Cxx_cold_pn"
			VALUE
			0x78B97
			DATA_RECORD_UBYTE
			4080
			F_16_p0_83
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cold_pn_tco_is_n_ofs
			"Cxx_cold_pn_tco_is_n_ofs"
			VALUE
			0x78B98
			DATA_RECORD_UBYTE
			4080
			F_16_p0_83
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cold_sta_tco
			"Cxx_cold_sta_tco"
			VALUE
			0x71C9C
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cor_fil_cata_hot_dec
			"Cxx_cor_fil_cata_hot_dec"
			VALUE
			0x73A8F
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cor_fil_cata_hot_inc
			"Cxx_cor_fil_cata_hot_inc"
			VALUE
			0x73A90
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cp_ad_tco_min_thd
			"Cxx_cp_ad_tco_min_thd"
			VALUE
			0x7879A
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cp_ad_thd
			"Cxx_cp_ad_thd"
			VALUE
			0x7879B
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cp_fac_pwm
			"Cxx_cp_fac_pwm"
			VALUE
			0x7879C
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cp_fac_rel
			"Cxx_cp_fac_rel"
			VALUE
			0x7879D
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cp_fil_cl_ti_fac
			"Cxx_cp_fil_cl_ti_fac"
			VALUE
			0x7879E
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cp_flr_min_1
			"Cxx_cp_flr_min_1"
			VALUE
			0x78A6A
			DATA_RECORD_UWORD
			255.5865
			F_0v0039_p0_114
			0
			255.5865
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cp_flr_min_2
			"Cxx_cp_flr_min_2"
			VALUE
			0x78A6C
			DATA_RECORD_UWORD
			255.5865
			F_0v0039_p0_114
			0
			255.5865
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cp_frq_1
			"Cxx_cp_frq_1"
			VALUE
			0x7879F
			DATA_RECORD_UBYTE
			255
			F_1_p0_162
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cp_frq_2
			"Cxx_cp_frq_2"
			VALUE
			0x787A0
			DATA_RECORD_UBYTE
			255
			F_1_p0_162
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cp_grd_fac
			"Cxx_cp_grd_fac"
			VALUE
			0x787A1
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cp_hys_n_frq
			"Cxx_cp_hys_n_frq"
			VALUE
			0x787A2
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cp_inc_ad
			"Cxx_cp_inc_ad"
			VALUE
			0x78A6E
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cp_is_cor
			"Cxx_cp_is_cor"
			VALUE
			0x73A91
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cp_is_tco_min_thd
			"Cxx_cp_is_tco_min_thd"
			VALUE
			0x787A3
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cp_is_tia_min_thd
			"Cxx_cp_is_tia_min_thd"
			VALUE
			0x787A4
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cp_lamb_fac_mv_thd_1
			"Cxx_cp_lamb_fac_mv_thd_1"
			VALUE
			0x76F60
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cp_lamb_fac_mv_thd_2
			"Cxx_cp_lamb_fac_mv_thd_2"
			VALUE
			0x76F62
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cp_max_ad
			"Cxx_cp_max_ad"
			VALUE
			0x787A5
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cp_max_ad_dly
			"Cxx_cp_max_ad_dly"
			VALUE
			0x787A6
			DATA_RECORD_UBYTE
			1020
			F_4_p0_163
			0
			1020
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cp_max_dly
			"Cxx_cp_max_dly"
			VALUE
			0x787A7
			DATA_RECORD_UBYTE
			1020
			F_4_p0_163
			0
			1020
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cp_max_prs_thd
			"Cxx_cp_max_prs_thd"
			VALUE
			0x78A70
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cp_min_ad_dly
			"Cxx_cp_min_ad_dly"
			VALUE
			0x787A8
			DATA_RECORD_UBYTE
			1020
			F_4_p0_163
			0
			1020
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cp_min_dly
			"Cxx_cp_min_dly"
			VALUE
			0x787A9
			DATA_RECORD_UBYTE
			1020
			F_4_p0_163
			0
			1020
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cp_n_frq
			"Cxx_cp_n_frq"
			VALUE
			0x787AA
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cp_n_thd
			"Cxx_cp_n_thd"
			VALUE
			0x787AB
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cp_ol_tco_min_thd
			"Cxx_cp_ol_tco_min_thd"
			VALUE
			0x787AC
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cp_pwm_cor_max
			"Cxx_cp_pwm_cor_max"
			VALUE
			0x78A72
			DATA_RECORD_UWORD
			255.5865
			F_0v0039_p0_114
			0
			255.5865
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cp_pwm_max_1
			"Cxx_cp_pwm_max_1"
			VALUE
			0x787AD
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cp_pwm_max_2
			"Cxx_cp_pwm_max_2"
			VALUE
			0x787AE
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cp_pwm_max_3
			"Cxx_cp_pwm_max_3"
			VALUE
			0x787AF
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cp_pwm_max_4
			"Cxx_cp_pwm_max_4"
			VALUE
			0x787B0
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cp_pwm_min_1
			"Cxx_cp_pwm_min_1"
			VALUE
			0x78A74
			DATA_RECORD_UWORD
			100.26855
			F_0v00153_p0_164
			0
			100.26855
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cp_pwm_min_2
			"Cxx_cp_pwm_min_2"
			VALUE
			0x78A76
			DATA_RECORD_UWORD
			100.26855
			F_0v00153_p0_164
			0
			100.26855
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cp_pwm_sp1
			"Cxx_cp_pwm_sp1"
			VALUE
			0x78A78
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cp_pwm_sp2
			"Cxx_cp_pwm_sp2"
			VALUE
			0x78A7A
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cp_pwm_sp3
			"Cxx_cp_pwm_sp3"
			VALUE
			0x78A7C
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cp_pwm_sp4
			"Cxx_cp_pwm_sp4"
			VALUE
			0x78A7E
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cp_pwm_step_1
			"Cxx_cp_pwm_step_1"
			VALUE
			0x787B1
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cp_pwm_step_2
			"Cxx_cp_pwm_step_2"
			VALUE
			0x787B2
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cp_pwm_step_3
			"Cxx_cp_pwm_step_3"
			VALUE
			0x787B3
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cp_pwm_step_4
			"Cxx_cp_pwm_step_4"
			VALUE
			0x787B4
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cp_pwm_step_5
			"Cxx_cp_pwm_step_5"
			VALUE
			0x787B5
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cp_rel_step_lamb_fac
			"Cxx_cp_rel_step_lamb_fac"
			VALUE
			0x787B6
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cp_rtn_dly_dec
			"Cxx_cp_rtn_dly_dec"
			VALUE
			0x787B7
			DATA_RECORD_UBYTE
			1020
			F_4_p0_163
			0
			1020
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cp_stab_dly
			"Cxx_cp_stab_dly"
			VALUE
			0x787B8
			DATA_RECORD_UBYTE
			16320
			F_64_p0_145
			0
			16320
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cp_step_lamb_fac
			"Cxx_cp_step_lamb_fac"
			VALUE
			0x787B9
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cp_t_off
			"Cxx_cp_t_off"
			VALUE
			0x758BB
			DATA_RECORD_UBYTE
			8160
			F_32_p0_122
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cp_t_on
			"Cxx_cp_t_on"
			VALUE
			0x758BC
			DATA_RECORD_UBYTE
			8160
			F_32_p0_122
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cp_tco_min_thd
			"Cxx_cp_tco_min_thd"
			VALUE
			0x787BA
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cp_tia_min_thd
			"Cxx_cp_tia_min_thd"
			VALUE
			0x787BB
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cp_trs_h_thd
			"Cxx_cp_trs_h_thd"
			VALUE
			0x7838B
			DATA_RECORD_UBYTE
			2488.8
			F_9v76_p0_45
			0
			2488.8
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cp_trs_h_thd_lpg
			"Cxx_cp_trs_h_thd_lpg"
			VALUE
			0x7838C
			DATA_RECORD_UBYTE
			2488.8
			F_9v76_p0_45
			0
			2488.8
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cp_trs_l_thd
			"Cxx_cp_trs_l_thd"
			VALUE
			0x7838D
			DATA_RECORD_UBYTE
			2488.8
			F_9v76_p0_45
			0
			2488.8
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cp_trs_l_thd_lpg
			"Cxx_cp_trs_l_thd_lpg"
			VALUE
			0x7838E
			DATA_RECORD_UBYTE
			2488.8
			F_9v76_p0_45
			0
			2488.8
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_crk1_bas_toth_nr
			"Cxx_crk1_bas_toth_nr"
			VALUE
			0x70CAE
			DATA_RECORD_UBYTE
			255
			F_1_p0_165
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_crk_nr_dft_n_max
			"Cxx_crk_nr_dft_n_max"
			VALUE
			0x78498
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_crk_nr_dft_n_min
			"Cxx_crk_nr_dft_n_min"
			VALUE
			0x78499
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_crk_toth_nr
			"Cxx_crk_toth_nr"
			VALUE
			0x7849A
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cru_abst_vs_dly
			"Cxx_cru_abst_vs_dly"
			VALUE
			0x78EFB
			DATA_RECORD_UBYTE
			8.16
			F_0v032_p0_99
			0
			8.16
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cru_cmf_cut_tqe_dec
			"Cxx_cru_cmf_cut_tqe_dec"
			VALUE
			0x78FC6
			DATA_RECORD_UWORD
			31999.51172
			F_0v48828125_p0_166
			0
			31999.51172
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cru_efv_vs_thd
			"Cxx_cru_efv_vs_thd"
			VALUE
			0x78EFC
			DATA_RECORD_UBYTE
			25.5
			F_0v1_p0_167
			0
			25.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cru_lk_ena_dly
			"Cxx_cru_lk_ena_dly"
			VALUE
			0x78EFD
			DATA_RECORD_UBYTE
			32.64
			F_0v128_p0_75
			0
			32.64
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cru_max_vs
			"Cxx_cru_max_vs"
			VALUE
			0x78EFE
			DATA_RECORD_UBYTE
			255
			F_1_p0_58
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cru_min_tq
			"Cxx_cru_min_tq"
			VALUE
			0x78EFF
			DATA_RECORD_UBYTE
			510
			F_2_m100_36
			-100
			410
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cru_min_vs
			"Cxx_cru_min_vs"
			VALUE
			0x78F00
			DATA_RECORD_UBYTE
			255
			F_1_p0_58
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cru_no_efv_vs_thd
			"Cxx_cru_no_efv_vs_thd"
			VALUE
			0x78F01
			DATA_RECORD_UBYTE
			25.5
			F_0v1_p0_167
			0
			25.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cru_nok_vs_dly
			"Cxx_cru_nok_vs_dly"
			VALUE
			0x78F02
			DATA_RECORD_UBYTE
			8.16
			F_0v032_p0_99
			0
			8.16
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cru_ref_vs_acel_grd
			"Cxx_cru_ref_vs_acel_grd"
			VALUE
			0x78D60
			DATA_RECORD_SBYTE
			0.255
			F_0v001_p0_168
			-0.128
			0.127
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cru_ref_vs_acel_ofs
			"Cxx_cru_ref_vs_acel_ofs"
			VALUE
			0x78F03
			DATA_RECORD_UBYTE
			25.5
			F_0v1_p0_169
			0
			25.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cru_ref_vs_decl_grd
			"Cxx_cru_ref_vs_decl_grd"
			VALUE
			0x78D61
			DATA_RECORD_SBYTE
			0.255
			F_0v001_p0_168
			-0.128
			0.127
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cru_ref_vs_decl_ofs
			"Cxx_cru_ref_vs_decl_ofs"
			VALUE
			0x78F04
			DATA_RECORD_UBYTE
			25.5
			F_0v1_p0_169
			0
			25.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cru_sl_acel_max_rat
			"Cxx_cru_sl_acel_max_rat"
			VALUE
			0x78F05
			DATA_RECORD_UBYTE
			255
			F_1_p0_170
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cru_sl_acel_min_rat
			"Cxx_cru_sl_acel_min_rat"
			VALUE
			0x78F06
			DATA_RECORD_UBYTE
			255
			F_1_p0_170
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cru_sl_decl_max_rat
			"Cxx_cru_sl_decl_max_rat"
			VALUE
			0x78F07
			DATA_RECORD_UBYTE
			255
			F_1_p0_170
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cru_sl_decl_min_rat
			"Cxx_cru_sl_decl_min_rat"
			VALUE
			0x78F08
			DATA_RECORD_UBYTE
			255
			F_1_p0_170
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cru_sl_fil_acel_fac
			"Cxx_cru_sl_fil_acel_fac"
			VALUE
			0x78F09
			DATA_RECORD_UBYTE
			0.9945
			F_0v0039_p0_171
			0
			0.9945
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cru_sl_fil_vs_fac
			"Cxx_cru_sl_fil_vs_fac"
			VALUE
			0x78F0A
			DATA_RECORD_UBYTE
			0.9945
			F_0v0039_p0_171
			0
			0.9945
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cru_sl_lk_ena_dly
			"Cxx_cru_sl_lk_ena_dly"
			VALUE
			0x78F0B
			DATA_RECORD_UBYTE
			8.16
			F_0v032_p0_99
			0
			8.16
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cru_sl_lk_vb_thd
			"Cxx_cru_sl_lk_vb_thd"
			VALUE
			0x78FC8
			DATA_RECORD_UWORD
			8.191875
			F_0v000125_p8_7
			8
			16.191875
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cru_sl_long_sp_dec_t
			"Cxx_cru_sl_long_sp_dec_t"
			VALUE
			0x78F0C
			DATA_RECORD_UBYTE
			2.04
			F_0v008_p0_172
			0
			2.04
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cru_sl_long_sp_inc_t
			"Cxx_cru_sl_long_sp_inc_t"
			VALUE
			0x78F0D
			DATA_RECORD_UBYTE
			2.04
			F_0v008_p0_172
			0
			2.04
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cru_sl_long_step
			"Cxx_cru_sl_long_step"
			VALUE
			0x78F0E
			DATA_RECORD_UBYTE
			255
			F_1_p0_58
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cru_sl_nok_swi_dly
			"Cxx_cru_sl_nok_swi_dly"
			VALUE
			0x78F0F
			DATA_RECORD_UBYTE
			32.64
			F_0v128_p0_75
			0
			32.64
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cru_sl_nok_whl_swi_dly
			"Cxx_cru_sl_nok_whl_swi_dly"
			VALUE
			0x78F10
			DATA_RECORD_UBYTE
			2040
			F_8_p0_56
			0
			2040
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cru_sl_open_min_rat
			"Cxx_cru_sl_open_min_rat"
			VALUE
			0x78F11
			DATA_RECORD_UBYTE
			255
			F_1_p0_170
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cru_sl_resu_max_rat
			"Cxx_cru_sl_resu_max_rat"
			VALUE
			0x78F12
			DATA_RECORD_UBYTE
			255
			F_1_p0_170
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cru_sl_resu_min_rat
			"Cxx_cru_sl_resu_min_rat"
			VALUE
			0x78F13
			DATA_RECORD_UBYTE
			255
			F_1_p0_170
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cru_sl_rls_max_rat
			"Cxx_cru_sl_rls_max_rat"
			VALUE
			0x78F14
			DATA_RECORD_UBYTE
			255
			F_1_p0_170
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cru_sl_rls_min_rat
			"Cxx_cru_sl_rls_min_rat"
			VALUE
			0x78F15
			DATA_RECORD_UBYTE
			255
			F_1_p0_170
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cru_sl_smal_step
			"Cxx_cru_sl_smal_step"
			VALUE
			0x78F16
			DATA_RECORD_UBYTE
			255
			F_1_p0_58
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cru_sl_sp_inc_t
			"Cxx_cru_sl_sp_inc_t"
			VALUE
			0x78F17
			DATA_RECORD_UBYTE
			32.64
			F_0v128_p0_75
			0
			32.64
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cru_sl_susp_max_rat
			"Cxx_cru_sl_susp_max_rat"
			VALUE
			0x78F18
			DATA_RECORD_UBYTE
			255
			F_1_p0_170
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cru_sl_swi_dly
			"Cxx_cru_sl_swi_dly"
			VALUE
			0x78F19
			DATA_RECORD_UBYTE
			32.64
			F_0v128_p0_75
			0
			32.64
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cru_sl_warn_dly
			"Cxx_cru_sl_warn_dly"
			VALUE
			0x78F1A
			DATA_RECORD_UBYTE
			25.5
			F_0v1_p0_173
			0
			25.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cru_sl_whl_swi_dly
			"Cxx_cru_sl_whl_swi_dly"
			VALUE
			0x78F1B
			DATA_RECORD_UBYTE
			2040
			F_8_p0_56
			0
			2040
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cru_sp_acel_grd
			"Cxx_cru_sp_acel_grd"
			VALUE
			0x78D62
			DATA_RECORD_SBYTE
			0.255
			F_0v001_p0_168
			-0.128
			0.127
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cru_sp_decl_grd
			"Cxx_cru_sp_decl_grd"
			VALUE
			0x78D63
			DATA_RECORD_SBYTE
			0.255
			F_0v001_p0_168
			-0.128
			0.127
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cru_sp_max_inc
			"Cxx_cru_sp_max_inc"
			VALUE
			0x78FCA
			DATA_RECORD_UWORD
			31999.51172
			F_0v48828125_m100_174
			-100
			31899.51172
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cru_svkl_ig
			"Cxx_cru_svkl_ig"
			VALUE
			0x78FCC
			DATA_RECORD_UWORD
			1953.093731
			F_0v0298023_p0_175
			0
			1953.093731
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cru_svkl_max_i_cor
			"Cxx_cru_svkl_max_i_cor"
			VALUE
			0x78F32
			DATA_RECORD_SWORD
			124.9949055
			F_0v0019073_p0_176
			-62.4984064
			62.4964991
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cru_svkl_min_i_cor
			"Cxx_cru_svkl_min_i_cor"
			VALUE
			0x78F34
			DATA_RECORD_SWORD
			124.9949055
			F_0v0019073_p0_176
			-62.4984064
			62.4964991
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cru_svkl_pg
			"Cxx_cru_svkl_pg"
			VALUE
			0x78FCE
			DATA_RECORD_UWORD
			124.9949055
			F_0v0019073_p0_177
			0
			124.9949055
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cru_svkl_vs_thd
			"Cxx_cru_svkl_vs_thd"
			VALUE
			0x78D64
			DATA_RECORD_SBYTE
			255
			F_1_p0_58
			-128
			127
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cru_vs_sp_rat
			"Cxx_cru_vs_sp_rat"
			VALUE
			0x78F1C
			DATA_RECORD_UBYTE
			255
			F_1_p0_170
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_csm_fil_fac
			"Cxx_csm_fil_fac"
			VALUE
			0x73191
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ct_dsb_pdl_psn_dif
			"Cxx_ct_dsb_pdl_psn_dif"
			VALUE
			0x784B9
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ct_dsb_pdl_psn_thd
			"Cxx_ct_dsb_pdl_psn_thd"
			VALUE
			0x784BA
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ct_fac_step_dec
			"Cxx_ct_fac_step_dec"
			VALUE
			0x71C9D
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ct_fac_step_inc
			"Cxx_ct_fac_step_inc"
			VALUE
			0x71C9E
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ct_pdl_mem_ofs
			"Cxx_ct_pdl_mem_ofs"
			VALUE
			0x784BB
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ct_pdl_ofs
			"Cxx_ct_pdl_ofs"
			VALUE
			0x784BC
			DATA_RECORD_UBYTE
			255
			F_1_p0_9
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ct_pdl_psn_hys
			"Cxx_ct_pdl_psn_hys"
			VALUE
			0x784BD
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ct_pdl_psn_thd
			"Cxx_ct_pdl_psn_thd"
			VALUE
			0x784BE
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ct_pdl_tco_thd
			"Cxx_ct_pdl_tco_thd"
			VALUE
			0x758BD
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ct_stat_tq_ofs
			"Cxx_ct_stat_tq_ofs"
			VALUE
			0x790E0
			DATA_RECORD_SBYTE
			127.5
			F_0v5_p0_28
			-64
			63.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ct_stop_tkof_fil_fac
			"Cxx_ct_stop_tkof_fil_fac"
			VALUE
			0x794FB
			DATA_RECORD_UBYTE
			0.99609375
			F_0v00390625_p0_90
			0
			0.99609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ctr_frm_csm_gas
			"Cxx_ctr_frm_csm_gas"
			VALUE
			0x71EDA
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ctr_frm_csm_lpg
			"Cxx_ctr_frm_csm_lpg"
			VALUE
			0x71EDB
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cut_decl_gear_thd1
			"Cxx_cut_decl_gear_thd1"
			VALUE
			0x758BE
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cut_decl_gear_thd2
			"Cxx_cut_decl_gear_thd2"
			VALUE
			0x758BF
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cut_decl_gear_thd3
			"Cxx_cut_decl_gear_thd3"
			VALUE
			0x758C0
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cut_decl_gear_thd4
			"Cxx_cut_decl_gear_thd4"
			VALUE
			0x758C1
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cut_decl_tco_thd
			"Cxx_cut_decl_tco_thd"
			VALUE
			0x758C2
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cut_decl_tco_thd1
			"Cxx_cut_decl_tco_thd1"
			VALUE
			0x758C4
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cut_decl_tco_thd1_lpg
			"Cxx_cut_decl_tco_thd1_lpg"
			VALUE
			0x758C5
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cut_decl_tco_thd_lpg
			"Cxx_cut_decl_tco_thd_lpg"
			VALUE
			0x758C3
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cut_fac_step_dec
			"Cxx_cut_fac_step_dec"
			VALUE
			0x71C9F
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cut_n_ofs
			"Cxx_cut_n_ofs"
			VALUE
			0x758C6
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cut_n_ofs2
			"Cxx_cut_n_ofs2"
			VALUE
			0x758C7
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cut_tqr_thd_n
			"Cxx_cut_tqr_thd_n"
			VALUE
			0x71CA0
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cut_tqr_thd_n_lpg
			"Cxx_cut_tqr_thd_n_lpg"
			VALUE
			0x71CA1
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cut_tqr_thd_prs
			"Cxx_cut_tqr_thd_prs"
			VALUE
			0x71DCC
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cut_tqr_thd_prs_lpg
			"Cxx_cut_tqr_thd_prs_lpg"
			VALUE
			0x71DCE
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cyl1_ti_dstb_iga
			"Cxx_cyl1_ti_dstb_iga"
			VALUE
			0x70FC0
			DATA_RECORD_SBYTE
			95.625
			F_0v375_p0_29
			-48
			47.625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cyl1_ti_dstb_iga_is
			"Cxx_cyl1_ti_dstb_iga_is"
			VALUE
			0x70FC4
			DATA_RECORD_SBYTE
			95.625
			F_0v375_p0_29
			-48
			47.625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cyl1_ti_dstb_iga_lpg
			"Cxx_cyl1_ti_dstb_iga_lpg"
			VALUE
			0x70FC8
			DATA_RECORD_SBYTE
			95.625
			F_0v375_p0_29
			-48
			47.625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cyl2_ti_dstb_iga
			"Cxx_cyl2_ti_dstb_iga"
			VALUE
			0x70FC3
			DATA_RECORD_SBYTE
			95.625
			F_0v375_p0_29
			-48
			47.625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cyl2_ti_dstb_iga_is
			"Cxx_cyl2_ti_dstb_iga_is"
			VALUE
			0x70FC7
			DATA_RECORD_SBYTE
			95.625
			F_0v375_p0_29
			-48
			47.625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cyl2_ti_dstb_iga_lpg
			"Cxx_cyl2_ti_dstb_iga_lpg"
			VALUE
			0x70FCB
			DATA_RECORD_SBYTE
			95.625
			F_0v375_p0_29
			-48
			47.625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cyl3_ti_dstb_iga
			"Cxx_cyl3_ti_dstb_iga"
			VALUE
			0x70FC1
			DATA_RECORD_SBYTE
			95.625
			F_0v375_p0_29
			-48
			47.625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cyl3_ti_dstb_iga_is
			"Cxx_cyl3_ti_dstb_iga_is"
			VALUE
			0x70FC5
			DATA_RECORD_SBYTE
			95.625
			F_0v375_p0_29
			-48
			47.625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cyl3_ti_dstb_iga_lpg
			"Cxx_cyl3_ti_dstb_iga_lpg"
			VALUE
			0x70FC9
			DATA_RECORD_SBYTE
			95.625
			F_0v375_p0_29
			-48
			47.625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cyl4_ti_dstb_iga
			"Cxx_cyl4_ti_dstb_iga"
			VALUE
			0x70FC2
			DATA_RECORD_SBYTE
			95.625
			F_0v375_p0_29
			-48
			47.625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cyl4_ti_dstb_iga_is
			"Cxx_cyl4_ti_dstb_iga_is"
			VALUE
			0x70FC6
			DATA_RECORD_SBYTE
			95.625
			F_0v375_p0_29
			-48
			47.625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cyl4_ti_dstb_iga_lpg
			"Cxx_cyl4_ti_dstb_iga_lpg"
			VALUE
			0x70FCA
			DATA_RECORD_SBYTE
			95.625
			F_0v375_p0_29
			-48
			47.625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cyl_nr
			"Cxx_cyl_nr"
			VALUE
			0x794FC
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cylr_alti_prs_max_fac
			"Cxx_cylr_alti_prs_max_fac"
			VALUE
			0x70CAF
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cylr_alti_prs_min_fac
			"Cxx_cylr_alti_prs_min_fac"
			VALUE
			0x70CB0
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cylr_clc_ctr
			"Cxx_cylr_clc_ctr"
			VALUE
			0x70CB1
			DATA_RECORD_UBYTE
			1020
			F_4_p0_178
			0
			1020
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cylr_clc_ctr_lpg
			"Cxx_cylr_clc_ctr_lpg"
			VALUE
			0x70CB2
			DATA_RECORD_UBYTE
			1020
			F_4_p0_178
			0
			1020
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cylr_cold_is_stab_t
			"Cxx_cylr_cold_is_stab_t"
			VALUE
			0x70CB3
			DATA_RECORD_UBYTE
			1020
			F_4_p0_178
			0
			1020
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cylr_cp_ti_fac
			"Cxx_cylr_cp_ti_fac"
			VALUE
			0x758C8
			DATA_RECORD_UBYTE
			198.9
			F_0v78_p0_179
			0
			198.9
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cylr_eol_mod
			"Cxx_cylr_eol_mod"
			VALUE
			0x70CB4
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cylr_gear
			"Cxx_cylr_gear"
			VALUE
			0x70CB5
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cylr_is_clc_ctr
			"Cxx_cylr_is_clc_ctr"
			VALUE
			0x70CB6
			DATA_RECORD_UBYTE
			1020
			F_4_p0_178
			0
			1020
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cylr_is_clc_ctr_lpg
			"Cxx_cylr_is_clc_ctr_lpg"
			VALUE
			0x70CB7
			DATA_RECORD_UBYTE
			1020
			F_4_p0_178
			0
			1020
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cylr_is_max_test_nr
			"Cxx_cylr_is_max_test_nr"
			VALUE
			0x70CB8
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cylr_is_max_tq_dec
			"Cxx_cylr_is_max_tq_dec"
			VALUE
			0x70CD4
			DATA_RECORD_SWORD
			6553.5
			F_0v1_p0_22
			-3276.8
			3276.7
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cylr_is_max_tq_dec1
			"Cxx_cylr_is_max_tq_dec1"
			VALUE
			0x70CD6
			DATA_RECORD_SWORD
			6553.5
			F_0v1_p0_22
			-3276.8
			3276.7
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cylr_is_min_tq_dec
			"Cxx_cylr_is_min_tq_dec"
			VALUE
			0x70CD8
			DATA_RECORD_SWORD
			6553.5
			F_0v1_p0_22
			-3276.8
			3276.7
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cylr_is_min_tq_dec1
			"Cxx_cylr_is_min_tq_dec1"
			VALUE
			0x70CDA
			DATA_RECORD_SWORD
			6553.5
			F_0v1_p0_22
			-3276.8
			3276.7
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cylr_is_neg_clu_stal
			"Cxx_cylr_is_neg_clu_stal"
			VALUE
			0x70CB9
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cylr_is_run_max_tco
			"Cxx_cylr_is_run_max_tco"
			VALUE
			0x70CBA
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cylr_is_run_min_tco
			"Cxx_cylr_is_run_min_tco"
			VALUE
			0x70CBB
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cylr_is_run_n_fac
			"Cxx_cylr_is_run_n_fac"
			VALUE
			0x70CBC
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cylr_is_ti_fac_min
			"Cxx_cylr_is_ti_fac_min"
			VALUE
			0x70D06
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cylr_l_n_re_phs
			"Cxx_cylr_l_n_re_phs"
			VALUE
			0x70CBD
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cylr_l_prs_dif_fac
			"Cxx_cylr_l_prs_dif_fac"
			VALUE
			0x70CBE
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cylr_l_prs_re_phs
			"Cxx_cylr_l_prs_re_phs"
			VALUE
			0x70D08
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cylr_max_dif_iga
			"Cxx_cylr_max_dif_iga"
			VALUE
			0x70CBF
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cylr_max_mv_lamb_fac
			"Cxx_cylr_max_mv_lamb_fac"
			VALUE
			0x70CC0
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cylr_max_n
			"Cxx_cylr_max_n"
			VALUE
			0x70CC1
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cylr_max_n_lpg
			"Cxx_cylr_max_n_lpg"
			VALUE
			0x70CC2
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cylr_max_prs
			"Cxx_cylr_max_prs"
			VALUE
			0x70D0A
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cylr_max_prs_lpg
			"Cxx_cylr_max_prs_lpg"
			VALUE
			0x70D0C
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cylr_max_tco
			"Cxx_cylr_max_tco"
			VALUE
			0x70CC3
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cylr_max_test_nr
			"Cxx_cylr_max_test_nr"
			VALUE
			0x70CC4
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cylr_max_tq_dec
			"Cxx_cylr_max_tq_dec"
			VALUE
			0x70CDC
			DATA_RECORD_SWORD
			6553.5
			F_0v1_p0_22
			-3276.8
			3276.7
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cylr_max_tq_dec_lpg
			"Cxx_cylr_max_tq_dec_lpg"
			VALUE
			0x70CDE
			DATA_RECORD_SWORD
			6553.5
			F_0v1_p0_22
			-3276.8
			3276.7
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cylr_min_mv_lamb_fac
			"Cxx_cylr_min_mv_lamb_fac"
			VALUE
			0x70CC5
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cylr_min_n
			"Cxx_cylr_min_n"
			VALUE
			0x70CC6
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cylr_min_n_lpg
			"Cxx_cylr_min_n_lpg"
			VALUE
			0x70CC7
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cylr_min_prs
			"Cxx_cylr_min_prs"
			VALUE
			0x70D0E
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cylr_min_prs_lpg
			"Cxx_cylr_min_prs_lpg"
			VALUE
			0x70D10
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cylr_min_tco
			"Cxx_cylr_min_tco"
			VALUE
			0x70CC8
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cylr_min_tq_dec
			"Cxx_cylr_min_tq_dec"
			VALUE
			0x70CE0
			DATA_RECORD_SWORD
			6553.5
			F_0v1_p0_22
			-3276.8
			3276.7
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cylr_min_tq_dec_lpg
			"Cxx_cylr_min_tq_dec_lpg"
			VALUE
			0x70CE2
			DATA_RECORD_SWORD
			6553.5
			F_0v1_p0_22
			-3276.8
			3276.7
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cylr_n_stab_dif
			"Cxx_cylr_n_stab_dif"
			VALUE
			0x70CC9
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cylr_stab_ctr
			"Cxx_cylr_stab_ctr"
			VALUE
			0x70CCA
			DATA_RECORD_UBYTE
			255
			F_1_p0_53
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cylr_stab_ctr_lpg
			"Cxx_cylr_stab_ctr_lpg"
			VALUE
			0x70CCB
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cylr_stab_inj_dif
			"Cxx_cylr_stab_inj_dif"
			VALUE
			0x70CCC
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cylr_stab_is_ctr
			"Cxx_cylr_stab_is_ctr"
			VALUE
			0x70CCD
			DATA_RECORD_UBYTE
			255
			F_1_p0_53
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cylr_stab_is_ctr_lpg
			"Cxx_cylr_stab_is_ctr_lpg"
			VALUE
			0x70CCE
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cylr_stab_t
			"Cxx_cylr_stab_t"
			VALUE
			0x70CCF
			DATA_RECORD_UBYTE
			1020
			F_4_p0_178
			0
			1020
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cylr_tco_thd
			"Cxx_cylr_tco_thd"
			VALUE
			0x758C9
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_cylr_trz_stab_dif
			"Cxx_cylr_trz_stab_dif"
			VALUE
			0x70D12
			DATA_RECORD_UWORD
			6553.5
			F_0v1_p0_22
			0
			6553.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_deb_dly
			"Cxx_deb_dly"
			VALUE
			0x73623
			DATA_RECORD_UBYTE
			4080
			F_16_p0_10
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_decl_cut_n_ofs
			"Cxx_decl_cut_n_ofs"
			VALUE
			0x758CA
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_decl_esti_tqe_fil_fac
			"Cxx_decl_esti_tqe_fil_fac"
			VALUE
			0x794FD
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_decl_fast_slop
			"Cxx_decl_fast_slop"
			VALUE
			0x758CB
			DATA_RECORD_UBYTE
			127.5
			F_0v5_p0_146
			0
			127.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_decl_fast_slop_lean
			"Cxx_decl_fast_slop_lean"
			VALUE
			0x758CC
			DATA_RECORD_UBYTE
			127.5
			F_0v5_p0_146
			0
			127.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_decl_knk_fil_fac
			"Cxx_decl_knk_fil_fac"
			VALUE
			0x72570
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_decl_lean_dsb_n_ofs
			"Cxx_decl_lean_dsb_n_ofs"
			VALUE
			0x7865C
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_decl_lean_dsb_n_thd
			"Cxx_decl_lean_dsb_n_thd"
			VALUE
			0x7865D
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_decl_prs_lean_dsb_dly
			"Cxx_decl_prs_lean_dsb_dly"
			VALUE
			0x7865E
			DATA_RECORD_UBYTE
			261.12
			F_1v024_p0_119
			0
			261.12
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_degr_cut_gear_thd
			"Cxx_degr_cut_gear_thd"
			VALUE
			0x758CD
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_det_wup_tco_ofs
			"Cxx_det_wup_tco_ofs"
			VALUE
			0x736CC
			DATA_RECORD_UBYTE
			159.375
			F_0v625_p0_143
			0
			159.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dft_agb_tq_sp_lim
			"Cxx_dft_agb_tq_sp_lim"
			VALUE
			0x71EDC
			DATA_RECORD_UBYTE
			510
			F_2_m100_36
			-100
			410
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dft_cp_load
			"Cxx_dft_cp_load"
			VALUE
			0x794FE
			DATA_RECORD_UBYTE
			0.99609375
			F_0v00390625_p0_90
			0
			0.99609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dft_lft_trt
			"Cxx_dft_lft_trt"
			VALUE
			0x73638
			DATA_RECORD_UWORD
			2867.8116
			F_0v04376_p0_180
			0
			2867.8116
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dft_lght_km_rst_wup
			"Cxx_dft_lght_km_rst_wup"
			VALUE
			0x731EF
			DATA_RECORD_UBYTE
			255
			F_1_p0_9
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dft_lght_off_tco_thd
			"Cxx_dft_lght_off_tco_thd"
			VALUE
			0x7B18F
			DATA_RECORD_UBYTE
			159.375
			F_0v625_p0_143
			0
			159.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dft_lght_on_dec
			"Cxx_dft_lght_on_dec"
			VALUE
			0x731F0
			DATA_RECORD_UBYTE
			255
			F_1_p0_9
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dft_lght_on_inc
			"Cxx_dft_lght_on_inc"
			VALUE
			0x731F1
			DATA_RECORD_UBYTE
			255
			F_1_p0_9
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dft_lght_on_tco_thd
			"Cxx_dft_lght_on_tco_thd"
			VALUE
			0x7B190
			DATA_RECORD_UBYTE
			159.375
			F_0v625_p0_143
			0
			159.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dft_rgt_trt
			"Cxx_dft_rgt_trt"
			VALUE
			0x7363A
			DATA_RECORD_UWORD
			2867.8116
			F_0v04376_p0_180
			0
			2867.8116
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_diag_fil_ti_ofs2_fac1
			"Cxx_diag_fil_ti_ofs2_fac1"
			VALUE
			0x758CE
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_diag_fil_ti_ofs2_fac2
			"Cxx_diag_fil_ti_ofs2_fac2"
			VALUE
			0x758CF
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_diag_knk_acq_fac
			"Cxx_diag_knk_acq_fac"
			VALUE
			0x72571
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_diag_knk_acq_frq
			"Cxx_diag_knk_acq_frq"
			VALUE
			0x72572
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_diag_knk_acq_int
			"Cxx_diag_knk_acq_int"
			VALUE
			0x72573
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_diag_knk_bpf_frq
			"Cxx_diag_knk_bpf_frq"
			VALUE
			0x7264A
			DATA_RECORD_UWORD
			18.48044938
			D_2_0v0004_p0v054_181
			0.03806913355
			18.51851852
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_diag_knk_n
			"Cxx_diag_knk_n"
			VALUE
			0x72574
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_diag_knk_tco
			"Cxx_diag_knk_tco"
			VALUE
			0x72575
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_diag_knk_tdc_nr
			"Cxx_diag_knk_tdc_nr"
			VALUE
			0x7264C
			DATA_RECORD_UWORD
			65535
			F_1_p0_53
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_diag_knk_win_frst
			"Cxx_diag_knk_win_frst"
			VALUE
			0x72576
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_diag_knk_win_long
			"Cxx_diag_knk_win_long"
			VALUE
			0x72577
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_diag_nr
			"Cxx_diag_nr"
			VALUE
			0x73209
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_diag_tmp_max_is_n
			"Cxx_diag_tmp_max_is_n"
			VALUE
			0x78AB4
			DATA_RECORD_SBYTE
			4080
			F_16_p0_83
			-2048
			2032
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_diag_tmp_min_is_n
			"Cxx_diag_tmp_min_is_n"
			VALUE
			0x78AB5
			DATA_RECORD_SBYTE
			4080
			F_16_p0_83
			-2048
			2032
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_diag_trs_h_thd
			"Cxx_diag_trs_h_thd"
			VALUE
			0x7838F
			DATA_RECORD_UBYTE
			2488.8
			F_9v76_p0_45
			0
			2488.8
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_diag_trs_h_thd_lpg
			"Cxx_diag_trs_h_thd_lpg"
			VALUE
			0x78390
			DATA_RECORD_UBYTE
			2488.8
			F_9v76_p0_45
			0
			2488.8
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_diag_trs_l_thd
			"Cxx_diag_trs_l_thd"
			VALUE
			0x78391
			DATA_RECORD_UBYTE
			2488.8
			F_9v76_p0_45
			0
			2488.8
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_diag_trs_l_thd_lpg
			"Cxx_diag_trs_l_thd_lpg"
			VALUE
			0x78392
			DATA_RECORD_UBYTE
			2488.8
			F_9v76_p0_45
			0
			2488.8
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dif_mes_esti_prs_err
			"Cxx_dif_mes_esti_prs_err"
			VALUE
			0x7873E
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p0_21
			0
			242479.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dly_ocl_alti_thd
			"Cxx_dly_ocl_alti_thd"
			VALUE
			0x758D0
			DATA_RECORD_UBYTE
			943.5
			F_3v7_p0_21
			0
			943.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dly_ocl_knk_thd
			"Cxx_dly_ocl_knk_thd"
			VALUE
			0x758D1
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dly_ocl_l_n_thd
			"Cxx_dly_ocl_l_n_thd"
			VALUE
			0x758D2
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dly_ocl_tco_thd
			"Cxx_dly_ocl_tco_thd"
			VALUE
			0x758D3
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dly_ocl_up_n_thd
			"Cxx_dly_ocl_up_n_thd"
			VALUE
			0x758D4
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_down_diag_oc_hot_t
			"Cxx_down_diag_oc_hot_t"
			VALUE
			0x78393
			DATA_RECORD_UBYTE
			1020
			F_4_p0_163
			0
			1020
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_down_eol_diag_hot_t
			"Cxx_down_eol_diag_hot_t"
			VALUE
			0x78394
			DATA_RECORD_UBYTE
			1020
			F_4_p0_163
			0
			1020
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_down_eol_oc_det_v
			"Cxx_down_eol_oc_det_v"
			VALUE
			0x78395
			DATA_RECORD_UBYTE
			2488.8
			F_9v76_p0_45
			0
			2488.8
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_drag_red_tco_is_n_ofs
			"Cxx_drag_red_tco_is_n_ofs"
			VALUE
			0x78B99
			DATA_RECORD_UBYTE
			4080
			F_16_p0_83
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dri_agb_ad_is_fil
			"Cxx_dri_agb_ad_is_fil"
			VALUE
			0x73A92
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dri_sp_is_cor
			"Cxx_dri_sp_is_cor"
			VALUE
			0x73A93
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dstb_inj1_ti_fac
			"Cxx_dstb_inj1_ti_fac"
			VALUE
			0x7588E
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dstb_inj1_ti_fac_is
			"Cxx_dstb_inj1_ti_fac_is"
			VALUE
			0x75892
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dstb_inj1_ti_fac_lpg
			"Cxx_dstb_inj1_ti_fac_lpg"
			VALUE
			0x737DE
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dstb_inj2_ti_fac
			"Cxx_dstb_inj2_ti_fac"
			VALUE
			0x75891
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dstb_inj2_ti_fac_is
			"Cxx_dstb_inj2_ti_fac_is"
			VALUE
			0x75895
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dstb_inj2_ti_fac_lpg
			"Cxx_dstb_inj2_ti_fac_lpg"
			VALUE
			0x737DF
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dstb_inj3_ti_fac
			"Cxx_dstb_inj3_ti_fac"
			VALUE
			0x7588F
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dstb_inj3_ti_fac_is
			"Cxx_dstb_inj3_ti_fac_is"
			VALUE
			0x75893
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dstb_inj3_ti_fac_lpg
			"Cxx_dstb_inj3_ti_fac_lpg"
			VALUE
			0x737E0
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dstb_inj4_ti_fac
			"Cxx_dstb_inj4_ti_fac"
			VALUE
			0x75890
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dstb_inj4_ti_fac_is
			"Cxx_dstb_inj4_ti_fac_is"
			VALUE
			0x75894
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dstb_inj4_ti_fac_lpg
			"Cxx_dstb_inj4_ti_fac_lpg"
			VALUE
			0x737E1
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dstb_ti_ofs_cor
			"Cxx_dstb_ti_ofs_cor"
			VALUE
			0x7594E
			DATA_RECORD_SWORD
			65535
			Id_0x00
			-32768
			32767
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dstb_ti_ofs_cor_lpg
			"Cxx_dstb_ti_ofs_cor_lpg"
			VALUE
			0x75950
			DATA_RECORD_SWORD
			65535
			F_1_p0_9
			-32768
			32767
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dstb_ti_p_cor
			"Cxx_dstb_ti_p_cor"
			VALUE
			0x7486C
			DATA_RECORD_SBYTE
			255
			Id_0x00
			-128
			127
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dstb_ti_p_cor_lpg
			"Cxx_dstb_ti_p_cor_lpg"
			VALUE
			0x7486D
			DATA_RECORD_SBYTE
			255
			F_1_p0_9
			-128
			127
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_ac_prs
			"Cxx_dtc_ac_prs"
			VALUE
			0x700D4
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_ac_rcpt
			"Cxx_dtc_ac_rcpt"
			VALUE
			0x700D6
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_acr
			"Cxx_dtc_acr"
			VALUE
			0x700C0
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_actr_rly
			"Cxx_dtc_actr_rly"
			VALUE
			0x700D8
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_agb_conv_stt
			"Cxx_dtc_agb_conv_stt"
			VALUE
			0x700DA
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_agb_gear
			"Cxx_dtc_agb_gear"
			VALUE
			0x700DC
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_agb_rcpt
			"Cxx_dtc_agb_rcpt"
			VALUE
			0x70032
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_air
			"Cxx_dtc_air"
			VALUE
			0x70034
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_alt
			"Cxx_dtc_alt"
			VALUE
			0x700C2
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_bkup_mem
			"Cxx_dtc_bkup_mem"
			VALUE
			0x70036
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_clu
			"Cxx_dtc_clu"
			VALUE
			0x70038
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_cp
			"Cxx_dtc_cp"
			VALUE
			0x70004
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_crk
			"Cxx_dtc_crk"
			VALUE
			0x7003A
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_crk_nr
			"Cxx_dtc_crk_nr"
			VALUE
			0x7003C
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_cru_brk_cnt1
			"Cxx_dtc_cru_brk_cnt1"
			VALUE
			0x700DE
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_cru_brk_cnt2
			"Cxx_dtc_cru_brk_cnt2"
			VALUE
			0x700E0
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_cru_on_off_chr
			"Cxx_dtc_cru_on_off_chr"
			VALUE
			0x700E2
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_cru_whl_cmd
			"Cxx_dtc_cru_whl_cmd"
			VALUE
			0x700E4
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_el_wind_rcpt
			"Cxx_dtc_el_wind_rcpt"
			VALUE
			0x700E6
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_eng_temp
			"Cxx_dtc_eng_temp"
			VALUE
			0x700C4
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_eng_whl
			"Cxx_dtc_eng_whl"
			VALUE
			0x7003E
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_fsys
			"Cxx_dtc_fsys"
			VALUE
			0x70040
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_fsys_lpg
			"Cxx_dtc_fsys_lpg"
			VALUE
			0x70042
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_gas_pump
			"Cxx_dtc_gas_pump"
			VALUE
			0x70006
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_igc_1
			"Cxx_dtc_igc_1"
			VALUE
			0x70008
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_igc_2
			"Cxx_dtc_igc_2"
			VALUE
			0x7000A
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_igc_3
			"Cxx_dtc_igc_3"
			VALUE
			0x7000C
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_igc_4
			"Cxx_dtc_igc_4"
			VALUE
			0x7000E
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_inj1
			"Cxx_dtc_inj1"
			VALUE
			0x70010
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_inj2
			"Cxx_dtc_inj2"
			VALUE
			0x70012
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_inj3
			"Cxx_dtc_inj3"
			VALUE
			0x70014
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_inj4
			"Cxx_dtc_inj4"
			VALUE
			0x70016
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_inj_ecu
			"Cxx_dtc_inj_ecu"
			VALUE
			0x70044
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_ip_inj_cnt
			"Cxx_dtc_ip_inj_cnt"
			VALUE
			0x700E8
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_knk
			"Cxx_dtc_knk"
			VALUE
			0x70046
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_lbdw
			"Cxx_dtc_lbdw"
			VALUE
			0x70018
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_lbdw_hot
			"Cxx_dtc_lbdw_hot"
			VALUE
			0x7001A
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_lbdw_pump_crt
			"Cxx_dtc_lbdw_pump_crt"
			VALUE
			0x700EA
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_lbup
			"Cxx_dtc_lbup"
			VALUE
			0x7001C
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_lbup_hot
			"Cxx_dtc_lbup_hot"
			VALUE
			0x7001E
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_lbup_pump_crt
			"Cxx_dtc_lbup_pump_crt"
			VALUE
			0x700EC
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_lpg_rcpt
			"Cxx_dtc_lpg_rcpt"
			VALUE
			0x70048
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_map
			"Cxx_dtc_map"
			VALUE
			0x7004A
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_map_chr
			"Cxx_dtc_map_chr"
			VALUE
			0x70092
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_mcut_sens1
			"Cxx_dtc_mcut_sens1"
			VALUE
			0x700EE
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_mdf1
			"Cxx_dtc_mdf1"
			VALUE
			0x700C6
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_mdf2
			"Cxx_dtc_mdf2"
			VALUE
			0x700C8
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_min_gas_lvl
			"Cxx_dtc_min_gas_lvl"
			VALUE
			0x7004C
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_min_lpg_lvl
			"Cxx_dtc_min_lpg_lvl"
			VALUE
			0x700F0
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_mis_cata
			"Cxx_dtc_mis_cata"
			VALUE
			0x7004E
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_mis_cata_1
			"Cxx_dtc_mis_cata_1"
			VALUE
			0x70050
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_mis_cata_1_lpg
			"Cxx_dtc_mis_cata_1_lpg"
			VALUE
			0x70052
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_mis_cata_2
			"Cxx_dtc_mis_cata_2"
			VALUE
			0x70054
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_mis_cata_2_lpg
			"Cxx_dtc_mis_cata_2_lpg"
			VALUE
			0x70056
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_mis_cata_3
			"Cxx_dtc_mis_cata_3"
			VALUE
			0x70058
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_mis_cata_3_lpg
			"Cxx_dtc_mis_cata_3_lpg"
			VALUE
			0x7005A
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_mis_cata_4
			"Cxx_dtc_mis_cata_4"
			VALUE
			0x7005C
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_mis_cata_4_lpg
			"Cxx_dtc_mis_cata_4_lpg"
			VALUE
			0x7005E
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_mis_cata_gas
			"Cxx_dtc_mis_cata_gas"
			VALUE
			0x70060
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_mis_cata_lpg
			"Cxx_dtc_mis_cata_lpg"
			VALUE
			0x70062
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_mis_fast
			"Cxx_dtc_mis_fast"
			VALUE
			0x70094
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_mis_lih
			"Cxx_dtc_mis_lih"
			VALUE
			0x700F2
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_mis_polu
			"Cxx_dtc_mis_polu"
			VALUE
			0x70064
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_mis_polu_1
			"Cxx_dtc_mis_polu_1"
			VALUE
			0x70066
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_mis_polu_1_lpg
			"Cxx_dtc_mis_polu_1_lpg"
			VALUE
			0x70068
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_mis_polu_2
			"Cxx_dtc_mis_polu_2"
			VALUE
			0x7006A
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_mis_polu_2_lpg
			"Cxx_dtc_mis_polu_2_lpg"
			VALUE
			0x7006C
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_mis_polu_3
			"Cxx_dtc_mis_polu_3"
			VALUE
			0x7006E
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_mis_polu_3_lpg
			"Cxx_dtc_mis_polu_3_lpg"
			VALUE
			0x70070
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_mis_polu_4
			"Cxx_dtc_mis_polu_4"
			VALUE
			0x70072
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_mis_polu_4_lpg
			"Cxx_dtc_mis_polu_4_lpg"
			VALUE
			0x70074
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_mis_polu_gas
			"Cxx_dtc_mis_polu_gas"
			VALUE
			0x70076
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_mis_polu_lpg
			"Cxx_dtc_mis_polu_lpg"
			VALUE
			0x70078
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_mvac_pump_oc
			"Cxx_dtc_mvac_pump_oc"
			VALUE
			0x700F4
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_mvac_pump_scg
			"Cxx_dtc_mvac_pump_scg"
			VALUE
			0x700F6
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_mvac_pump_vb_sc
			"Cxx_dtc_mvac_pump_vb_sc"
			VALUE
			0x700F8
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_mvac_sys
			"Cxx_dtc_mvac_sys"
			VALUE
			0x700FA
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_obd_cata
			"Cxx_dtc_obd_cata"
			VALUE
			0x7007A
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_obd_lamb
			"Cxx_dtc_obd_lamb"
			VALUE
			0x7007C
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_obd_sa
			"Cxx_dtc_obd_sa"
			VALUE
			0x7007E
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_oil
			"Cxx_dtc_oil"
			VALUE
			0x700CA
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_pdl_sens1_oc
			"Cxx_dtc_pdl_sens1_oc"
			VALUE
			0x70096
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_pdl_sens1_vb_sc
			"Cxx_dtc_pdl_sens1_vb_sc"
			VALUE
			0x70098
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_pdl_sens2_oc
			"Cxx_dtc_pdl_sens2_oc"
			VALUE
			0x7009A
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_pdl_sens2_vb_sc
			"Cxx_dtc_pdl_sens2_vb_sc"
			VALUE
			0x7009C
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_pdl_sens_chr
			"Cxx_dtc_pdl_sens_chr"
			VALUE
			0x7009E
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_pow_lbdw
			"Cxx_dtc_pow_lbdw"
			VALUE
			0x70080
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_pow_lbup
			"Cxx_dtc_pow_lbup"
			VALUE
			0x70082
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_ptc
			"Cxx_dtc_ptc"
			VALUE
			0x700FC
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_ptc_rov
			"Cxx_dtc_ptc_rov"
			VALUE
			0x700CC
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_pws_1
			"Cxx_dtc_pws_1"
			VALUE
			0x700A0
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_pws_2
			"Cxx_dtc_pws_2"
			VALUE
			0x700A2
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_pws_pdl2
			"Cxx_dtc_pws_pdl2"
			VALUE
			0x700FE
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_pws_thr_pdl1
			"Cxx_dtc_pws_thr_pdl1"
			VALUE
			0x70100
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_rams_pdl
			"Cxx_dtc_rams_pdl"
			VALUE
			0x70084
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_rams_tq_ctl
			"Cxx_dtc_rams_tq_ctl"
			VALUE
			0x700A4
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_rmc
			"Cxx_dtc_rmc"
			VALUE
			0x70090
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_sa
			"Cxx_dtc_sa"
			VALUE
			0x70020
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_sa_ev
			"Cxx_dtc_sa_ev"
			VALUE
			0x70022
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_spg
			"Cxx_dtc_spg"
			VALUE
			0x70086
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_spg_sys
			"Cxx_dtc_spg_sys"
			VALUE
			0x70088
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_spi_cc
			"Cxx_dtc_spi_cc"
			VALUE
			0x70102
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_svkl_chk_springs
			"Cxx_dtc_svkl_chk_springs"
			VALUE
			0x700A6
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_svkl_lih
			"Cxx_dtc_svkl_lih"
			VALUE
			0x700A8
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_svkl_oc
			"Cxx_dtc_svkl_oc"
			VALUE
			0x700AA
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_svkl_psn
			"Cxx_dtc_svkl_psn"
			VALUE
			0x700AC
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_svkl_sge
			"Cxx_dtc_svkl_sge"
			VALUE
			0x700AE
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_svkl_trt_srch
			"Cxx_dtc_svkl_trt_srch"
			VALUE
			0x700B0
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_swlk_mem
			"Cxx_dtc_swlk_mem"
			VALUE
			0x70104
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_tco
			"Cxx_dtc_tco"
			VALUE
			0x70024
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_thpl
			"Cxx_dtc_thpl"
			VALUE
			0x700CE
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_thr_cmd_cpt
			"Cxx_dtc_thr_cmd_cpt"
			VALUE
			0x700BC
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_thr_cmd_vb_sc
			"Cxx_dtc_thr_cmd_vb_sc"
			VALUE
			0x700BE
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_thr_sens1_oc
			"Cxx_dtc_thr_sens1_oc"
			VALUE
			0x700B2
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_thr_sens1_vb_sc
			"Cxx_dtc_thr_sens1_vb_sc"
			VALUE
			0x700B4
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_thr_sens2_scg
			"Cxx_dtc_thr_sens2_scg"
			VALUE
			0x700B6
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_thr_sens2_vb_sc
			"Cxx_dtc_thr_sens2_vb_sc"
			VALUE
			0x700B8
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_thr_sens_chr
			"Cxx_dtc_thr_sens_chr"
			VALUE
			0x700BA
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_tia
			"Cxx_dtc_tia"
			VALUE
			0x70026
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_tjy_ctl
			"Cxx_dtc_tjy_ctl"
			VALUE
			0x70106
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_tlz_ad_b
			"Cxx_dtc_tlz_ad_b"
			VALUE
			0x7008A
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_vb
			"Cxx_dtc_vb"
			VALUE
			0x700D0
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_vs
			"Cxx_dtc_vs"
			VALUE
			0x70028
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_vta_intake
			"Cxx_dtc_vta_intake"
			VALUE
			0x7002A
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_vvt_int_ev
			"Cxx_dtc_vvt_int_ev"
			VALUE
			0x7002C
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_vvt_int_old_off
			"Cxx_dtc_vvt_int_old_off"
			VALUE
			0x7008C
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_vvt_intake
			"Cxx_dtc_vvt_intake"
			VALUE
			0x7002E
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_vvtc_toth_3
			"Cxx_dtc_vvtc_toth_3"
			VALUE
			0x7008E
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_wgc
			"Cxx_dtc_wgc"
			VALUE
			0x70030
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dtc_wpmp
			"Cxx_dtc_wpmp"
			VALUE
			0x700D2
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dyn_iga_dsb_n_thd
			"Cxx_dyn_iga_dsb_n_thd"
			VALUE
			0x71CA2
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dyn_iga_efy_dz
			"Cxx_dyn_iga_efy_dz"
			VALUE
			0x7485E
			DATA_RECORD_UWORD
			15.99975586
			F_0v0002441406_p0_182
			0
			15.99975586
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dyn_iga_fil_ini_n_ofs
			"Cxx_dyn_iga_fil_ini_n_ofs"
			VALUE
			0x70FCC
			DATA_RECORD_SBYTE
			8160
			F_32_p0_46
			-4096
			4064
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dyn_iga_fil_n_ofs
			"Cxx_dyn_iga_fil_n_ofs"
			VALUE
			0x71CA3
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dyn_iga_gear_val
			"Cxx_dyn_iga_gear_val"
			VALUE
			0x71CA4
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dyn_iga_mv_clc_dly
			"Cxx_dyn_iga_mv_clc_dly"
			VALUE
			0x71CA5
			DATA_RECORD_UBYTE
			32640
			F_128_p0_125
			0
			32640
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dyn_iga_mv_n_fac
			"Cxx_dyn_iga_mv_n_fac"
			VALUE
			0x71CA6
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dyn_iga_mv_n_thd
			"Cxx_dyn_iga_mv_n_thd"
			VALUE
			0x71CA7
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dyn_iga_pdl_rel
			"Cxx_dyn_iga_pdl_rel"
			VALUE
			0x71CA8
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dyn_iga_pdl_rel_hys
			"Cxx_dyn_iga_pdl_rel_hys"
			VALUE
			0x71CA9
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dyn_iga_vs
			"Cxx_dyn_iga_vs"
			VALUE
			0x71CAA
			DATA_RECORD_UBYTE
			255
			F_1_p0_58
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dyn_iga_vs_hys
			"Cxx_dyn_iga_vs_hys"
			VALUE
			0x71CAB
			DATA_RECORD_UBYTE
			255
			F_1_p0_58
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dyn_prs_fil_ofs2
			"Cxx_dyn_prs_fil_ofs2"
			VALUE
			0x76F64
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p0_21
			0
			242479.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dz_iga_efv
			"Cxx_dz_iga_efv"
			VALUE
			0x7ABF8
			DATA_RECORD_UWORD
			511.9921875
			F_0v0078125_p0_15
			0
			511.9921875
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_dz_pdl
			"Cxx_dz_pdl"
			VALUE
			0x784BF
			DATA_RECORD_UBYTE
			255
			F_1_p0_9
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ecu_nr1
			"Cxx_ecu_nr1"
			VALUE
			0x73204
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ecu_nr2
			"Cxx_ecu_nr2"
			VALUE
			0x73205
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ecu_nr3
			"Cxx_ecu_nr3"
			VALUE
			0x73206
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ecu_nr4
			"Cxx_ecu_nr4"
			VALUE
			0x73207
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ecu_nr5
			"Cxx_ecu_nr5"
			VALUE
			0x73208
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_edic_dly
			"Cxx_edic_dly"
			VALUE
			0x776FC
			DATA_RECORD_UBYTE
			32640
			F_128_p0_125
			0
			32640
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_edic_prmt_trg_dly
			"Cxx_edic_prmt_trg_dly"
			VALUE
			0x7831C
			DATA_RECORD_UWORD
			2097120
			F_32_p0_122
			0
			2097120
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_edic_schd_trg_dly
			"Cxx_edic_schd_trg_dly"
			VALUE
			0x7831E
			DATA_RECORD_UWORD
			2097120
			F_32_p0_122
			0
			2097120
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_el_bk_wind_dly
			"Cxx_el_bk_wind_dly"
			VALUE
			0x73A94
			DATA_RECORD_UBYTE
			4080
			F_16_p0_10
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_el_bk_wind_is_cor
			"Cxx_el_bk_wind_is_cor"
			VALUE
			0x73A95
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_el_bk_wind_is_cor_dec
			"Cxx_el_bk_wind_is_cor_dec"
			VALUE
			0x73A96
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_el_bk_wind_is_cor_dly
			"Cxx_el_bk_wind_is_cor_dly"
			VALUE
			0x73A97
			DATA_RECORD_UBYTE
			4080
			F_16_p0_10
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_el_bk_wind_is_n
			"Cxx_el_bk_wind_is_n"
			VALUE
			0x78B9A
			DATA_RECORD_UBYTE
			4080
			F_16_p0_83
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_el_csm_clc_dly
			"Cxx_el_csm_clc_dly"
			VALUE
			0x78B9B
			DATA_RECORD_UBYTE
			32640
			F_128_p0_125
			0
			32640
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_el_csm_clc_neg_fac
			"Cxx_el_csm_clc_neg_fac"
			VALUE
			0x78B9C
			DATA_RECORD_UBYTE
			255
			F_1_p0_9
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_el_csm_clc_neut_vb
			"Cxx_el_csm_clc_neut_vb"
			VALUE
			0x78B9D
			DATA_RECORD_UBYTE
			7.96875
			F_0v03125_p8_183
			8
			15.96875
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_el_csm_clc_pos_fac
			"Cxx_el_csm_clc_pos_fac"
			VALUE
			0x78B9E
			DATA_RECORD_UBYTE
			255
			F_1_p0_9
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_el_wind_dec_dly
			"Cxx_el_wind_dec_dly"
			VALUE
			0x78B9F
			DATA_RECORD_UBYTE
			32640
			F_128_p0_125
			0
			32640
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_el_wind_dly
			"Cxx_el_wind_dly"
			VALUE
			0x73A98
			DATA_RECORD_UBYTE
			4080
			F_16_p0_10
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_el_wind_dri_is_cor
			"Cxx_el_wind_dri_is_cor"
			VALUE
			0x73A99
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_el_wind_is_cor_dec
			"Cxx_el_wind_is_cor_dec"
			VALUE
			0x73A9A
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_el_wind_is_cor_dly
			"Cxx_el_wind_is_cor_dly"
			VALUE
			0x73A9B
			DATA_RECORD_UBYTE
			4080
			F_16_p0_10
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_el_wind_n_dec
			"Cxx_el_wind_n_dec"
			VALUE
			0x78BA0
			DATA_RECORD_UBYTE
			4080
			F_16_p0_83
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_el_wind_neut_is_cor
			"Cxx_el_wind_neut_is_cor"
			VALUE
			0x73A9C
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_el_wind_pow
			"Cxx_el_wind_pow"
			VALUE
			0x794FF
			DATA_RECORD_UBYTE
			5100
			F_20_p0_63
			0
			5100
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_el_wind_tco
			"Cxx_el_wind_tco"
			VALUE
			0x78BA1
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_eng_air_wht_ref
			"Cxx_eng_air_wht_ref"
			VALUE
			0x7ABFA
			DATA_RECORD_UWORD
			7798.665
			F_0v119_p0_184
			0
			7798.665
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_eng_alt_fac
			"Cxx_eng_alt_fac"
			VALUE
			0x79500
			DATA_RECORD_UBYTE
			4.98046875
			F_0v01953125_p0_185
			0
			4.98046875
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_eng_stop_thr_psn_sp
			"Cxx_eng_stop_thr_psn_sp"
			VALUE
			0x7ABFC
			DATA_RECORD_UWORD
			6399.88596
			F_0v097656_p0_5
			0
			6399.88596
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_eol_lbdw_oc_air_wht
			"Cxx_eol_lbdw_oc_air_wht"
			VALUE
			0x7841C
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_etun_nr
			"Cxx_etun_nr"
			VALUE
			0x73218
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ex_gaz_cata_max_temp
			"Cxx_ex_gaz_cata_max_temp"
			VALUE
			0x776FD
			DATA_RECORD_UBYTE
			1020
			F_4_m40_88
			-40
			980
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ex_gaz_cata_min_temp
			"Cxx_ex_gaz_cata_min_temp"
			VALUE
			0x776FE
			DATA_RECORD_UBYTE
			1020
			F_4_m40_88
			-40
			980
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ex_gaz_fil_fac_inj
			"Cxx_ex_gaz_fil_fac_inj"
			VALUE
			0x776FF
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_fac_cor_thr_adj
			"Cxx_fac_cor_thr_adj"
			VALUE
			0x70D72
			DATA_RECORD_UWORD
			9999.98565
			F_0v15259_p0_186
			0
			9999.98565
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_fac_n_grd
			"Cxx_fac_n_grd"
			VALUE
			0x784C0
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_fac_n_mmv
			"Cxx_fac_n_mmv"
			VALUE
			0x78BA2
			DATA_RECORD_UBYTE
			0.9945
			F_0v0039_p0_114
			0
			0.9945
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_fail_ctr_vs_thd
			"Cxx_fail_ctr_vs_thd"
			VALUE
			0x79027
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_fail_decl_cut_n_ofs
			"Cxx_fail_decl_cut_n_ofs"
			VALUE
			0x758D5
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_fail_decl_inj_cut
			"Cxx_fail_decl_inj_cut"
			VALUE
			0x758D6
			DATA_RECORD_UBYTE
			8.16
			F_0v032_p0_99
			0
			8.16
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_fail_decl_inj_cut_lpg
			"Cxx_fail_decl_inj_cut_lpg"
			VALUE
			0x758D7
			DATA_RECORD_UBYTE
			8.16
			F_0v032_p0_99
			0
			8.16
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_fast_ad_cdn_dly
			"Cxx_fast_ad_cdn_dly"
			VALUE
			0x73BFC
			DATA_RECORD_UWORD
			2097120
			F_32_p0_122
			0
			2097120
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_fast_slop_h_thd
			"Cxx_fast_slop_h_thd"
			VALUE
			0x758D8
			DATA_RECORD_UBYTE
			943.5
			F_3v7_p0_21
			0
			943.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_fast_slop_l_thd
			"Cxx_fast_slop_l_thd"
			VALUE
			0x758D9
			DATA_RECORD_UBYTE
			943.5
			F_3v7_p0_21
			0
			943.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_fast_tq_max_lim10
			"Cxx_fast_tq_max_lim10"
			VALUE
			0x71CAC
			DATA_RECORD_UBYTE
			127.5
			F_0v5_p0_28
			0
			127.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_fast_tq_max_lim20
			"Cxx_fast_tq_max_lim20"
			VALUE
			0x71CAD
			DATA_RECORD_UBYTE
			127.5
			F_0v5_p0_28
			0
			127.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_fast_tq_max_lim30
			"Cxx_fast_tq_max_lim30"
			VALUE
			0x71CAE
			DATA_RECORD_UBYTE
			127.5
			F_0v5_p0_28
			0
			127.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_fast_tq_min_lim10
			"Cxx_fast_tq_min_lim10"
			VALUE
			0x71CAF
			DATA_RECORD_UBYTE
			127.5
			F_0v5_p0_28
			0
			127.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_fast_tq_min_lim20
			"Cxx_fast_tq_min_lim20"
			VALUE
			0x71CB0
			DATA_RECORD_UBYTE
			127.5
			F_0v5_p0_28
			0
			127.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_fast_tq_min_lim30
			"Cxx_fast_tq_min_lim30"
			VALUE
			0x71CB1
			DATA_RECORD_UBYTE
			127.5
			F_0v5_p0_28
			0
			127.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_fil_cl_ti_fac
			"Cxx_fil_cl_ti_fac"
			VALUE
			0x758DA
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_fil_cl_ti_fac_lpg
			"Cxx_fil_cl_ti_fac_lpg"
			VALUE
			0x758DB
			DATA_RECORD_UBYTE
			255
			F_1_p0_9
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_fil_fac_cor_thr_adj
			"Cxx_fil_fac_cor_thr_adj"
			VALUE
			0x70D74
			DATA_RECORD_UWORD
			99.9998565
			F_0v0015259_p0_92
			0
			99.9998565
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_fil_fac_thr_adj
			"Cxx_fil_fac_thr_adj"
			VALUE
			0x70D76
			DATA_RECORD_UWORD
			99.9998565
			F_0v0015259_p0_92
			0
			99.9998565
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_fil_fac_vb
			"Cxx_fil_fac_vb"
			VALUE
			0x71DE8
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_fil_fac_vvtc_dif
			"Cxx_fil_fac_vvtc_dif"
			VALUE
			0x7B0CA
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_fil_inj_clos_dec
			"Cxx_fil_inj_clos_dec"
			VALUE
			0x758DC
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_fil_inj_clos_inc
			"Cxx_fil_inj_clos_inc"
			VALUE
			0x758DD
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_fil_is_i_sp
			"Cxx_fil_is_i_sp"
			VALUE
			0x7218C
			DATA_RECORD_UWORD
			99.9998565
			F_0v0015259_p0_92
			0
			99.9998565
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_fil_map_fac
			"Cxx_fil_map_fac"
			VALUE
			0x784C1
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_fil_map_thr_adj
			"Cxx_fil_map_thr_adj"
			VALUE
			0x70D78
			DATA_RECORD_UWORD
			99.9998565
			F_0v0015259_p0_92
			0
			99.9998565
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_fil_mdl_map_thr_adj
			"Cxx_fil_mdl_map_thr_adj"
			VALUE
			0x70D7A
			DATA_RECORD_UWORD
			99.9998565
			F_0v0015259_p0_92
			0
			99.9998565
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_fil_n_thr_adj
			"Cxx_fil_n_thr_adj"
			VALUE
			0x70D7C
			DATA_RECORD_UWORD
			99.9998565
			F_0v0015259_p0_92
			0
			99.9998565
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_fil_thr_psn_dif_thd
			"Cxx_fil_thr_psn_dif_thd"
			VALUE
			0x7ADCA
			DATA_RECORD_UBYTE
			102
			F_0v4_p0_106
			0
			102
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_fil_ti_ofs2_fac
			"Cxx_fil_ti_ofs2_fac"
			VALUE
			0x758DE
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_filt_input_pdt1_coef
			"Cxx_filt_input_pdt1_coef"
			VALUE
			0x7337E
			DATA_RECORD_UWORD
			63.99902344
			F_0v0009765625_p0_138
			0
			63.99902344
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_filt_input_ppt1_coef
			"Cxx_filt_input_ppt1_coef"
			VALUE
			0x73380
			DATA_RECORD_UWORD
			0.99993303
			F_0v000015258_p0_187
			0
			0.99993303
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_filt_output_pdt1_coef
			"Cxx_filt_output_pdt1_coef"
			VALUE
			0x73382
			DATA_RECORD_UWORD
			0.99993303
			F_0v000015258_p0_187
			0
			0.99993303
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_filt_output_ppt1_coef
			"Cxx_filt_output_ppt1_coef"
			VALUE
			0x73384
			DATA_RECORD_UWORD
			1.999964362
			F_0v0000305175_p0_188
			0
			1.999964362
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_fl_bfr_cl_ctr
			"Cxx_fl_bfr_cl_ctr"
			VALUE
			0x758DF
			DATA_RECORD_UBYTE
			255
			F_1_p0_53
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_fl_ena_n_thd
			"Cxx_fl_ena_n_thd"
			VALUE
			0x758E0
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_fl_max_thr_ar
			"Cxx_fl_max_thr_ar"
			VALUE
			0x7ABFE
			DATA_RECORD_UWORD
			3905.886
			F_0v0596_p0_108
			0
			3905.886
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_fl_n_thd
			"Cxx_fl_n_thd"
			VALUE
			0x758E1
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_fl_n_thd_hys
			"Cxx_fl_n_thd_hys"
			VALUE
			0x758E2
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_fl_tq_hys
			"Cxx_fl_tq_hys"
			VALUE
			0x7AC00
			DATA_RECORD_UWORD
			511.9921875
			F_0v0078125_p0_15
			0
			511.9921875
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_fl_tq_ofs
			"Cxx_fl_tq_ofs"
			VALUE
			0x7AC02
			DATA_RECORD_UWORD
			511.9921875
			F_0v0078125_p0_15
			0
			511.9921875
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_flr_clc_dsb_prs_thd
			"Cxx_flr_clc_dsb_prs_thd"
			VALUE
			0x7AC04
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_fmt_pdl_h_vs_thd
			"Cxx_fmt_pdl_h_vs_thd"
			VALUE
			0x78F1D
			DATA_RECORD_UBYTE
			255
			F_1_p0_58
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_fmt_pdl_l_vs_thd
			"Cxx_fmt_pdl_l_vs_thd"
			VALUE
			0x78F1E
			DATA_RECORD_UBYTE
			255
			F_1_p0_58
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_foot_up_lh_thresh
			"Cxx_foot_up_lh_thresh"
			VALUE
			0x73253
			DATA_RECORD_UBYTE
			24.90234375
			F_0v09765625_p0_71
			0
			24.90234375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_fsys_cor_fac_eol_max
			"Cxx_fsys_cor_fac_eol_max"
			VALUE
			0x78320
			DATA_RECORD_UWORD
			65535
			F_1_p0_9
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_fsys_cor_fac_eol_min
			"Cxx_fsys_cor_fac_eol_min"
			VALUE
			0x78322
			DATA_RECORD_UWORD
			65535
			F_1_p0_9
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_fsys_cor_fac_max_1
			"Cxx_fsys_cor_fac_max_1"
			VALUE
			0x78324
			DATA_RECORD_UWORD
			65535
			F_1_p0_9
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_fsys_cor_fac_max_2
			"Cxx_fsys_cor_fac_max_2"
			VALUE
			0x78326
			DATA_RECORD_UWORD
			65535
			F_1_p0_9
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_fsys_cor_fac_min_1
			"Cxx_fsys_cor_fac_min_1"
			VALUE
			0x78328
			DATA_RECORD_UWORD
			65535
			F_1_p0_9
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_fsys_cor_fac_min_2
			"Cxx_fsys_cor_fac_min_2"
			VALUE
			0x7832A
			DATA_RECORD_UWORD
			65535
			F_1_p0_9
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_fsys_dly_1
			"Cxx_fsys_dly_1"
			VALUE
			0x77700
			DATA_RECORD_UBYTE
			261120
			F_1024_p0_189
			0
			261120
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_fsys_dly_2
			"Cxx_fsys_dly_2"
			VALUE
			0x77701
			DATA_RECORD_UBYTE
			261120
			F_1024_p0_189
			0
			261120
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_fsys_eal_max_thd
			"Cxx_fsys_eal_max_thd"
			VALUE
			0x7832C
			DATA_RECORD_UWORD
			399.9938965
			F_0v0061035156_p0_23
			0
			399.9938965
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_fsys_eal_min_thd
			"Cxx_fsys_eal_min_thd"
			VALUE
			0x7832E
			DATA_RECORD_UWORD
			399.9938965
			F_0v0061035156_p0_23
			0
			399.9938965
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_fsys_eol_dly
			"Cxx_fsys_eol_dly"
			VALUE
			0x77702
			DATA_RECORD_UBYTE
			261120
			F_1024_p0_189
			0
			261120
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_fsys_n_max_thd
			"Cxx_fsys_n_max_thd"
			VALUE
			0x78330
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_fsys_n_min_thd
			"Cxx_fsys_n_min_thd"
			VALUE
			0x78332
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_fsys_thd_2_dly
			"Cxx_fsys_thd_2_dly"
			VALUE
			0x78334
			DATA_RECORD_UWORD
			67107840
			F_1024_p0_189
			0
			67107840
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_fsys_thd_2_eol_dly
			"Cxx_fsys_thd_2_eol_dly"
			VALUE
			0x78336
			DATA_RECORD_UWORD
			67107840
			F_1024_p0_189
			0
			67107840
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_fzy_tkof_lim_dec_t
			"Cxx_fzy_tkof_lim_dec_t"
			VALUE
			0x73675
			DATA_RECORD_UBYTE
			3.984375
			F_0v015625_p0_190
			0
			3.984375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_gas_lpg_trs_cyc_nr
			"Cxx_gas_lpg_trs_cyc_nr"
			VALUE
			0x737E2
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_gas_pump_dly
			"Cxx_gas_pump_dly"
			VALUE
			0x70D20
			DATA_RECORD_UBYTE
			2040
			F_8_p0_56
			0
			2040
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_gas_pump_sta_dly
			"Cxx_gas_pump_sta_dly"
			VALUE
			0x78D55
			DATA_RECORD_UBYTE
			32.64
			F_0v128_p0_75
			0
			32.64
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_gear1_iga_dec
			"Cxx_gear1_iga_dec"
			VALUE
			0x71CB4
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_gear1_iga_dec_tdc_nr
			"Cxx_gear1_iga_dec_tdc_nr"
			VALUE
			0x71CB5
			DATA_RECORD_UBYTE
			255
			F_1_p0_53
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_gear_cge_cut_map_ofs
			"Cxx_gear_cge_cut_map_ofs"
			VALUE
			0x75952
			DATA_RECORD_SWORD
			242479.5
			F_3v7_p0_21
			-121241.6
			121237.9
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_gear_cge_dec_dly
			"Cxx_gear_cge_dec_dly"
			VALUE
			0x736E8
			DATA_RECORD_UWORD
			524.28
			F_0v008_p0_172
			0
			524.28
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_gear_cge_dly
			"Cxx_gear_cge_dly"
			VALUE
			0x736EA
			DATA_RECORD_UWORD
			1048560
			F_16_p0_10
			0
			1048560
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_gear_cge_eal_thd
			"Cxx_gear_cge_eal_thd"
			VALUE
			0x736EC
			DATA_RECORD_UWORD
			399.9938965
			F_0v0061035156_p0_23
			0
			399.9938965
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_gear_cge_fast_lim_dly
			"Cxx_gear_cge_fast_lim_dly"
			VALUE
			0x736EE
			DATA_RECORD_UWORD
			524.28
			F_0v008_p0_172
			0
			524.28
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_gear_cge_l_tq_dly
			"Cxx_gear_cge_l_tq_dly"
			VALUE
			0x736F0
			DATA_RECORD_UWORD
			524.28
			F_0v008_p0_172
			0
			524.28
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_gear_cge_n_thd
			"Cxx_gear_cge_n_thd"
			VALUE
			0x736F2
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_gear_cge_tq_max_ofs
			"Cxx_gear_cge_tq_max_ofs"
			VALUE
			0x71CB2
			DATA_RECORD_UBYTE
			127.5
			F_0v5_p0_28
			0
			127.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_gear_cge_vs_dly
			"Cxx_gear_cge_vs_dly"
			VALUE
			0x736F4
			DATA_RECORD_UWORD
			1048560
			F_16_p0_10
			0
			1048560
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_gear_ctr
			"Cxx_gear_ctr"
			VALUE
			0x736E6
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_gear_iga_dec
			"Cxx_gear_iga_dec"
			VALUE
			0x71CB3
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_gear_mem_vs_thd
			"Cxx_gear_mem_vs_thd"
			VALUE
			0x78A8F
			DATA_RECORD_UBYTE
			255
			F_1_p0_58
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_gear_val_fac
			"Cxx_gear_val_fac"
			VALUE
			0x78A90
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_gear_val_fil_fac1
			"Cxx_gear_val_fil_fac1"
			VALUE
			0x78A92
			DATA_RECORD_UWORD
			999.998565
			F_0v015259_p0_191
			0
			999.998565
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_gear_val_fil_fac2
			"Cxx_gear_val_fil_fac2"
			VALUE
			0x78A94
			DATA_RECORD_UWORD
			999.998565
			F_0v015259_p0_191
			0
			999.998565
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_gear_val_fil_fac3
			"Cxx_gear_val_fil_fac3"
			VALUE
			0x78A96
			DATA_RECORD_UWORD
			999.998565
			F_0v015259_p0_191
			0
			999.998565
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_gear_val_mux_fac
			"Cxx_gear_val_mux_fac"
			VALUE
			0x78A91
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_gear_vs_thd
			"Cxx_gear_vs_thd"
			VALUE
			0x736E7
			DATA_RECORD_UBYTE
			255
			F_1_p0_58
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_h_ad_is_alt_pow
			"Cxx_h_ad_is_alt_pow"
			VALUE
			0x73BFE
			DATA_RECORD_UWORD
			1310700
			F_20_p0_63
			0
			1310700
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_h_alt_crt_nok
			"Cxx_h_alt_crt_nok"
			VALUE
			0x70DE7
			DATA_RECORD_UBYTE
			12.036
			F_0v0472_p0_154
			0
			12.036
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_h_alt_ind
			"Cxx_h_alt_ind"
			VALUE
			0x70DE9
			DATA_RECORD_UBYTE
			747.0703125
			F_2v9296875_p0_192
			0
			747.0703125
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_h_alt_r_mv
			"Cxx_h_alt_r_mv"
			VALUE
			0x70DEB
			DATA_RECORD_UBYTE
			7.96875
			F_0v03125_p0_193
			0
			7.96875
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_h_alt_temp_fac
			"Cxx_h_alt_temp_fac"
			VALUE
			0x70DED
			DATA_RECORD_UBYTE
			31.12792969
			F_0v1220703125_p0_194
			0
			31.12792969
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_h_alt_temp_max_grd
			"Cxx_h_alt_temp_max_grd"
			VALUE
			0x70DEF
			DATA_RECORD_UBYTE
			155.6396484
			F_0v6103515625_p0_195
			0
			155.6396484
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_h_alt_temp_min_v
			"Cxx_h_alt_temp_min_v"
			VALUE
			0x70DFE
			DATA_RECORD_UWORD
			1545.576391
			F_0v023583984_p0_196
			0
			1545.576391
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_h_alt_temp_mv
			"Cxx_h_alt_temp_mv"
			VALUE
			0x70E02
			DATA_RECORD_UWORD
			40959.375
			F_0v625_p0_143
			0
			40959.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_h_alt_temp_ref
			"Cxx_h_alt_temp_ref"
			VALUE
			0x70E06
			DATA_RECORD_UWORD
			40959.375
			F_0v625_p0_143
			0
			40959.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_h_alt_v_ref
			"Cxx_h_alt_v_ref"
			VALUE
			0x70E0A
			DATA_RECORD_UWORD
			1545.576391
			F_0v023583984_p0_196
			0
			1545.576391
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_h_alt_v_temp_fac
			"Cxx_h_alt_v_temp_fac"
			VALUE
			0x70DF1
			DATA_RECORD_UBYTE
			510
			F_2_p0_197
			0
			510
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_h_alt_vb_ofs
			"Cxx_h_alt_vb_ofs"
			VALUE
			0x70DF3
			DATA_RECORD_UBYTE
			6.01391592
			F_0v023583984_p0_196
			0
			6.01391592
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_h_cge_n_dly
			"Cxx_h_cge_n_dly"
			VALUE
			0x736F6
			DATA_RECORD_UWORD
			524.28
			F_0v008_p0_172
			0
			524.28
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_h_cge_n_thd
			"Cxx_h_cge_n_thd"
			VALUE
			0x736F8
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_h_dif_prs_dsb_sp
			"Cxx_h_dif_prs_dsb_sp"
			VALUE
			0x784A0
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p0_21
			0
			242479.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_h_dly_ocl_tco_thd
			"Cxx_h_dly_ocl_tco_thd"
			VALUE
			0x76F66
			DATA_RECORD_UWORD
			40959.375
			F_0v625_m40_25
			-40
			40919.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_h_dyn_efy_cor
			"Cxx_h_dyn_efy_cor"
			VALUE
			0x74860
			DATA_RECORD_UWORD
			15.99975586
			F_0v0002441406_p0_182
			0
			15.99975586
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_h_pdl_psn_ofs
			"Cxx_h_pdl_psn_ofs"
			VALUE
			0x784C2
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_h_prs_ac_dsb_dly
			"Cxx_h_prs_ac_dsb_dly"
			VALUE
			0x72150
			DATA_RECORD_UBYTE
			261.12
			F_1v024_p0_119
			0
			261.12
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_h_prs_ac_dsb_prs_hys
			"Cxx_h_prs_ac_dsb_prs_hys"
			VALUE
			0x7218E
			DATA_RECORD_UWORD
			6553.5
			F_0v1_p0_141
			0
			6553.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_h_prs_ac_dsb_prs_thd
			"Cxx_h_prs_ac_dsb_prs_thd"
			VALUE
			0x72190
			DATA_RECORD_UWORD
			6553.5
			F_0v1_p0_141
			0
			6553.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_h_thd_dif_prs_dsb_sp
			"Cxx_h_thd_dif_prs_dsb_sp"
			VALUE
			0x784A2
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p0_21
			0
			242479.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_h_thd_n_vs_test
			"Cxx_h_thd_n_vs_test"
			VALUE
			0x79028
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_h_thd_prs_h_fail
			"Cxx_h_thd_prs_h_fail"
			VALUE
			0x78740
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_h_thd_prs_sp_fail
			"Cxx_h_thd_prs_sp_fail"
			VALUE
			0x784A4
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_h_tq_req
			"Cxx_h_tq_req"
			VALUE
			0x79501
			DATA_RECORD_UBYTE
			510
			F_2_p0_198
			0
			510
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_h_trt_limit_sp
			"Cxx_h_trt_limit_sp"
			VALUE
			0x73386
			DATA_RECORD_UWORD
			3199.951172
			F_0v048828125_p0_199
			0
			3199.951172
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_h_trt_rate_lim_thd
			"Cxx_h_trt_rate_lim_thd"
			VALUE
			0x73388
			DATA_RECORD_UWORD
			3199.951172
			F_0v048828125_p0_199
			0
			3199.951172
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_h_vvtc_fil_fac
			"Cxx_h_vvtc_fil_fac"
			VALUE
			0x7B0CB
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_hot_sta_iga_tco_thd
			"Cxx_hot_sta_iga_tco_thd"
			VALUE
			0x71CB6
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_hot_vb_thd
			"Cxx_hot_vb_thd"
			VALUE
			0x735DD
			DATA_RECORD_UBYTE
			7.96875
			F_0v03125_p8_183
			8
			15.96875
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_hw_nr1
			"Cxx_hw_nr1"
			VALUE
			0x7320D
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_hw_nr2
			"Cxx_hw_nr2"
			VALUE
			0x7320E
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_hw_nr3
			"Cxx_hw_nr3"
			VALUE
			0x7320F
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_hw_nr4
			"Cxx_hw_nr4"
			VALUE
			0x73210
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_hw_nr5
			"Cxx_hw_nr5"
			VALUE
			0x73211
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_i_agb_driv_tq_thd
			"Cxx_i_agb_driv_tq_thd"
			VALUE
			0x720B8
			DATA_RECORD_UWORD
			131070
			F_2_p0_198
			0
			131070
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_iga_bch_mod
			"Cxx_iga_bch_mod"
			VALUE
			0x747E8
			DATA_RECORD_UBYTE
			95.625
			F_0v375_m23v625_6
			-23.625
			72
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_iga_dec_tdc_nr
			"Cxx_iga_dec_tdc_nr"
			VALUE
			0x71CB7
			DATA_RECORD_UBYTE
			255
			F_1_p0_53
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_iga_is_deci_in_dly
			"Cxx_iga_is_deci_in_dly"
			VALUE
			0x71DD0
			DATA_RECORD_UWORD
			2097120
			F_32_p0_122
			0
			2097120
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_iga_is_deci_in_n_thd
			"Cxx_iga_is_deci_in_n_thd"
			VALUE
			0x71CB8
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_iga_ofs_cyl
			"Cxx_iga_ofs_cyl"
			VALUE
			0x747E9
			DATA_RECORD_UBYTE
			95.625
			F_0v375_m23v625_6
			-23.625
			72
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_iga_ofs_cyl1
			"Cxx_iga_ofs_cyl1"
			VALUE
			0x747EA
			DATA_RECORD_UBYTE
			95.625
			F_0v375_m23v625_6
			-23.625
			72
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_iga_ofs_cyl2
			"Cxx_iga_ofs_cyl2"
			VALUE
			0x747EB
			DATA_RECORD_UBYTE
			95.625
			F_0v375_m23v625_6
			-23.625
			72
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_iga_ofs_cyl3
			"Cxx_iga_ofs_cyl3"
			VALUE
			0x747EC
			DATA_RECORD_UBYTE
			95.625
			F_0v375_m23v625_6
			-23.625
			72
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_iga_ofs_cyl4
			"Cxx_iga_ofs_cyl4"
			VALUE
			0x747ED
			DATA_RECORD_UBYTE
			95.625
			F_0v375_m23v625_6
			-23.625
			72
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_iga_vvt_req_off_tdc
			"Cxx_iga_vvt_req_off_tdc"
			VALUE
			0x71CB9
			DATA_RECORD_UBYTE
			255
			F_1_p0_53
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_iga_vvt_req_on_tdc
			"Cxx_iga_vvt_req_on_tdc"
			VALUE
			0x71CBA
			DATA_RECORD_UBYTE
			255
			F_1_p0_53
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_igk_stal_eng_n_thd
			"Cxx_igk_stal_eng_n_thd"
			VALUE
			0x736FD
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_in_hot_temp_hys
			"Cxx_in_hot_temp_hys"
			VALUE
			0x735DE
			DATA_RECORD_UBYTE
			159.375
			F_0v625_p0_143
			0
			159.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_in_hot_temp_thd
			"Cxx_in_hot_temp_thd"
			VALUE
			0x735DF
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_in_run_stal_step
			"Cxx_in_run_stal_step"
			VALUE
			0x70CD0
			DATA_RECORD_UBYTE
			255
			F_1_p0_165
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_in_vol_rat
			"Cxx_in_vol_rat"
			VALUE
			0x78724
			DATA_RECORD_UWORD
			500032.05
			F_7v63_p0_200
			0
			500032.05
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_inc_knk_fil_fac
			"Cxx_inc_knk_fil_fac"
			VALUE
			0x72578
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_inj_clos_angl_bch
			"Cxx_inj_clos_angl_bch"
			VALUE
			0x758E3
			DATA_RECORD_UBYTE
			765
			F_3_p0_111
			0
			765
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_inj_csm
			"Cxx_inj_csm"
			VALUE
			0x73192
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_inj_dly
			"Cxx_inj_dly"
			VALUE
			0x76F68
			DATA_RECORD_UWORD
			262.14
			F_0v004_p0_201
			0
			262.14
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_inj_stop_n_ofs
			"Cxx_inj_stop_n_ofs"
			VALUE
			0x76F6A
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_inj_stop_tco_thd
			"Cxx_inj_stop_tco_thd"
			VALUE
			0x78BA3
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_inj_vvt_req_off_tdc
			"Cxx_inj_vvt_req_off_tdc"
			VALUE
			0x71CBB
			DATA_RECORD_UBYTE
			255
			F_1_p0_53
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_inj_vvt_req_on_tdc
			"Cxx_inj_vvt_req_on_tdc"
			VALUE
			0x71CBC
			DATA_RECORD_UBYTE
			255
			F_1_p0_53
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_inv_dsb
			"Cxx_inv_dsb"
			VALUE
			0x7363C
			DATA_RECORD_UWORD
			2867.8116
			F_0v04376_p0_180
			0
			2867.8116
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_inv_ini_acq_dif
			"Cxx_inv_ini_acq_dif"
			VALUE
			0x73624
			DATA_RECORD_UBYTE
			557.94
			F_2v188_p0_202
			0
			557.94
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_ip_abst_nr_fail
			"Cxx_ip_abst_nr_fail"
			VALUE
			0x71EDD
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_is_acel_ac_dsb_dly
			"Cxx_is_acel_ac_dsb_dly"
			VALUE
			0x72151
			DATA_RECORD_UBYTE
			32640
			F_128_p0_125
			0
			32640
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_is_aj_clc_n_drv_fac
			"Cxx_is_aj_clc_n_drv_fac"
			VALUE
			0x73A9D
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_is_aj_clc_step
			"Cxx_is_aj_clc_step"
			VALUE
			0x73A9E
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_is_aj_n_drv_h_hys
			"Cxx_is_aj_n_drv_h_hys"
			VALUE
			0x73868
			DATA_RECORD_SBYTE
			4845
			F_19_p0_203
			-2432
			2413
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_is_aj_n_drv_l_hys
			"Cxx_is_aj_n_drv_l_hys"
			VALUE
			0x73869
			DATA_RECORD_SBYTE
			4845
			F_19_p0_203
			-2432
			2413
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_is_cdn_h_sta_n_dly
			"Cxx_is_cdn_h_sta_n_dly"
			VALUE
			0x73A9F
			DATA_RECORD_UBYTE
			8160
			F_32_p0_122
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_is_d_cor_min
			"Cxx_is_d_cor_min"
			VALUE
			0x73ADA
			DATA_RECORD_SWORD
			65535
			Id_0x00
			-32768
			32767
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_is_d_dsb_n_drv_thd
			"Cxx_is_d_dsb_n_drv_thd"
			VALUE
			0x73AA0
			DATA_RECORD_UBYTE
			4845
			F_19_p0_203
			0
			4845
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_is_dclu_acc
			"Cxx_is_dclu_acc"
			VALUE
			0x72152
			DATA_RECORD_UBYTE
			4080
			F_16_p0_10
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_is_deci_in_dly
			"Cxx_is_deci_in_dly"
			VALUE
			0x73C00
			DATA_RECORD_UWORD
			2097120
			F_32_p0_122
			0
			2097120
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_is_deci_in_n_thd
			"Cxx_is_deci_in_n_thd"
			VALUE
			0x73AA1
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_is_dstb_ti_ofs_cor
			"Cxx_is_dstb_ti_ofs_cor"
			VALUE
			0x75954
			DATA_RECORD_SWORD
			65535
			Id_0x00
			-32768
			32767
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_is_dstb_ti_ofs_cor1
			"Cxx_is_dstb_ti_ofs_cor1"
			VALUE
			0x75956
			DATA_RECORD_SWORD
			65535
			F_1_p0_9
			-32768
			32767
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_is_dyn_iga_fil_fac
			"Cxx_is_dyn_iga_fil_fac"
			VALUE
			0x71CBD
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_is_dyn_iga_n_ofs
			"Cxx_is_dyn_iga_n_ofs"
			VALUE
			0x71DD2
			DATA_RECORD_UWORD
			2097120
			F_32_p0_46
			0
			2097120
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_is_hot_tco_thd
			"Cxx_is_hot_tco_thd"
			VALUE
			0x758E4
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_is_hot_ti_cl_dly
			"Cxx_is_hot_ti_cl_dly"
			VALUE
			0x758E5
			DATA_RECORD_UBYTE
			1044.48
			F_4v096_p0_12
			0
			1044.48
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_is_i_fac1
			"Cxx_is_i_fac1"
			VALUE
			0x73AA2
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_is_i_fac2
			"Cxx_is_i_fac2"
			VALUE
			0x73AA3
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_is_i_fac3
			"Cxx_is_i_fac3"
			VALUE
			0x73AA4
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_is_i_fil_fac1
			"Cxx_is_i_fil_fac1"
			VALUE
			0x72153
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_is_i_fil_fac2
			"Cxx_is_i_fil_fac2"
			VALUE
			0x72154
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_is_i_n_drv_thd
			"Cxx_is_i_n_drv_thd"
			VALUE
			0x73AA5
			DATA_RECORD_UBYTE
			4845
			F_19_p0_203
			0
			4845
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_is_i_sp_fil_fac
			"Cxx_is_i_sp_fil_fac"
			VALUE
			0x72155
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_is_i_zon_out_dly
			"Cxx_is_i_zon_out_dly"
			VALUE
			0x73C02
			DATA_RECORD_UWORD
			2097120
			F_32_p0_122
			0
			2097120
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_is_iga_cor_fil_step
			"Cxx_is_iga_cor_fil_step"
			VALUE
			0x71CBE
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_is_iga_prop_sp_fac
			"Cxx_is_iga_prop_sp_fac"
			VALUE
			0x71CBF
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_is_iga_sp_max_ofs
			"Cxx_is_iga_sp_max_ofs"
			VALUE
			0x71CC0
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_is_in_cdn_ofs
			"Cxx_is_in_cdn_ofs"
			VALUE
			0x73AA6
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_is_in_cdn_ofs2
			"Cxx_is_in_cdn_ofs2"
			VALUE
			0x73AA7
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_is_in_dly
			"Cxx_is_in_dly"
			VALUE
			0x73AA8
			DATA_RECORD_UBYTE
			8160
			F_32_p0_122
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_is_in_ofs_sta_stt
			"Cxx_is_in_ofs_sta_stt"
			VALUE
			0x7386A
			DATA_RECORD_SBYTE
			8160
			F_32_p0_46
			-4096
			4064
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_is_in_pump_thd
			"Cxx_is_in_pump_thd"
			VALUE
			0x73AA9
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_is_min_ad_pwm_ini
			"Cxx_is_min_ad_pwm_ini"
			VALUE
			0x73222
			DATA_RECORD_SWORD
			65535
			Id_0x00
			-32768
			32767
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_is_n_sp_max
			"Cxx_is_n_sp_max"
			VALUE
			0x78BA4
			DATA_RECORD_UBYTE
			4080
			F_16_p0_83
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_is_n_stab_clc_fac
			"Cxx_is_n_stab_clc_fac"
			VALUE
			0x73AAA
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_is_ocl_tco_thd
			"Cxx_is_ocl_tco_thd"
			VALUE
			0x758E6
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_is_out_n_ofs
			"Cxx_is_out_n_ofs"
			VALUE
			0x73AAB
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_is_out_n_ofs2
			"Cxx_is_out_n_ofs2"
			VALUE
			0x73AAD
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_is_out_n_ofs_sta
			"Cxx_is_out_n_ofs_sta"
			VALUE
			0x73AAC
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_is_out_pump_thd
			"Cxx_is_out_pump_thd"
			VALUE
			0x73AAE
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_is_p_clc_fac1
			"Cxx_is_p_clc_fac1"
			VALUE
			0x73AAF
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_is_p_clc_fac2
			"Cxx_is_p_clc_fac2"
			VALUE
			0x73AB0
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_is_p_clc_fac3
			"Cxx_is_p_clc_fac3"
			VALUE
			0x73AB1
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_is_p_clc_fac4
			"Cxx_is_p_clc_fac4"
			VALUE
			0x73AB2
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_is_p_dsb_n_hys
			"Cxx_is_p_dsb_n_hys"
			VALUE
			0x73AB3
			DATA_RECORD_UBYTE
			255
			F_1_p0_14
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_is_p_max
			"Cxx_is_p_max"
			VALUE
			0x73ADC
			DATA_RECORD_SWORD
			65535
			Id_0x00
			-32768
			32767
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_is_p_min
			"Cxx_is_p_min"
			VALUE
			0x73ADE
			DATA_RECORD_SWORD
			65535
			Id_0x00
			-32768
			32767
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_is_stab_n_drv_thd
			"Cxx_is_stab_n_drv_thd"
			VALUE
			0x73AB4
			DATA_RECORD_UBYTE
			4845
			F_19_p0_203
			0
			4845
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_is_ti_i_cor
			"Cxx_is_ti_i_cor"
			VALUE
			0x758E7
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_is_ti_i_cor_lean
			"Cxx_is_ti_i_cor_lean"
			VALUE
			0x758E8
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_is_ti_i_cor_lpg
			"Cxx_is_ti_i_cor_lpg"
			VALUE
			0x758E9
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_is_ti_p_cor
			"Cxx_is_ti_p_cor"
			VALUE
			0x758EA
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_is_ti_p_cor_lean1
			"Cxx_is_ti_p_cor_lean1"
			VALUE
			0x758EB
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_is_ti_p_cor_lean2
			"Cxx_is_ti_p_cor_lean2"
			VALUE
			0x758EC
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_is_ti_p_cor_lpg
			"Cxx_is_ti_p_cor_lpg"
			VALUE
			0x758ED
			DATA_RECORD_UBYTE
			255
			F_1_p0_9
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_kd_decl_cut_n_ofs
			"Cxx_kd_decl_cut_n_ofs"
			VALUE
			0x758EE
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_kd_rel_pdl_hys
			"Cxx_kd_rel_pdl_hys"
			VALUE
			0x784C3
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_kd_thr_hys
			"Cxx_kd_thr_hys"
			VALUE
			0x784C4
			DATA_RECORD_UBYTE
			255
			F_1_p0_9
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_kd_thr_thd
			"Cxx_kd_thr_thd"
			VALUE
			0x784C5
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_knk_1cyl_slow_cor_max
			"Cxx_knk_1cyl_slow_cor_max"
			VALUE
			0x71CC1
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_knk_2cyl_slow_dif_max
			"Cxx_knk_2cyl_slow_dif_max"
			VALUE
			0x71CC2
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_knk_det_n_thd
			"Cxx_knk_det_n_thd"
			VALUE
			0x72579
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_knk_det_prs_thd
			"Cxx_knk_det_prs_thd"
			VALUE
			0x7264E
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_knk_det_tco_thd
			"Cxx_knk_det_tco_thd"
			VALUE
			0x7257A
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_knk_fail_nr
			"Cxx_knk_fail_nr"
			VALUE
			0x7257B
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_knk_fast_cor_dec_ctr
			"Cxx_knk_fast_cor_dec_ctr"
			VALUE
			0x71CC3
			DATA_RECORD_UBYTE
			4080
			F_16_p0_10
			0
			4080
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_knk_fast_cor_iga_max
			"Cxx_knk_fast_cor_iga_max"
			VALUE
			0x71CC4
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_knk_fast_cor_iga_thd
			"Cxx_knk_fast_cor_iga_thd"
			VALUE
			0x71CC5
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_knk_fil_fac
			"Cxx_knk_fil_fac"
			VALUE
			0x7257C
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_knk_fil_inc
			"Cxx_knk_fil_inc"
			VALUE
			0x72650
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_knk_fmt_fil_fac
			"Cxx_knk_fmt_fil_fac"
			VALUE
			0x7257D
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_knk_fmt_fil_max
			"Cxx_knk_fmt_fil_max"
			VALUE
			0x725BC
			DATA_RECORD_SWORD
			65535
			Id_0x00
			-32768
			32767
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_knk_fmt_fil_min
			"Cxx_knk_fmt_fil_min"
			VALUE
			0x725BE
			DATA_RECORD_SWORD
			65535
			Id_0x00
			-32768
			32767
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_knk_iga_cor
			"Cxx_knk_iga_cor"
			VALUE
			0x71CC6
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_knk_iga_cor_fil_fac
			"Cxx_knk_iga_cor_fil_fac"
			VALUE
			0x79502
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_knk_noi_lvl
			"Cxx_knk_noi_lvl"
			VALUE
			0x7257E
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_knk_slow_cor_dec_ctr
			"Cxx_knk_slow_cor_dec_ctr"
			VALUE
			0x71CC7
			DATA_RECORD_UBYTE
			255
			F_1_p0_54
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_knk_slow_cor_iga_inc
			"Cxx_knk_slow_cor_iga_inc"
			VALUE
			0x71CC8
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_knk_slow_cor_iga_max
			"Cxx_knk_slow_cor_iga_max"
			VALUE
			0x71CC9
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_knk_slow_cor_prs_dif
			"Cxx_knk_slow_cor_prs_dif"
			VALUE
			0x71DD4
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p0_21
			0
			242479.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_knk_slow_fil_mv_hys
			"Cxx_knk_slow_fil_mv_hys"
			VALUE
			0x79503
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_knk_slow_fil_mv_iga
			"Cxx_knk_slow_fil_mv_iga"
			VALUE
			0x79504
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_29
			0
			95.625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_knk_slow_iga_efy
			"Cxx_knk_slow_iga_efy"
			VALUE
			0x7AC06
			DATA_RECORD_UWORD
			10018.92527
			F_0v152879_p0_204
			0
			10018.92527
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_knk_slow_iga_efy_hys
			"Cxx_knk_slow_iga_efy_hys"
			VALUE
			0x7AC08
			DATA_RECORD_UWORD
			9999.848026
			F_0v1525879_p0_205
			0
			9999.848026
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_knk_tq_cor_dec_dly
			"Cxx_knk_tq_cor_dec_dly"
			VALUE
			0x79505
			DATA_RECORD_UBYTE
			32.64
			F_0v128_p0_75
			0
			32.64
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_knk_tq_cor_dec_fac
			"Cxx_knk_tq_cor_dec_fac"
			VALUE
			0x79506
			DATA_RECORD_UBYTE
			25.5
			F_0v1_p0_206
			0
			25.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_knk_tq_cor_dec_ofs
			"Cxx_knk_tq_cor_dec_ofs"
			VALUE
			0x79507
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_knk_tq_cor_inc_dly
			"Cxx_knk_tq_cor_inc_dly"
			VALUE
			0x79508
			DATA_RECORD_UBYTE
			32.64
			F_0v128_p0_75
			0
			32.64
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_knk_tq_cor_inc_fac
			"Cxx_knk_tq_cor_inc_fac"
			VALUE
			0x79509
			DATA_RECORD_UBYTE
			25.5
			F_0v1_p0_206
			0
			25.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_knk_tq_cor_inc_ofs
			"Cxx_knk_tq_cor_inc_ofs"
			VALUE
			0x7950A
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_knk_zon_tco_thd
			"Cxx_knk_zon_tco_thd"
			VALUE
			0x7257F
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_l_ad_is_alt_pow
			"Cxx_l_ad_is_alt_pow"
			VALUE
			0x73C04
			DATA_RECORD_UWORD
			1310700
			F_20_p0_63
			0
			1310700
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_l_alt_crt_nok
			"Cxx_l_alt_crt_nok"
			VALUE
			0x70DE6
			DATA_RECORD_UBYTE
			12.036
			F_0v0472_p0_154
			0
			12.036
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_l_alt_ind
			"Cxx_l_alt_ind"
			VALUE
			0x70DE8
			DATA_RECORD_UBYTE
			747.0703125
			F_2v9296875_p0_192
			0
			747.0703125
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_l_alt_r_mv
			"Cxx_l_alt_r_mv"
			VALUE
			0x70DEA
			DATA_RECORD_UBYTE
			7.96875
			F_0v03125_p0_193
			0
			7.96875
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_l_alt_temp_fac
			"Cxx_l_alt_temp_fac"
			VALUE
			0x70DEC
			DATA_RECORD_UBYTE
			31.12792969
			F_0v1220703125_p0_194
			0
			31.12792969
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_l_alt_temp_max_grd
			"Cxx_l_alt_temp_max_grd"
			VALUE
			0x70DEE
			DATA_RECORD_UBYTE
			155.6396484
			F_0v6103515625_p0_195
			0
			155.6396484
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_l_alt_temp_min_v
			"Cxx_l_alt_temp_min_v"
			VALUE
			0x70DFC
			DATA_RECORD_UWORD
			1545.576391
			F_0v023583984_p0_196
			0
			1545.576391
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_l_alt_temp_mv
			"Cxx_l_alt_temp_mv"
			VALUE
			0x70E00
			DATA_RECORD_UWORD
			40959.375
			F_0v625_p0_143
			0
			40959.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_l_alt_temp_ref
			"Cxx_l_alt_temp_ref"
			VALUE
			0x70E04
			DATA_RECORD_UWORD
			40959.375
			F_0v625_p0_143
			0
			40959.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_l_alt_v_ref
			"Cxx_l_alt_v_ref"
			VALUE
			0x70E08
			DATA_RECORD_UWORD
			1545.576391
			F_0v023583984_p0_196
			0
			1545.576391
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_l_alt_v_temp_fac
			"Cxx_l_alt_v_temp_fac"
			VALUE
			0x70DF0
			DATA_RECORD_UBYTE
			510
			F_2_p0_197
			0
			510
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_l_alt_vb_ofs
			"Cxx_l_alt_vb_ofs"
			VALUE
			0x70DF2
			DATA_RECORD_UBYTE
			6.01391592
			F_0v023583984_p0_196
			0
			6.01391592
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_l_dyn_efy_cor
			"Cxx_l_dyn_efy_cor"
			VALUE
			0x74862
			DATA_RECORD_UWORD
			15.99975586
			F_0v0002441406_p0_182
			0
			15.99975586
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_l_is_pwm
			"Cxx_l_is_pwm"
			VALUE
			0x73C06
			DATA_RECORD_UWORD
			99.9998565
			F_0v0015259_p0_92
			0
			99.9998565
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_l_min_iga_ctr_dec
			"Cxx_l_min_iga_ctr_dec"
			VALUE
			0x747EE
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_l_min_iga_ctr_inc
			"Cxx_l_min_iga_ctr_inc"
			VALUE
			0x747EF
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_l_min_iga_ctr_thd
			"Cxx_l_min_iga_ctr_thd"
			VALUE
			0x747F0
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_l_min_iga_inc
			"Cxx_l_min_iga_inc"
			VALUE
			0x747F1
			DATA_RECORD_UBYTE
			95.625
			F_0v375_p0_33
			0
			95.625
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_l_pdl_psn_ofs
			"Cxx_l_pdl_psn_ofs"
			VALUE
			0x784C6
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_l_prs_ac_dsb_prs_hys
			"Cxx_l_prs_ac_dsb_prs_hys"
			VALUE
			0x72192
			DATA_RECORD_UWORD
			6553.5
			F_0v1_p0_141
			0
			6553.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_l_prs_ac_dsb_prs_thd
			"Cxx_l_prs_ac_dsb_prs_thd"
			VALUE
			0x72194
			DATA_RECORD_UWORD
			6553.5
			F_0v1_p0_141
			0
			6553.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_l_tco_inj_stop_n
			"Cxx_l_tco_inj_stop_n"
			VALUE
			0x78D4A
			DATA_RECORD_UWORD
			65535
			F_1_p0_14
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_l_thd_dif_prs_dsb_sp
			"Cxx_l_thd_dif_prs_dsb_sp"
			VALUE
			0x784A6
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p0_21
			0
			242479.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_l_thd_n_vs_test
			"Cxx_l_thd_n_vs_test"
			VALUE
			0x79029
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_l_thd_prs_l_fail
			"Cxx_l_thd_prs_l_fail"
			VALUE
			0x78742
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_l_ti_slop_thd
			"Cxx_l_ti_slop_thd"
			VALUE
			0x758EF
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_l_ti_slop_thd_lean1
			"Cxx_l_ti_slop_thd_lean1"
			VALUE
			0x758F0
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_l_ti_slop_thd_lean2
			"Cxx_l_ti_slop_thd_lean2"
			VALUE
			0x758F1
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_l_ti_slop_thd_lpg
			"Cxx_l_ti_slop_thd_lpg"
			VALUE
			0x758F2
			DATA_RECORD_UBYTE
			255
			F_1_p0_9
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_l_tq_req
			"Cxx_l_tq_req"
			VALUE
			0x7950B
			DATA_RECORD_UBYTE
			510
			F_2_p0_198
			0
			510
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_l_trt_limit_sp
			"Cxx_l_trt_limit_sp"
			VALUE
			0x7338A
			DATA_RECORD_UWORD
			3199.951172
			F_0v048828125_p0_199
			0
			3199.951172
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_l_trt_rate_lim_thd
			"Cxx_l_trt_rate_lim_thd"
			VALUE
			0x7338C
			DATA_RECORD_UWORD
			3199.951172
			F_0v048828125_p0_199
			0
			3199.951172
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_l_v_lamb_thd
			"Cxx_l_v_lamb_thd"
			VALUE
			0x758F3
			DATA_RECORD_UBYTE
			2488.8
			F_9v76_p0_45
			0
			2488.8
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_l_vvtc_fil_fac
			"Cxx_l_vvtc_fil_fac"
			VALUE
			0x7B0CC
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lamb_swi_ctr_ini
			"Cxx_lamb_swi_ctr_ini"
			VALUE
			0x758F4
			DATA_RECORD_UBYTE
			255
			F_1_p0_148
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lamb_swi_ctr_ini_lpg
			"Cxx_lamb_swi_ctr_ini_lpg"
			VALUE
			0x758F5
			DATA_RECORD_UBYTE
			255
			F_1_p0_148
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_last_bkp_prs_rat
			"Cxx_last_bkp_prs_rat"
			VALUE
			0x78726
			DATA_RECORD_UWORD
			1999969.482
			F_30v517578125_p0_67
			0
			1999969.482
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbdw_cata_fil_fac
			"Cxx_lbdw_cata_fil_fac"
			VALUE
			0x77703
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbdw_fil_fac
			"Cxx_lbdw_fil_fac"
			VALUE
			0x758F6
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbdw_h_lvl_fil_fac
			"Cxx_lbdw_h_lvl_fil_fac"
			VALUE
			0x77704
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbdw_hot_cmd_dly1
			"Cxx_lbdw_hot_cmd_dly1"
			VALUE
			0x7841E
			DATA_RECORD_UWORD
			262140
			F_4_p0_128
			0
			262140
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbdw_hot_cmd_dly2
			"Cxx_lbdw_hot_cmd_dly2"
			VALUE
			0x78420
			DATA_RECORD_UWORD
			262140
			F_4_p0_128
			0
			262140
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbdw_hot_cmd_map_hys
			"Cxx_lbdw_hot_cmd_map_hys"
			VALUE
			0x78422
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p0_21
			0
			242479.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbdw_hot_cmd_vs_hys
			"Cxx_lbdw_hot_cmd_vs_hys"
			VALUE
			0x78396
			DATA_RECORD_UBYTE
			255
			F_1_p0_58
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbdw_hot_dsb_vs
			"Cxx_lbdw_hot_dsb_vs"
			VALUE
			0x78397
			DATA_RECORD_UBYTE
			255
			F_1_p0_58
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbdw_hot_pwm1_dly1
			"Cxx_lbdw_hot_pwm1_dly1"
			VALUE
			0x7839B
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbdw_hot_pwm1_dly2
			"Cxx_lbdw_hot_pwm1_dly2"
			VALUE
			0x7839C
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbdw_hot_pwm_dly_inc
			"Cxx_lbdw_hot_pwm_dly_inc"
			VALUE
			0x78398
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbdw_hot_pwm_per1
			"Cxx_lbdw_hot_pwm_per1"
			VALUE
			0x78399
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbdw_hot_pwm_per2
			"Cxx_lbdw_hot_pwm_per2"
			VALUE
			0x7839A
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbdw_hot_stt_t
			"Cxx_lbdw_hot_stt_t"
			VALUE
			0x7839D
			DATA_RECORD_UBYTE
			130.56
			F_0v512_p0_121
			0
			130.56
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbdw_no_oc_det_ctr
			"Cxx_lbdw_no_oc_det_ctr"
			VALUE
			0x7839E
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbdw_oc_air_wht
			"Cxx_lbdw_oc_air_wht"
			VALUE
			0x78424
			DATA_RECORD_UWORD
			65535
			Id_0x00
			0
			65535
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbdw_oc_h_v
			"Cxx_lbdw_oc_h_v"
			VALUE
			0x78426
			DATA_RECORD_UWORD
			639621.6
			F_9v76_p0_45
			0
			639621.6
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbdw_osp_oc_det_h_v
			"Cxx_lbdw_osp_oc_det_h_v"
			VALUE
			0x78428
			DATA_RECORD_UWORD
			639621.6
			F_9v76_p0_45
			0
			639621.6
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbdw_osp_oc_det_l_v
			"Cxx_lbdw_osp_oc_det_l_v"
			VALUE
			0x7842A
			DATA_RECORD_UWORD
			639621.6
			F_9v76_p0_45
			0
			639621.6
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbdw_osp_sc_vb_v
			"Cxx_lbdw_osp_sc_vb_v"
			VALUE
			0x7842C
			DATA_RECORD_UWORD
			639621.6
			F_9v76_p0_45
			0
			639621.6
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbdw_osp_scg_v
			"Cxx_lbdw_osp_scg_v"
			VALUE
			0x7842E
			DATA_RECORD_UWORD
			639621.6
			F_9v76_p0_45
			0
			639621.6
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbdw_pump_crt_dly
			"Cxx_lbdw_pump_crt_dly"
			VALUE
			0x7839F
			DATA_RECORD_UBYTE
			130.56
			F_0v512_p0_121
			0
			130.56
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbdw_pump_crt_t
			"Cxx_lbdw_pump_crt_t"
			VALUE
			0x783A0
			DATA_RECORD_UBYTE
			130.56
			F_0v512_p0_121
			0
			130.56
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbdw_pump_crt_v_thd
			"Cxx_lbdw_pump_crt_v_thd"
			VALUE
			0x78430
			DATA_RECORD_UWORD
			639621.6
			F_9v76_p0_45
			0
			639621.6
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbdw_sc_vb_v
			"Cxx_lbdw_sc_vb_v"
			VALUE
			0x78432
			DATA_RECORD_UWORD
			639621.6
			F_9v76_p0_45
			0
			639621.6
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbdw_scg_t
			"Cxx_lbdw_scg_t"
			VALUE
			0x783A1
			DATA_RECORD_UBYTE
			16320
			F_64_p0_145
			0
			16320
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbdw_scg_v
			"Cxx_lbdw_scg_v"
			VALUE
			0x78434
			DATA_RECORD_UWORD
			639621.6
			F_9v76_p0_45
			0
			639621.6
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbup_asd_diag_nr
			"Cxx_lbup_asd_diag_nr"
			VALUE
			0x77705
			DATA_RECORD_UBYTE
			255
			F_1_p0_9
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbup_asd_in_nr
			"Cxx_lbup_asd_in_nr"
			VALUE
			0x77706
			DATA_RECORD_UBYTE
			255
			F_1_p0_9
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbup_asd_n_max
			"Cxx_lbup_asd_n_max"
			VALUE
			0x77707
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbup_asd_n_min
			"Cxx_lbup_asd_n_min"
			VALUE
			0x77708
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbup_asd_per_dly
			"Cxx_lbup_asd_per_dly"
			VALUE
			0x78338
			DATA_RECORD_UWORD
			524280
			F_8_p0_56
			0
			524280
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbup_asd_prs_min
			"Cxx_lbup_asd_prs_min"
			VALUE
			0x7833A
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbup_asd_sf_nr
			"Cxx_lbup_asd_sf_nr"
			VALUE
			0x77709
			DATA_RECORD_UBYTE
			255
			F_1_p0_9
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbup_asd_tco_min
			"Cxx_lbup_asd_tco_min"
			VALUE
			0x7770A
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbup_cold_sta_rat
			"Cxx_lbup_cold_sta_rat"
			VALUE
			0x783A2
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbup_dft_pwm
			"Cxx_lbup_dft_pwm"
			VALUE
			0x783A3
			DATA_RECORD_UBYTE
			99.609375
			F_0v390625_p0_4
			0
			99.609375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbup_hot_cmd_dly1
			"Cxx_lbup_hot_cmd_dly1"
			VALUE
			0x78436
			DATA_RECORD_UWORD
			262140
			F_4_p0_128
			0
			262140
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbup_hot_cmd_dly2
			"Cxx_lbup_hot_cmd_dly2"
			VALUE
			0x78438
			DATA_RECORD_UWORD
			262140
			F_4_p0_128
			0
			262140
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbup_hot_cmd_map_hys
			"Cxx_lbup_hot_cmd_map_hys"
			VALUE
			0x7843A
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p0_21
			0
			242479.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbup_hot_cmd_vs_hys
			"Cxx_lbup_hot_cmd_vs_hys"
			VALUE
			0x783A4
			DATA_RECORD_UBYTE
			255
			F_1_p0_58
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbup_hot_dsb_vs
			"Cxx_lbup_hot_dsb_vs"
			VALUE
			0x783A5
			DATA_RECORD_UBYTE
			255
			F_1_p0_58
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbup_hot_pwm1_dly1
			"Cxx_lbup_hot_pwm1_dly1"
			VALUE
			0x783A9
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbup_hot_pwm1_dly2
			"Cxx_lbup_hot_pwm1_dly2"
			VALUE
			0x783AA
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbup_hot_pwm_dly_inc
			"Cxx_lbup_hot_pwm_dly_inc"
			VALUE
			0x783A6
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbup_hot_pwm_per1
			"Cxx_lbup_hot_pwm_per1"
			VALUE
			0x783A7
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbup_hot_pwm_per2
			"Cxx_lbup_hot_pwm_per2"
			VALUE
			0x783A8
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbup_hot_stt_t
			"Cxx_lbup_hot_stt_t"
			VALUE
			0x783AB
			DATA_RECORD_UBYTE
			130.56
			F_0v512_p0_121
			0
			130.56
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbup_hys_n
			"Cxx_lbup_hys_n"
			VALUE
			0x7770B
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbup_hys_prs
			"Cxx_lbup_hys_prs"
			VALUE
			0x7833C
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p0_21
			0
			242479.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbup_in_nr
			"Cxx_lbup_in_nr"
			VALUE
			0x7770C
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbup_maf_dif_max
			"Cxx_lbup_maf_dif_max"
			VALUE
			0x7770D
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbup_maf_mes_max
			"Cxx_lbup_maf_mes_max"
			VALUE
			0x7770E
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbup_max_vb_thd
			"Cxx_lbup_max_vb_thd"
			VALUE
			0x7843C
			DATA_RECORD_UWORD
			8.191875
			F_0v000125_p8_7
			8
			16.191875
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbup_min_vb_thd
			"Cxx_lbup_min_vb_thd"
			VALUE
			0x7843E
			DATA_RECORD_UWORD
			8.191875
			F_0v000125_p8_7
			8
			16.191875
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbup_n_max
			"Cxx_lbup_n_max"
			VALUE
			0x7770F
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbup_n_min
			"Cxx_lbup_n_min"
			VALUE
			0x77710
			DATA_RECORD_UBYTE
			8160
			F_32_p0_46
			0
			8160
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbup_no_oc_det_ctr
			"Cxx_lbup_no_oc_det_ctr"
			VALUE
			0x783AC
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbup_oc_det_h_v
			"Cxx_lbup_oc_det_h_v"
			VALUE
			0x78440
			DATA_RECORD_UWORD
			639621.6
			F_9v76_p0_45
			0
			639621.6
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbup_oc_det_l_v
			"Cxx_lbup_oc_det_l_v"
			VALUE
			0x78442
			DATA_RECORD_UWORD
			639621.6
			F_9v76_p0_45
			0
			639621.6
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbup_oc_t
			"Cxx_lbup_oc_t"
			VALUE
			0x783AD
			DATA_RECORD_UBYTE
			16320
			F_64_p0_145
			0
			16320
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbup_ofs_stab_dly
			"Cxx_lbup_ofs_stab_dly"
			VALUE
			0x77711
			DATA_RECORD_UBYTE
			130560
			F_512_p0_104
			0
			130560
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbup_osp_oc_det_h_v
			"Cxx_lbup_osp_oc_det_h_v"
			VALUE
			0x78444
			DATA_RECORD_UWORD
			639621.6
			F_9v76_p0_45
			0
			639621.6
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbup_osp_oc_det_l_v
			"Cxx_lbup_osp_oc_det_l_v"
			VALUE
			0x78446
			DATA_RECORD_UWORD
			639621.6
			F_9v76_p0_45
			0
			639621.6
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbup_osp_sc_vb_det_v
			"Cxx_lbup_osp_sc_vb_det_v"
			VALUE
			0x78448
			DATA_RECORD_UWORD
			639621.6
			F_9v76_p0_45
			0
			639621.6
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbup_osp_scg_det_v
			"Cxx_lbup_osp_scg_det_v"
			VALUE
			0x7844A
			DATA_RECORD_UWORD
			639621.6
			F_9v76_p0_45
			0
			639621.6
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbup_per_dly
			"Cxx_lbup_per_dly"
			VALUE
			0x7833E
			DATA_RECORD_UWORD
			524280
			F_8_p0_56
			0
			524280
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbup_per_nr_min
			"Cxx_lbup_per_nr_min"
			VALUE
			0x77712
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbup_per_nr_tot
			"Cxx_lbup_per_nr_tot"
			VALUE
			0x77713
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbup_per_swi_nr
			"Cxx_lbup_per_swi_nr"
			VALUE
			0x77714
			DATA_RECORD_UBYTE
			255
			Id_0x00
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbup_prs_max
			"Cxx_lbup_prs_max"
			VALUE
			0x78340
			DATA_RECORD_UWORD
			242479.5
			F_3v7_p103_37
			103
			242582.5
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbup_pump_crt_dly
			"Cxx_lbup_pump_crt_dly"
			VALUE
			0x783AE
			DATA_RECORD_UBYTE
			130.56
			F_0v512_p0_121
			0
			130.56
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbup_pump_crt_t
			"Cxx_lbup_pump_crt_t"
			VALUE
			0x783AF
			DATA_RECORD_UBYTE
			130.56
			F_0v512_p0_121
			0
			130.56
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbup_pump_crt_v_thd
			"Cxx_lbup_pump_crt_v_thd"
			VALUE
			0x7844C
			DATA_RECORD_UWORD
			639621.6
			F_9v76_p0_45
			0
			639621.6
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbup_rms_v
			"Cxx_lbup_rms_v"
			VALUE
			0x783B0
			DATA_RECORD_UBYTE
			255
			F_1_p0_207
			0
			255
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbup_sc_vb_det_v
			"Cxx_lbup_sc_vb_det_v"
			VALUE
			0x7844E
			DATA_RECORD_UWORD
			639621.6
			F_9v76_p0_45
			0
			639621.6
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbup_scg_det_v
			"Cxx_lbup_scg_det_v"
			VALUE
			0x78450
			DATA_RECORD_UWORD
			639621.6
			F_9v76_p0_45
			0
			639621.6
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbup_scg_t
			"Cxx_lbup_scg_t"
			VALUE
			0x783B1
			DATA_RECORD_UBYTE
			16320
			F_64_p0_145
			0
			16320
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbup_stab_dly
			"Cxx_lbup_stab_dly"
			VALUE
			0x77715
			DATA_RECORD_UBYTE
			130560
			F_512_p0_104
			0
			130560
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbup_tco_min
			"Cxx_lbup_tco_min"
			VALUE
			0x77716
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbup_tco_rest_thd
			"Cxx_lbup_tco_rest_thd"
			VALUE
			0x783B2
			DATA_RECORD_UBYTE
			159.375
			F_0v625_m40_25
			-40
			119.375
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lbup_v_thd
			"Cxx_lbup_v_thd"
			VALUE
			0x78452
			DATA_RECORD_UWORD
			639621.6
			F_9v76_p0_45
			0
			639621.6
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lean_rich_trs_dly
			"Cxx_lean_rich_trs_dly"
			VALUE
			0x783B3
			DATA_RECORD_UBYTE
			2040
			F_8_p0_56
			0
			2040
		/end CHARACTERISTIC
		/begin CHARACTERISTIC Cxx_lgl_dly_asd_diag_cata
			"Cxx_lgl_dly_asd_diag_cata"
			VALUE
			0x78342
			DATA_RECORD_UWORD
			33553920
